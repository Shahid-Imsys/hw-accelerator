*---------------------------------------------------------------------*
*               Copyright(c) Synopsys, Inc.                           *
*     All Rights reserved - Unpublished -rights reserved under        *
*     the Copyright laws of the United States of America.             *
*                                                                     *
*  U.S. Patents: 7,093,156 B1 and 7,406,620 B2 (and more pending).    *
*                                                                     *
*  This file includes the Confidential information of Synopsys, Inc.  *
*  and GLOBALFOUNDRIES.                                               *
*  The receiver of this Confidential Information shall not disclose   *
*  it to any third party and shall protect its confidentiality by     *
*  using the same degree of care, but not less than a reasonable      *
*  degree of care, as the receiver uses to protect receiver's own     *
*  Confidential Information.                                          *
*  Licensee acknowledges and agrees that all output generated for     *
*  Licensee by Synopsys, Inc. as described in the pertinent Program   *
*  Schedule(s), or generated by Licensee through use of any Compiler  *
*  licensed hereunder contains information that complies with the     *
*  Virtual Component Identification Physical Tagging Standard (VCID)  *
*  as maintained by the Virtual Socket Interface Alliance (VSIA).     *
*  Such information may be expressed in GDSII Layer 63 or other such  *
*  layer designated by the VSIA, hardware definition languages, or    *
*  other formats.  Licensee is not authorized to alter or change any  *
*  such information.                                                  *
*---------------------------------------------------------------------*
*                                                                     *
*  Built for linux64 and running on linux64.                          *
*                                                                     *
*  Software           : Rev: S-2021.09-SP1                            *
*  Library Format     : Rev: 1.05.00                                  *
*  Compiler Name      : gf22nsd41p11s1srl256sa04p1                    *
*  Platform           : Linux3.10.0-957.5.1.el7.x86_64                *
*                     : #1 SMP Wed Dec 19 10:46:58 EST 2018x86_64     *
*  Date of Generation : Thu Nov 10 09:50:10 CET 2022                  *
*                                                                     *
*---------------------------------------------------------------------*
.option scale = 1

.subckt mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=125n wn2=125n wp1=120n wp2=120n
MNA1 X A1 VSS VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 X A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MPA2 net10 A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2
+ w=wp2 m=m_p2
MPA1 X A1 net10 VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
.ends

.subckt mm19a04_u_inv_bulk_n_vt2_p_vt2 VDD VSS VBP VBN X A CPP=104n P_LA_n=4n
+ P_LA_p=4n ULP=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
MNA X A VSS VBN slvtnfet cpp=cpp p_la=p_la_n ulp=ulp nf=nf_n l=ln w=wn m=m_n
MPA X A VDD VBP slvtpfet cpp=cpp p_la=p_la_p ulp=ulp nf=nf_p l=lp w=wp m=m_p
.ends

.subckt mm19a04_u_bc_control_hs1prf VDDP VSS VBP VBN LSDB LSDB_BC1 LSDB_BC2
+ LOG1 BC1 BC2 SD
XI1[0] VDDP VSS VBP VBN LSDB_BC1 SD BC1B
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=160n
+ wp2=160n
XI1[1] VDDP VSS VBP VBN LSDB_BC1 SD BC1B
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=160n
+ wp2=160n
XI0[0] VDDP VSS VBP VBN LSDB_BC2 SD BC2B
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=160n
+ wp2=160n
XI0[1] VDDP VSS VBP VBN LSDB_BC2 SD BC2B
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=160n
+ wp2=160n
XI22 VDDP_SD VSS VBP VBN BC1B BCB12 BC1
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=240n
+ wp2=240n
XI20 VDDP_SD VSS VBP VBN BCB12 BC1 BC2
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=240n
+ wp2=240n
XI21 VDDP_SD VSS VBP VBN BC2B BCB12 LOG1
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=240n
+ wp2=240n
M9 VDDP SD VDDP_SD VBP slvtpfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=240n m=4
XI18 VDDP VSS VBP VBN LSDB SD mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=240n
.ends

.subckt mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=156n wn2=156n wp1=120n wp2=120n
MPA2 X A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
MPA1 X A1 VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MNA1 X A1 net22 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 net22 A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2
+ w=wn2 m=m_n2
.ends

.subckt mm19a04_u_tg_bulk_n_vt2_p_vt2 VBP VBN A B S SB CPP=104n P_LA_n=4n
+ P_LA_p=4n ULP=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
MNS A S B VBN slvtnfet cpp=cpp p_la=p_la_n ulp=ulp nf=nf_n l=ln w=wn m=m_n
MPSB A SB B VBP slvtpfet cpp=cpp p_la=p_la_p ulp=ulp nf=nf_p l=lp w=wp m=m_p
.ends

.subckt mm19a04_u_rm4to1 VDDP VDDPI VSS VBP VBN AT BT CT DT A B C D SEL[0]
+ SEL[1]
*XI8 VBP VBN net39 mm19a04_u_init1
*XI9 VBP VBN net40 mm19a04_u_init0
XI1 VBP VBN B BT SEL[1] SEL[0] mm19a04_u_tg_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
XI0 VBP VBN A AT SEL[1] SEL[0] mm19a04_u_tg_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
XI2 VBP VBN C CT SEL[1] SEL[0] mm19a04_u_tg_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
XI3 VBP VBN D DT SEL[1] SEL[0] mm19a04_u_tg_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
.ends

.subckt mm19a04_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 VDD VSS
+ VBP VBN X A1 A2 A3 CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_n3=4n P_LA_p1=4n
+ P_LA_p2=4n P_LA_p3=4n ULP=0 ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n
+ m_n1=1 m_n2=1 m_n3=1 m_p1=1 m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1
+ nf_p2=1 nf_p3=1 wn1=120n wn2=120n wn3=120n wp1=160n wp2=160n wp3=160n
MNA1 X A1 net19 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 net19 A2 net018 VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2
+ w=wn2 m=m_n2
MNA3 net018 A3 VSS VBN slvtnfet cpp=cpp p_la=p_la_n3 ulp=ulp nf=nf_n3 l=ln3
+ w=wn3 m=m_n3
MPA1 X A1 VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MPA3 X A3 VDD VBP slvtpfet cpp=cpp p_la=p_la_p3 ulp=ulp nf=nf_p3 l=lp3 w=wp3
+ m=m_p3
MPA2 X A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
.ends

.subckt mm19a04_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 VDD VSS VBP VBN X A S0
+ S1 CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=120n wn2=120n wp1=120n wp2=120n
MNA net020 A VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MNS0 X S0 net020 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MPA net16 A VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MPS1 X S1 net16 VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
.ends

.subckt mm19a04_u_blatch_rm VDDPI VNWP VSS VBP VBN OUT OUTB CB CT IN
XI0 VDDPI VSS VBP VBN OUTB IN CB CT
+ mm19a04_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XI1 VDDPI VSS VBP VBN OUTB OUT CT CB
+ mm19a04_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
*XI39 VBP VBN OUTB mm19a04_u_init1
XI2 VDDPI VSS VBP VBN OUT OUTB mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
.ends

.subckt mm19a04_u_rmmx VDDP VDDPI VSS VBP VBN QB A BCB BCT TA
XA VDDPI VSS VBP VBN QB A BCB BCT
+ mm19a04_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XTA VDDPI VSS VBP VBN QB TA BCT BCB
+ mm19a04_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
.ends

.subckt mm19a04_u_hs1prf_rm2to4_pc VDDP VDDPI VSS VBP VBN LRM[2] SEL_RM0123
+ SEL_RM0B SEL_RM1 SEL_RM1B SEL_RM2 SEL_RM2B SEL_RM3 SEL_RM3B SEL_RM4 SEL_RM5
+ LOG1 LCLKB LCLKT RM[0] RM[1] RM[2] RME RMENI[0] RMENI[1] RMENI[2]
XI78 VDDPI VSS VBP VBN SEL_RM1B LRM[0] LRMB[1] LRMB[2]
+ mm19a04_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=240n
+ wn2=240n wn3=240n wp1=120n wp2=120n wp3=120n
XI79 VDDPI VSS VBP VBN SEL_RM0B LRMB[0] LRMB[1] LRMB[2]
+ mm19a04_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=240n
+ wn2=240n wn3=240n wp1=120n wp2=120n wp3=120n
XI71 VDDPI VSS VBP VBN SEL_RM2B LRMB[0] LRM[1] LRMB[2]
+ mm19a04_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=240n
+ wn2=240n wn3=240n wp1=120n wp2=120n wp3=120n
XI76 VDDPI VSS VBP VBN SEL_RM4B LRMB[0] LRMB[1] LRM[2]
+ mm19a04_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=240n
+ wn2=240n wn3=240n wp1=120n wp2=120n wp3=120n
XLRM1 VDDPI VDDP VSS VBP VBN LRMB[1] LRM[1] LCLKB LCLKT RM_RMI[1]
+ mm19a04_u_blatch_rm
XLRM0 VDDPI VDDP VSS VBP VBN LRMB[0] LRM[0] LCLKB LCLKT RM_RMI[0]
+ mm19a04_u_blatch_rm
XLRM2 VDDPI VDDP VSS VBP VBN LRMB[2] LRM[2] LCLKB LCLKT RM_RMI[2]
+ mm19a04_u_blatch_rm
XIRM_RMI0 VDDP VDDPI VSS VBP VBN RM_RMI[0] RM[0] RME RMEB RMENI[0]
+ mm19a04_u_rmmx
XIRM_RMI1 VDDP VDDPI VSS VBP VBN RM_RMI[1] RM[1] RME RMEB RMENI[1]
+ mm19a04_u_rmmx
XIRM_RMI2 VDDP VDDPI VSS VBP VBN RM_RMI[2] RM[2] RME RMEB RMENI[2]
+ mm19a04_u_rmmx
MNA SEL_RM5 LRMB[1] net169 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=1
MI56 SEL_RM5 LRMB[2] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n
+ m=1
MI55 net169 LRMB[0] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n
+ m=1
XI80 VDDPI VSS VBP VBN SEL_RM3B SEL_RM3 mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI75 VDDPI VSS VBP VBN SEL_RM0123 LRM[2] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI91 VDDPI VSS VBP VBN SEL_RM4 SEL_RM4B mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI61 VDDPI VSS VBP VBN RMEB RME mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI68 VDDPI VSS VBP VBN SEL_RM1 SEL_RM1B mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI72 VDDPI VSS VBP VBN SEL_RM2 SEL_RM2B mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI69 VDDPI VSS VBP VBN SEL_RM3 net239 LRMB[2]
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI81 VDDPI VSS VBP VBN net239 LRM[0] LRM[1]
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
MIdummy16 SEL_RM4B LOG1 SEL_RM4 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=1
MI57 net163 LRMB[0] SEL_RM5 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=1
MI58 net163 LRMB[1] SEL_RM5 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=1
MIdummy17 SEL_RM2B LOG1 SEL_RM2 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=1
Midummy19 VDDPI LOG1 SEL_RM0B VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=1
MIdummy20 VDDPI LOG1 LRMB[1] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=1
Midummy15 VDDPI LOG1 SEL_RM3B VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=1
MPA VDDPI LRMB[2] net163 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n
+ m=1
MIdummy18 SEL_RM1B LOG1 SEL_RM1 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=1
.ends

.subckt mm19a04_u_rm4to1_pmos VDDP VBP VBN AT BT CT DT A B C D SELB[1]
MI5 A SELB[1] AT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M2 D SELB[1] DT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M1 C SELB[1] CT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M0 B SELB[1] BT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
.ends

.subckt mm19a04_u_hs1prf_rm_wm_ctrl_pc VDDP VDDPI VDDPI_LOG1 VSS VBP VBN DEF1
+ DEF1B DEF2 DEF2B DEF_MODE FAST1_MODE FAST2_MODE RT[0] RT[1] RT[2] RT[3] WT[0]
+ WT[1] WT[2] WT[3] LOG0 LOG1 DEF12B_PROG DEF12_PROG DEF_PROG LCLKB LCLKT
+ PROCOM[0] PROCOM[1] RM[0] RM[1] RM[2] RMDEF1[0] RMDEF1[1] RMDEF1[2] RMDEF1[3]
+ RMDEF1_PROCOM00[0] RMDEF1_PROCOM00[1] RMDEF1_PROCOM00[2] RMDEF1_PROCOM00[3]
+ RMDEF1_PROCOM01[0] RMDEF1_PROCOM01[1] RMDEF1_PROCOM01[2] RMDEF1_PROCOM01[3]
+ RMDEF2[0] RMDEF2[1] RMDEF2[2] RMDEF2[3] RME RMENI[0] RMENI[1] RMENI[2]
+ RMSLOW[0] RMSLOW[1] RMSLOW[2] RMSLOW[3] WMDEF1[0] WMDEF1[1] WMDEF1[2]
+ WMDEF1[3] WMDEF1_PROCOM00[0] WMDEF1_PROCOM00[1] WMDEF1_PROCOM00[2]
+ WMDEF1_PROCOM00[3] WMDEF1_PROCOM01[0] WMDEF1_PROCOM01[1] WMDEF1_PROCOM01[2]
+ WMDEF1_PROCOM01[3] WMDEF2[0] WMDEF2[1] WMDEF2[2] WMDEF2[3] WMSLOW[0]
+ WMSLOW[1] WMSLOW[2] WMSLOW[3]
XI107 VDDP VDDPI VSS VBP VBN WT[0] WT[1] WT[2] WT[3] WMDEF1[0] WMDEF1[1]
+ WMDEF1[2] WMDEF1[3] DEF1B DEF1 mm19a04_u_rm4to1
XI108 VDDP VDDPI VSS VBP VBN RT[0] RT[1] RT[2] RT[3] RMDEF1[0] RMDEF1[1]
+ RMDEF1[2] RMDEF1[3] DEF1B DEF1 mm19a04_u_rm4to1
XI59 VDDP VDDPI VSS VBP VBN WT[0] WT[1] WT[2] WT[3] WMSLOW[0] WMSLOW[1]
+ WMSLOW[2] WMSLOW[3] SLOWB SLOW mm19a04_u_rm4to1
XI58 VDDP VDDPI VSS VBP VBN WT[0] WT[1] WT[2] WT[3] WMDEF2[0] WMDEF2[1]
+ WMDEF2[2] WMDEF2[3] DEF2B DEF2 mm19a04_u_rm4to1
XI53 VDDP VDDPI VSS VBP VBN RT[0] RT[1] RT[2] RT[3] RMSLOW[0] RMSLOW[1]
+ RMSLOW[2] RMSLOW[3] SLOWB SLOW mm19a04_u_rm4to1
XRMD VDDP VDDPI VSS VBP VBN RT[0] RT[1] RT[2] RT[3] RMDEF2[0] RMDEF2[1]
+ RMDEF2[2] RMDEF2[3] DEF2B DEF2 mm19a04_u_rm4to1
XIRM_MUX VDDP VDDPI VSS VBP VBN LRM[2] DEF_MODE VDDMINB SLOW SLOWB DEF2 DEF2B
+ DEF1 DEF1B FAST1_MODE FAST2_MODE LOG1 LCLKB LCLKT RM[0] RM[1] RM[2] RME
+ RMENI[0] RMENI[1] RMENI[2] mm19a04_u_hs1prf_rm2to4_pc
XI78 VDDPI VSS VBP VBN DEF_PROGB DEF_PROG mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI57 VDDP VBP VBN WT[0] WT[1] WT[2] WT[3] VDDPI_LOG1 VDDPI_LOG1 VDDPI_LOG1
+ VDDPI_LOG1 VDDMINB mm19a04_u_rm4to1_pmos
XI52 VDDP VBP VBN RT[0] RT[1] RT[2] RT[3] VDDPI_LOG1 VDDPI_LOG1 VDDPI_LOG1
+ VDDPI_LOG1 VDDMINB mm19a04_u_rm4to1_pmos
.ends

.subckt mm19a04_u_hs1prf_rm_wm_ctrl_base VDDP VDDPI VDDPI_LOG1 VSS VBP VBN DEF1
+ DEF1B DEF2 DEF2B DEF_MODE FAST1_MODE FAST2_MODE RMT[0] RMT[1] RMT[2] RMT[3]
+ WMT[0] WMT[1] WMT[2] WMT[3] LOG0 LOG1 DEF12B_PROG DEF12_PROG DEF_PROG FLOAT
+ PROCOM[0] PROCOM[1] RM[0] RM[1] RM[2] RMDEF1[0] RMDEF1[1] RMDEF1[2] RMDEF1[3]
+ RMDEF1_PROCOM00[0] RMDEF1_PROCOM00[1] RMDEF1_PROCOM00[2] RMDEF1_PROCOM00[3]
+ RMDEF1_PROCOM01[0] RMDEF1_PROCOM01[1] RMDEF1_PROCOM01[2] RMDEF1_PROCOM01[3]
+ RMDEF2[0] RMDEF2[1] RMDEF2[2] RMDEF2[3] RME RMENI[0] RMENI[1] RMENI[2]
+ RMSLOW[0] RMSLOW[1] RMSLOW[2] RMSLOW[3] WMDEF1[0] WMDEF1[1] WMDEF1[2]
+ WMDEF1[3] WMDEF1_PROCOM00[0] WMDEF1_PROCOM00[1] WMDEF1_PROCOM00[2]
+ WMDEF1_PROCOM00[3] WMDEF1_PROCOM01[0] WMDEF1_PROCOM01[1] WMDEF1_PROCOM01[2]
+ WMDEF1_PROCOM01[3] WMDEF2[0] WMDEF2[1] WMDEF2[2] WMDEF2[3] WMSLOW[0]
+ WMSLOW[1] WMSLOW[2] WMSLOW[3]
XRM VDDP VDDPI VDDPI_LOG1 VSS VBP VBN DEF1 DEF1B DEF2 DEF2B DEF_MODE FAST1_MODE
+ FAST2_MODE RMB[0] RMB[1] RMB[2] RMB[3] WMB[0] WMB[1] WMB[2] WMB[3] LOG0 LOG1
+ DEF12B_PROG DEF12_PROG DEF_PROG LCLKB LCLKT PROCOM[0] PROCOM[1] RM[0] RM[1]
+ RM[2] RMDEF1[0] RMDEF1[1] RMDEF1[2] RMDEF1[3] RMDEF1_PROCOM00[0]
+ RMDEF1_PROCOM00[1] RMDEF1_PROCOM00[2] RMDEF1_PROCOM00[3] RMDEF1_PROCOM01[0]
+ RMDEF1_PROCOM01[1] RMDEF1_PROCOM01[2] RMDEF1_PROCOM01[3] RMDEF2[0] RMDEF2[1]
+ RMDEF2[2] RMDEF2[3] RME RMENI[0] RMENI[1] RMENI[2] RMSLOW[0] RMSLOW[1]
+ RMSLOW[2] RMSLOW[3] WMDEF1[0] WMDEF1[1] WMDEF1[2] WMDEF1[3]
+ WMDEF1_PROCOM00[0] WMDEF1_PROCOM00[1] WMDEF1_PROCOM00[2] WMDEF1_PROCOM00[3]
+ WMDEF1_PROCOM01[0] WMDEF1_PROCOM01[1] WMDEF1_PROCOM01[2] WMDEF1_PROCOM01[3]
+ WMDEF2[0] WMDEF2[1] WMDEF2[2] WMDEF2[3] WMSLOW[0] WMSLOW[1] WMSLOW[2]
+ WMSLOW[3] mm19a04_u_hs1prf_rm_wm_ctrl_pc
XI101[0] VDDPI VSS VBP VBN WMT[0] WMB[0] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=320n wp=320n
XI101[1] VDDPI VSS VBP VBN WMT[1] WMB[1] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=320n wp=320n
XRMT3 VDDPI VSS VBP VBN LCLKB LCLKT mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI63[2] VDDPI VSS VBP VBN WMT[2] WMB[2] mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI63[3] VDDPI VSS VBP VBN WMT[3] WMB[3] mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI58[0] VDDPI VSS VBP VBN RMT[0] RMB[0] mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI58[1] VDDPI VSS VBP VBN RMT[1] RMB[1] mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XRMB3 VDDPI VSS VBP VBN LCLKT FLOAT mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI102[2] VDDPI VSS VBP VBN RMT[2] RMB[2] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=320n wp=320n
XI102[3] VDDPI VSS VBP VBN RMT[3] RMB[3] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=320n wp=320n
.ends

.subckt mm19a04_u_hs1prf_rmctrl VDDP VDDPI VDDPI_LOG1 VSS VBP VBN DEF1 DEF1B
+ DEF2 DEF2B DEF_MODE FAST1_MODE FAST2_MODE RM3_CORE_CNT RMT[0] RMT[1] RMT[2]
+ RMT[3] WMT[0] WMT[1] WMT[2] WMT[3] LOG0 LOG1 LOG1_RM DEF12B_PROG DEF12_PROG
+ DEF_PROG FLOAT LSDB PROCOM[0] PROCOM[1] RM[0] RM[1] RM[2] RM[3] RMDEF1[0]
+ RMDEF1[1] RMDEF1[2] RMDEF1[3] RMDEF1_PROCOM00[0] RMDEF1_PROCOM00[1]
+ RMDEF1_PROCOM00[2] RMDEF1_PROCOM00[3] RMDEF1_PROCOM01[0] RMDEF1_PROCOM01[1]
+ RMDEF1_PROCOM01[2] RMDEF1_PROCOM01[3] RMDEF2[0] RMDEF2[1] RMDEF2[2] RMDEF2[3]
+ RME RMENI[0] RMENI[1] RMENI[2] RMSLOW[0] RMSLOW[1] RMSLOW[2] RMSLOW[3]
+ WMDEF1[0] WMDEF1[1] WMDEF1[2] WMDEF1[3] WMDEF1_PROCOM00[0] WMDEF1_PROCOM00[1]
+ WMDEF1_PROCOM00[2] WMDEF1_PROCOM00[3] WMDEF1_PROCOM01[0] WMDEF1_PROCOM01[1]
+ WMDEF1_PROCOM01[2] WMDEF1_PROCOM01[3] WMDEF2[0] WMDEF2[1] WMDEF2[2] WMDEF2[3]
+ WMSLOW[0] WMSLOW[1] WMSLOW[2] WMSLOW[3]
XI43 VDDP VSS VBP VBN RM3_CORE_CNT net235 mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI53 VDDP VSS VBP VBN net235 RM[3] LSDB
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XRM VDDP VDDPI VDDPI_LOG1 VSS VBP VBN DEF1 DEF1B DEF2 DEF2B DEF_MODE FAST1_MODE
+ FAST2_MODE RMT[0] RMT[1] RMT[2] RMT[3] WMT[0] WMT[1] WMT[2] WMT[3] LOG0 LOG1
+ DEF12B_PROG DEF12_PROG DEF_PROG FLOAT PROCOM[0] PROCOM[1] RM[0] RM[1] RM[2]
+ RMDEF1[0] RMDEF1[1] RMDEF1[2] RMDEF1[3] RMDEF1_PROCOM00[0] RMDEF1_PROCOM00[1]
+ RMDEF1_PROCOM00[2] RMDEF1_PROCOM00[3] RMDEF1_PROCOM01[0] RMDEF1_PROCOM01[1]
+ RMDEF1_PROCOM01[2] RMDEF1_PROCOM01[3] RMDEF2[0] RMDEF2[1] RMDEF2[2] RMDEF2[3]
+ RME RMENI[0] RMENI[1] RMENI[2] RMSLOW[0] RMSLOW[1] RMSLOW[2] RMSLOW[3]
+ WMDEF1[0] WMDEF1[1] WMDEF1[2] WMDEF1[3] WMDEF1_PROCOM00[0] WMDEF1_PROCOM00[1]
+ WMDEF1_PROCOM00[2] WMDEF1_PROCOM00[3] WMDEF1_PROCOM01[0] WMDEF1_PROCOM01[1]
+ WMDEF1_PROCOM01[2] WMDEF1_PROCOM01[3] WMDEF2[0] WMDEF2[1] WMDEF2[2] WMDEF2[3]
+ WMSLOW[0] WMSLOW[1] WMSLOW[2] WMSLOW[3] mm19a04_u_hs1prf_rm_wm_ctrl_base
MIdummy4[0] RMSLOW[0] LOG1 WMDEF1[2] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=120n m=1
MIdummy4[1] RMSLOW[1] LOG1 WMDEF1[3] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=120n m=1
Midummy1[2] VDDPI_LOG1 LOG1 RMSLOW[2] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=120n m=1
Midummy1[3] VDDPI_LOG1 LOG1 RMSLOW[3] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=120n m=1
MI98 VDDP LOG0 LOG1_RM VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=360n
+ m=2
MIdummy2[0] VDDPI_LOG1 LOG1 WMSLOW[0] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=120n m=1
MIdummy2[1] VDDPI_LOG1 LOG1 WMSLOW[1] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=120n m=1
MIdummy2[2] VDDPI_LOG1 LOG1 WMSLOW[2] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=120n m=1
MIdummy2[3] VDDPI_LOG1 LOG1 WMSLOW[3] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=120n m=1
MIdummy1[0] RMDEF2[0] LOG1 RMDEF2[2] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=120n m=1
MIdummy1[1] RMDEF2[1] LOG1 RMDEF2[3] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=120n m=1
MIdummy5[0] WMDEF1[0] LOG1 RMDEF1[2] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=120n m=1
MIdummy5[1] WMDEF1[1] LOG1 RMDEF1[3] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=120n m=1
MIdummy3[0] WMDEF2[0] LOG1 WMDEF2[2] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=120n m=1
MIdummy3[1] WMDEF2[1] LOG1 WMDEF2[3] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=120n m=1
.ends

.subckt mm19a04_u_hs1prf_pg_lsltch VDDP VDDPI VSS VBP VBN LITESLP RWLCKB LS
+ RFLOAT WFLOAT
XI23 VDDPI VSS VBP VBN LSB LS mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n wp=160n
XI3 VDDPI VSS VBP VBN LDP LDPB mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI26 VDDP VSS VBP VBN RWLCKB RWLCKT mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI32 VDDPI VSS VBP VBN LITESLP LDPB mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI1[0] VDDPI VSS VBP VBN RWLCKT RFLOAT WFLOAT
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=160n
+ wp2=160n
XI1[1] VDDPI VSS VBP VBN RWLCKT RFLOAT WFLOAT
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=160n
+ wp2=160n
XI33[0] VBP VBN LSB LDPB RWLCKB RWLCKT mm19a04_u_tg_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI33[1] VBP VBN LSB LDPB RWLCKB RWLCKT mm19a04_u_tg_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI27 VDDPI VSS VBP VBN LDPB LDP RWLCKT RWLCKB
+ mm19a04_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n
+ wp1=160n wp2=160n
.ends

.subckt mm19a04_u_hs1prf_tclk VDDP VDDPI VSS VBP VBN FLOAT T1T TCLKB
Xinv_tckrd[0] VDDPI VSS VBP VBN TCK TCLKB T1T
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=213n
+ wp2=213n
Xinv_tckrd[1] VDDPI VSS VBP VBN TCK TCLKB T1T
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=213n
+ wp2=213n
Xinv_tckrd[2] VDDPI VSS VBP VBN TCK TCLKB T1T
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=213n
+ wp2=213n
M8 net33 TCK FLOAT VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=480n m=2
M7 net29 T1T net33 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=225n m=4
M6 VSS net28 net29 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=225n m=4
MP_trd VDDP TCK FLOAT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=596n m=8
XI5 VDDPI VSS VBP VBN net28 FLOAT mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=160n
.ends

.subckt mm19a04_u_latch_pass VDDP VDDPI VSS VBP VBN Q QB A CB CT
Xinv_lat1 VDDPI VSS VBP VBN QB Q mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=160n
Xinv_feed VDDPI VSS VBP VBN Q QB CT CB
+ mm19a04_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2
+ m_n2=2 m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n
+ wp1=160n wp2=160n
XI3 VBP VBN A Q CB CT mm19a04_u_tg_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1 wn=160n wp=160n
.ends

.subckt mm19a04_u_lat_pass_new_me VDDP VDDPI VSS VBP VBN Q QB A CB CT
XI3 VBP VBN A Q CB CT mm19a04_u_tg_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=160n wp=160n
Xinv_lat1 VDDPI VSS VBP VBN QB Q mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=200n
+ wp=200n
*XI8 Q mm19a04_u_lat_int_node
*XI9 VBP VBN QB VDDPI mm19a04_u_lat_set_op_pfv
Xinv_feed VDDPI VSS VBP VBN Q QB CT CB
+ mm19a04_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2
+ m_n2=2 m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n
+ wp1=160n wp2=160n
.ends

.subckt mm19a04_u_control_dft_hs1prf VDDP VDDPI VSS VBP VBN CLKB CLKT LME
+ LMEWRB LWE LWE_DFT MCLKB MCLKT MEB_LT MEORDFTCLKEN T1T CLK DFTCLKEN LCLKB
+ LCLKT LDFTX ME MEB_I TEST1 WE
XI20[0] VDDPI VSS VBP VBN LWE_DFT LWEB LDFTX
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=150n wn2=150n wp1=375n
+ wp2=375n
XI20[1] VDDPI VSS VBP VBN LWE_DFT LWEB LDFTX
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=150n wn2=150n wp1=375n
+ wp2=375n
XI20[2] VDDPI VSS VBP VBN LWE_DFT LWEB LDFTX
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=150n wn2=150n wp1=375n
+ wp2=375n
XI20[3] VDDPI VSS VBP VBN LWE_DFT LWEB LDFTX
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=150n wn2=150n wp1=375n
+ wp2=375n
XI15[0] VDDPI VSS VBP VBN T1T TEST1B LDFTX
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=160n
+ wp2=160n
XI15[1] VDDPI VSS VBP VBN T1T TEST1B LDFTX
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=160n
+ wp2=160n
XI15[2] VDDPI VSS VBP VBN T1T TEST1B LDFTX
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=160n
+ wp2=160n
XI15[3] VDDPI VSS VBP VBN T1T TEST1B LDFTX
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=160n
+ wp2=160n
XI15[4] VDDPI VSS VBP VBN T1T TEST1B LDFTX
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=160n
+ wp2=160n
Xnd2_lmewr[0] VDDPI VSS VBP VBN MEORDFTCLKEN DFTCLKENB MEB_I
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=160n
+ wp2=160n
Xnd2_lmewr[1] VDDPI VSS VBP VBN MEORDFTCLKEN DFTCLKENB MEB_I
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=160n
+ wp2=160n
XI27 VDDPI VSS VBP VBN MEB_LT ME mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=200n
+ wp=200n
Xinv_web VDDPI VSS VBP VBN WEB WE mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=7 m_p=7 nf_n=1 nf_p=1 wn=225n
+ wp=225n
Xinv_test1 VDDPI VSS VBP VBN TEST1B TEST1 mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=160n
Xinv_tclk VDDPI VSS VBP VBN CLKT CLKB mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1 wn=160n
+ wp=160n
Xinv_tclkb VDDPI VSS VBP VBN CLKB CLK mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=160n
+ wp=160n
Xinv_mclk VDDPI VSS VBP VBN MCLKT MCLKB mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=200n
+ wp=200n
Xinv_mclkb VDDPI VSS VBP VBN MCLKB CLK mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=200n
+ wp=200n
Xinv_swt VDDPI VSS VBP VBN DFTCLKENB DFTCLKEN mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=160n
XI35 VDDPI VSS VBP VBN LWE LWEB mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=160n
Xlat_wr VDDP VDDPI VSS VBP VBN LWEB net63 WEB LCLKB LCLKT mm19a04_u_latch_pass
Xlat_mewr VDDP VDDPI VSS VBP VBN LMEWRB LME MEB_I MCLKB MCLKT
+ mm19a04_u_lat_pass_new_me
.ends

.subckt mm19a04_u_inv_bulk_n_vt3_p_vt3 VDD VSS VBP VBN X A CPP=104n P_LA_n=4n
+ P_LA_p=4n ULP=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
MNA X A VSS VBN slvtnfet cpp=cpp p_la=p_la_n ulp=ulp nf=nf_n l=ln w=wn m=m_n
MPA X A VDD VBP slvtpfet cpp=cpp p_la=p_la_p ulp=ulp nf=nf_p l=lp w=wp m=m_p
.ends

.subckt mm19a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 VDD VSS VBP VBN X A S0
+ S1 CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=120n wn2=120n wp1=120n wp2=120n
MNA net020 A VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MNS0 X S0 net020 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MPA net16 A VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MPS1 X S1 net16 VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
.ends

.subckt mm19a04_u_hs1prf_blatch_addr_vt4 VDDP VDDPI VSS VBP VBN OUT OUTB CB CT
+ IN
*XI5 VBP VBN OUTB mm19a04_u_init0
XI2 VDDPI VSS VBP VBN OUT OUTB mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=0
+ p_la_p=0 ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=225n wp=225n
*XI6 OUTB mm19a04_u_lat_int_node
*XI8 VBP VBN OUTB VDDPI mm19a04_u_lat_set_op_pfv
XI0[0] VDDPI VSS VBP VBN OUTB IN CB CT
+ mm19a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=0 p_la_n2=0
+ p_la_p1=0 p_la_p2=0 ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=225n wn2=225n wp1=225n
+ wp2=225n
XI0[1] VDDPI VSS VBP VBN OUTB IN CB CT
+ mm19a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=0 p_la_n2=0
+ p_la_p1=0 p_la_p2=0 ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=225n wn2=225n wp1=225n
+ wp2=225n
XI1 VDDPI VSS VBP VBN OUTB OUT CT CB
+ mm19a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=225n wn2=225n
+ wp1=225n wp2=225n
.ends

.subckt mm19a04_u_hs1prf_adr_latches_cm4bk2 VDDP VDDPI VSS VBP VBN LBKADR
+ LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+ LYADR[0] LYADR[1] BKADRA CLKB CLKI XADRA[0] XADRA[1] XADRA[2] XADRA[3]
+ XADRA[4] XADRA[5] XADRA[6] XADRA[7] YADRA[0] YADRA[1]
XBKADDR VDDP VDDPI VSS VBP VBN LBKADR LBKADRQB CLKB CLKI BKADRA
+ mm19a04_u_hs1prf_blatch_addr_vt4
XRADR[0] VDDP VDDPI VSS VBP VBN LXADR[0] LXADRQB[0] CLKB CLKI XADRA[0]
+ mm19a04_u_hs1prf_blatch_addr_vt4
XRADR[1] VDDP VDDPI VSS VBP VBN LXADR[1] LXADRQB[1] CLKB CLKI XADRA[1]
+ mm19a04_u_hs1prf_blatch_addr_vt4
XRADR[2] VDDP VDDPI VSS VBP VBN LXADR[2] LXADRQB[2] CLKB CLKI XADRA[2]
+ mm19a04_u_hs1prf_blatch_addr_vt4
XRADR[3] VDDP VDDPI VSS VBP VBN LXADR[3] LXADRQB[3] CLKB CLKI XADRA[3]
+ mm19a04_u_hs1prf_blatch_addr_vt4
XRADR[4] VDDP VDDPI VSS VBP VBN LXADR[4] LXADRQB[4] CLKB CLKI XADRA[4]
+ mm19a04_u_hs1prf_blatch_addr_vt4
XRADR[5] VDDP VDDPI VSS VBP VBN LXADR[5] LXADRQB[5] CLKB CLKI XADRA[5]
+ mm19a04_u_hs1prf_blatch_addr_vt4
XRADR[6] VDDP VDDPI VSS VBP VBN LXADR[6] LXADRQB[6] CLKB CLKI XADRA[6]
+ mm19a04_u_hs1prf_blatch_addr_vt4
XRADR[7] VDDP VDDPI VSS VBP VBN LXADR[7] LXADRQB[7] CLKB CLKI XADRA[7]
+ mm19a04_u_hs1prf_blatch_addr_vt4
XYADR[0] VDDP VDDPI VSS VBP VBN LYADR[0] LYADRQB[0] CLKB CLKI YADRA[0]
+ mm19a04_u_hs1prf_blatch_addr_vt4
XYADR[1] VDDP VDDPI VSS VBP VBN LYADR[1] LYADRQB[1] CLKB CLKI YADRA[1]
+ mm19a04_u_hs1prf_blatch_addr_vt4
.ends

.subckt mm19a04_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=156n wn2=156n wp1=120n wp2=120n
MPA2 X A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
MPA1 X A1 VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MNA1 X A1 net22 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 net22 A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2
+ w=wn2 m=m_n2
.ends

.subckt mm19a04_u_hs1prf_float_gen_new VDDP VDDPI VSS VBP VBN CKGATE FLOAT CLKB
+ CLPSEBUF DLYPW LDFTX LMEB PW
*XI84 VBP VBN FLOAT mm19a04_u_init1
XI88 VDDPI VSS VBP VBN MEDFT LDFTXB LMEB
+ mm19a04_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=0 p_la_n2=0
+ p_la_p1=0 p_la_p2=0 ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=120n
+ wp2=120n
XI95[0] VDDP VSS VBP VBN PWB PW MEDFT
+ mm19a04_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=0 p_la_n2=0
+ p_la_p1=0 p_la_p2=0 ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=120n
+ wp2=120n
XI95[1] VDDP VSS VBP VBN PWB PW MEDFT
+ mm19a04_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=0 p_la_n2=0
+ p_la_p1=0 p_la_p2=0 ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=120n
+ wp2=120n
XI95[2] VDDP VSS VBP VBN PWB PW MEDFT
+ mm19a04_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=0 p_la_n2=0
+ p_la_p1=0 p_la_p2=0 ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=120n
+ wp2=120n
MI86 VDDPI PWB NET_A VBP slvtpfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=572n m=7
MI87 NET_A CLKB CKGATE VBP slvtpfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=572n m=7
MIfloat_lockup_mp2 FLOAT CKGATE NET_B VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=240n m=4
MIfloat_lockup_mp1 NET_B FLOATB VDDP VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=240n m=4
XIfloat_lockup_inv1 VDDPI VSS VBP VBN FLOATB FLOAT
+ mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=0 p_la_p=0 ulp=0 ln=20n lp=20n
+ m_n=5 m_p=1 nf_n=1 nf_p=1 wn=128n wp=240n
XI94 VDDPI VSS VBP VBN LDFTXB LDFTX mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
MI85 FLOATB CLPSEBUF VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=4
MI89 FLOAT CKGATE VSS VBN slvtnfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=538n m=13
MI90 FLOATB DLYPW VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=4
M58 CKGATE CLKB VSS VBN slvtnfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=172n m=7
M73 CKGATE PWB VSS VBN slvtnfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=172n m=7
.ends

.subckt mm19a04_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=125n wn2=125n wp1=120n wp2=120n
MNA1 X A1 VSS VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 X A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MPA2 net10 A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2
+ w=wp2 m=m_p2
MPA1 X A1 net10 VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
.ends

.subckt mm19a04_u_nd3_bulk_n1_vt3_n2_vt3_n3_vt3_p1_vt3_p2_vt3_p3_vt3 VDD VSS
+ VBP VBN X A1 A2 A3 CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_n3=4n P_LA_p1=4n
+ P_LA_p2=4n P_LA_p3=4n ULP=0 ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n
+ m_n1=1 m_n2=1 m_n3=1 m_p1=1 m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1
+ nf_p2=1 nf_p3=1 wn1=120n wn2=120n wn3=120n wp1=160n wp2=160n wp3=160n
MNA1 X A1 net19 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 net19 A2 net018 VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2
+ w=wn2 m=m_n2
MNA3 net018 A3 VSS VBN slvtnfet cpp=cpp p_la=p_la_n3 ulp=ulp nf=nf_n3 l=ln3
+ w=wn3 m=m_n3
MPA1 X A1 VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MPA3 X A3 VDD VBP slvtpfet cpp=cpp p_la=p_la_p3 ulp=ulp nf=nf_p3 l=lp3 w=wp3
+ m=m_p3
MPA2 X A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
.ends

.subckt mm19a04_u_hs1prf_data_latch_clock_gen VDDP VDDPI VSS VBP VBN FLTIO
+ LCLKBIO FLOATBD LS_INT OUT_2INV OUT_4INV OUT_6INV CLKB_LATCH FLOAT IN_2INV
+ IN_4INV IN_6INV LS WE_GATE_CLK
XI88 VDDPI VSS VBP VBN OUT_6INV net290 mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI87 VDDPI VSS VBP VBN OUT_4INV net288 mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI86 VDDPI VSS VBP VBN OUT_2INV net259 mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
Xinv_floatb VDDPI VSS VBP VBN net259 IN_2INV LS
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI79 VDDPI VSS VBP VBN net288 IN_4INV LS
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI80 VDDPI VSS VBP VBN net290 IN_6INV LS
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
Xnr2_ls[0] VDDPI VSS VBP VBN FLTIO FLOATBD LS_INT
+ mm19a04_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=200n
+ wp2=200n
Xnr2_ls[1] VDDPI VSS VBP VBN FLTIO FLOATBD LS_INT
+ mm19a04_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=200n
+ wp2=200n
Xnr2_ls[2] VDDPI VSS VBP VBN FLTIO FLOATBD LS_INT
+ mm19a04_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=200n
+ wp2=200n
Xnr2_ls[3] VDDPI VSS VBP VBN FLTIO FLOATBD LS_INT
+ mm19a04_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=200n
+ wp2=200n
MI95 VSS OUT_2INV VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=225n m=1
MLPCPLP VSS net290 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=225n
+ m=1
MI89 VSS net288 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=225n m=1
MI90 VSS net259 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=225n m=1
MI92 VSS OUT_4INV VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=225n m=1
MI93 VSS OUT_6INV VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=225n m=1
XI42 VDDPI VSS VBP VBN LCLKBIO CLKB_LATCH FLTIO FLOAT
+ mm19a04_u_nd3_bulk_n1_vt3_n2_vt3_n3_vt3_p1_vt3_p2_vt3_p3_vt3 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=9 m_n2=9 m_n3=9 m_p1=9
+ m_p2=9 m_p3=9 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=222n
+ wn2=222n wn3=222n wp1=222n wp2=222n wp3=222n
.ends

.subckt mm19a04_u_hs1prf_add_we_latch_clk_gen VDDP VDDPI VSS VBP VBN CLKB_LATCH
+ FLTBL LCLKB LCLKT LSB CLKFLT DFTCLKEN FLOAT IN_2INV_ADDR LS
XI93 VDDPI net348 VBP VBN net352 IN_2INV_ADDR mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI95 net354 VSS VBP VBN net349 net352 mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI74 VDDPI net347 VBP VBN net341 net349 mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
Mpa VDDPI FLTBL LCLKB VBP slvtpfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=120n m=10
MI77 VDDPI FLT LCLKT VBP slvtpfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=405n m=5
MI79 VDDPI FLTBL FLT VBP slvtpfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=225n m=4
MI97 VDDPI net352 net354 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
Mnd3_lclk_nmos_c[0] netxyz[0] LSB VSS VBN slvtnfet cpp=104n p_la=0 ulp=0 nf=1
+ l=20n w=160n m=1
Mnd3_lclk_nmos_c[1] netxyz[1] LSB VSS VBN slvtnfet cpp=104n p_la=0 ulp=0 nf=1
+ l=20n w=160n m=1
Mnd3_lclk_nmos_c[2] netxyz[2] LSB VSS VBN slvtnfet cpp=104n p_la=0 ulp=0 nf=1
+ l=20n w=160n m=1
Mna LCLKB FLTBL VSS VBN slvtnfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=180n m=10
MI76 LCLKT FLT VSS VBN slvtnfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=225n m=9
MI80 FLT FLTBL VSS VBN slvtnfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=225n m=4
MI94 net348 IN_2INV_ADDR VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=1
Mnd2_clkenab_nmos_a[0] CLKB_LATCH CLKFLT net326[0] VBN slvtnfet cpp=104n
+ p_la=4n ulp=0 nf=1 l=20n w=160n m=1
Mnd2_clkenab_nmos_a[1] CLKB_LATCH CLKFLT net326[1] VBN slvtnfet cpp=104n
+ p_la=4n ulp=0 nf=1 l=20n w=160n m=1
Mnd2_clkenab_nmos_a[2] CLKB_LATCH CLKFLT net326[2] VBN slvtnfet cpp=104n
+ p_la=4n ulp=0 nf=1 l=20n w=160n m=1
MI92 net347 net349 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
Mnd2_clkenab_nmos_b[0] net326[0] DFTCLKEN VSS VBN slvtnfet cpp=104n p_la=4n
+ ulp=0 nf=1 l=20n w=160n m=1
Mnd2_clkenab_nmos_b[1] net326[1] DFTCLKEN VSS VBN slvtnfet cpp=104n p_la=4n
+ ulp=0 nf=1 l=20n w=160n m=1
Mnd2_clkenab_nmos_b[2] net326[2] DFTCLKEN VSS VBN slvtnfet cpp=104n p_la=4n
+ ulp=0 nf=1 l=20n w=160n m=1
Mnd3_lclk_nmos_b[0] net336[0] FLOAT netxyz[0] VBN slvtnfet cpp=104n p_la=0
+ ulp=0 nf=1 l=20n w=160n m=1
Mnd3_lclk_nmos_b[1] net336[1] FLOAT netxyz[1] VBN slvtnfet cpp=104n p_la=0
+ ulp=0 nf=1 l=20n w=160n m=1
Mnd3_lclk_nmos_b[2] net336[2] FLOAT netxyz[2] VBN slvtnfet cpp=104n p_la=0
+ ulp=0 nf=1 l=20n w=160n m=1
Mnd3_lclk_nmos_a[0] FLTBL CLKB_LATCH net336[0] VBN slvtnfet cpp=104n p_la=0
+ ulp=0 nf=1 l=20n w=160n m=1
Mnd3_lclk_nmos_a[1] FLTBL CLKB_LATCH net336[1] VBN slvtnfet cpp=104n p_la=0
+ ulp=0 nf=1 l=20n w=160n m=1
Mnd3_lclk_nmos_a[2] FLTBL CLKB_LATCH net336[2] VBN slvtnfet cpp=104n p_la=0
+ ulp=0 nf=1 l=20n w=160n m=1
XLSB[0] VDDPI VSS VBP VBN LSB LS net341
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=256n
+ wp2=256n
XLSB[1] VDDPI VSS VBP VBN LSB LS net341
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=256n
+ wp2=256n
Xnd2_clkenab[0] VDDPI VSS VBP VBN CLKB_LATCH CLKFLT DFTCLKEN
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=240n
+ wp2=240n
Xnd2_clkenab[1] VDDPI VSS VBP VBN CLKB_LATCH CLKFLT DFTCLKEN
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=240n
+ wp2=240n
Xnd2_clkenab[2] VDDPI VSS VBP VBN CLKB_LATCH CLKFLT DFTCLKEN
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=240n
+ wp2=240n
Xnd3_lclk[0] VDDPI VSS VBP VBN FLTBL CLKB_LATCH FLOAT LSB
+ mm19a04_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=0 p_la_n2=0 p_la_n3=0 p_la_p1=0 p_la_p2=0 p_la_p3=0 ulp=0 ln1=20n
+ ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1 m_p2=1
+ m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=160n wn2=160n
+ wn3=160n wp1=240n wp2=240n wp3=240n
Xnd3_lclk[1] VDDPI VSS VBP VBN FLTBL CLKB_LATCH FLOAT LSB
+ mm19a04_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=0 p_la_n2=0 p_la_n3=0 p_la_p1=0 p_la_p2=0 p_la_p3=0 ulp=0 ln1=20n
+ ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1 m_p2=1
+ m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=160n wn2=160n
+ wn3=160n wp1=240n wp2=240n wp3=240n
Xnd3_lclk[2] VDDPI VSS VBP VBN FLTBL CLKB_LATCH FLOAT LSB
+ mm19a04_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=0 p_la_n2=0 p_la_n3=0 p_la_p1=0 p_la_p2=0 p_la_p3=0 ulp=0 ln1=20n
+ ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1 m_p2=1
+ m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=160n wn2=160n
+ wn3=160n wp1=240n wp2=240n wp3=240n
.ends

.subckt mm19a04_u_nr3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 VDD VSS
+ VBP VBN X A1 A2 A3 CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_n3=4n P_LA_p1=4n
+ P_LA_p2=4n P_LA_p3=4n ULP=0 ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n
+ m_n1=1 m_n2=1 m_n3=1 m_p1=1 m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1
+ nf_p2=1 nf_p3=1 wn1=120n wn2=120n wn3=120n wp1=320n wp2=320n wp3=320n
MNA1 X A1 VSS VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA3 X A3 VSS VBN slvtnfet cpp=cpp p_la=p_la_n3 ulp=ulp nf=nf_n3 l=ln3 w=wn3
+ m=m_n3
MNA2 X A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MPA3 net10 A3 VDD VBP slvtpfet cpp=cpp p_la=p_la_p3 ulp=ulp nf=nf_p3 l=lp3
+ w=wp3 m=m_p3
MPA2 net029 A2 net10 VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2
+ w=wp2 m=m_p2
MPA1 X A1 net029 VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
.ends

.subckt mm19a04_u_hs1prf_pw_gen VDDP VDDPI VSS VBP VBN PW LOG1 CLKFLT CLPSEBUF
+ DFTMASK DLYPW FLOAT_RET LS
MI72 PW CLPSEBUF VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
Mckdrv pwsvs CLKFLT VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=2
M11 PW CLMP VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
Mxback1ck CKGDN CLKDEL VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=320n m=1
MN3 pwsvs FLTBAR PW VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=2
Xnr2_ckdel1 VDDPI VSS VBP VBN CLKDELB CLKFLT CLMP
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=320n
+ wp2=320n
XFWD VDDPI VSS VBP VBN PWB1 PW net284
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
M0 net267 CLKFLT net268 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=319n
+ m=1
M65 net268 FLTBAR net267 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=319n
+ m=1
M8 VDDPI CLMP net267 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=319n m=1
Xnr2_clmp VDDPI VSS VBP VBN LSORDLTPWB DLYPW DFTMASK LS
+ mm19a04_u_nr3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=320n
+ wn2=320n wn3=320n wp1=320n wp2=320n wp3=320n
M12 PW PWB1 CKGDN VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
*XI38 VBP VBN PW mm19a04_u_init1
XI73 VDDPI_PWGEN VSS VBP VBN net284 CLPSEBUF mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=160n wp=160n
Xinv_ckdel2 VDDP VSS VBP VBN CLKDEL CLKDELB mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI40 VDDPI VSS VBP VBN FLTBAR FLOAT_RET mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=2 nf_n=1 nf_p=1 wn=320n
+ wp=320n
Xinv_clmp VDDP VSS VBP VBN CLMP LSORDLTPWB mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
M9 net268 PWB1 PW VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=319n m=1
Mclkpull VDDPI_PWGEN CLKDEL PW VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=319n m=1
MI70 VDDPI CLPSEBUF VDDPI_PWGEN VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=319n m=1
MIdummy VDDPI LOG1 CLMP VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
.ends

.subckt mm19a04_u_hs1prf_cenclock_dft_new VDDP VDDPI VSS VBP VBN FLOAT FLOATT
+ FLTBL LCLKB LCLKBIO LCLKT CKGATE FLOATB FLOATBD IN_2INV_ADDR LOG1 LS_INT
+ OUT_2INV OUT_4INV OUT_6INV CLKB CLKFLT CLPSEBUF DFTCLKEN DFTMASK DLYPW
+ FLOAT_RET LDFTX LMEB LS LS_ONLY
XIFLOAT_GEN VDDP VDDPI VSS VBP VBN CKGATE FLOAT CLKB CLPSEBUF DLYPW LDFTX LMEB
+ PW mm19a04_u_hs1prf_float_gen_new
Xinv_fltt[0] VDDP VSS VBP VBN FLOATT FLOATB mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=160n wp=160n
Xinv_fltt[1] VDDP VSS VBP VBN FLOATT FLOATB mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=160n wp=160n
Xinv_fltt[2] VDDP VSS VBP VBN FLOATT FLOATB mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=160n wp=160n
XIDCLK_GEN VDDP VDDPI VSS VBP VBN FLTIO LCLKBIO FLOATBD LS_INT OUT_2INV
+ OUT_4INV OUT_6INV CLKB_LATCH FLOAT FLOATB OUT_2INV OUT_4INV LS net471
+ mm19a04_u_hs1prf_data_latch_clock_gen
MI75 FLOATB FLOAT VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI74 VDDPI FLOAT FLOATB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=3
XADDR_LATCH_GEN VDDP VDDPI VSS VBP VBN CLKB_LATCH FLTBL LCLKB LCLKT net466
+ CLKFLT DFTCLKEN FLOAT IN_2INV_ADDR LS mm19a04_u_hs1prf_add_we_latch_clk_gen
XPWGEN VDDP VDDPI VSS VBP VBN PW LOG1 CLKFLT CLPSEBUF DFTMASK DLYPW FLOAT_RET
+ LS_ONLY mm19a04_u_hs1prf_pw_gen
.ends

.subckt mm19a04_u_hs1prf_gcen_base_new VDDP VDDPI VSS VBP VBN CLKB CLKDEL FLOAT
+ FLOATT LBKADR LCLKB LCLKBIO LCLKT LME LWE LWE_DFT LXADR[0] LXADR[1] LXADR[2]
+ LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] MCLKB MCLKT
+ T1T CKGATE IN_2INV_ADDR LDFTX LOG1 LSORMEORDFTCLKEN LS_INT MEB_LT
+ MEORDFTCLKEN OUT_2INV OUT_4INV OUT_6INV BKADR CLK CLKFLT CLK_MUXB CLPSEBUF
+ DFTCLKEN DFTMASK DLYPW FLOAT_RET LS ME MEB_I MEORDFTCLKEN_IN TEST1 WE XADR[0]
+ XADR[1] XADR[2] XADR[3] XADR[4] XADR[5] XADR[6] XADR[7] YADR[0] YADR[1]
XTCLK_GEN VDDP VDDPI VSS VBP VBN FLOAT T1T TCLKB mm19a04_u_hs1prf_tclk
XCONTROL VDDP VDDPI VSS VBP VBN TCLKB CLKT LME LMEWRB LWE LWE_DFT MCLKB MCLKT
+ MEB_LT MEORDFTCLKEN T1T CLKFLT DFTCLKEN LCLKB LCLKT LDFTX ME MEB_I TEST1 WE
+ mm19a04_u_control_dft_hs1prf
XADDR_LATCH VDDP VDDPI VSS VBP VBN LBKADR LXADR[0] LXADR[1] LXADR[2] LXADR[3]
+ LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] BKADR LCLKB LCLKT
+ XADR[0] XADR[1] XADR[2] XADR[3] XADR[4] XADR[5] XADR[6] XADR[7] YADR[0]
+ YADR[1] mm19a04_u_hs1prf_adr_latches_cm4bk2
XCLOCK VDDP VDDPI VSS VBP VBN FLOAT FLOATT FLTBL LCLKB LCLKBIO LCLKT CKGATE
+ FLOATB FLOATB IN_2INV_ADDR LOG1 LS_INT OUT_2INV OUT_4INV OUT_6INV CLK_MUXB
+ CLKFLT CLPSEBUF DFTCLKEN DFTMASK DLYPW FLOAT_RET LDFTX LMEWRB
+ LSORMEORDFTCLKEN LS mm19a04_u_hs1prf_cenclock_dft_new
Xinv_clk VDDPI VSS VBP VBN CLKB CLK mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=5 m_p=5 nf_n=1 nf_p=1 wn=320n
+ wp=240n
Xinv_clkb VDDPI VSS VBP VBN CLKDEL CLKB mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=4 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI106 VDDPI VSS VBP VBN net190 LS mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=1 nf_n=1 nf_p=1 wn=160n
+ wp=235n
XI108[0] VDDPI VSS VBP VBN LSORMEORDFTCLKEN net190 MEORDFTCLKEN_IN
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=160n
+ wp2=160n
XI108[1] VDDPI VSS VBP VBN LSORMEORDFTCLKEN net190 MEORDFTCLKEN_IN
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=160n
+ wp2=160n
.ends

.subckt mm19a04_u_hs1prf_gcen VDDA VDDF VDDP VDDPI VDDPI_LOG1 VSS VBP VBN
+ ARYSDB ARYSDB_BC1 ARYSDB_BC2 CKGATE CLKDEL DEF_MODE FAST1_MODE FAST2_MODE
+ LBKADR LCLKB LCLKBIO LCLKT LITESLP LME LSDB LSDB_BC1 LSDB_BC2 LWE LWEIB
+ LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+ LYADR[0] LYADR[1] MCLKB MCLKT RAB[0] RAB[1] RM3CNT RMT[0] RMT[1] RMT[2]
+ RMT[3] RWLCKB T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2]
+ WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] CKGATE_GCEN CLKB CLPSEBUF DEF1 DEF12B_PROG
+ DEF12_PROG DEF1B DEF2 DEF2B DEF_PROG FISO FLOAT IN_2INV_ADDR LOG0 LOG1
+ LOG1_RM LSORMEORDFTCLKEN LS_INT MEB_I MEB_LT MEORDFTCLKEN MEORDFTCLKEN_IN
+ OUT_2INV OUT_4INV OUT_6INV PLBKADR RM3CLPSB RSCEN RSCIN RSCLK RSCOUT RSCRST
+ SDCLPSB WFLOAT BC1 BC2 BKADR CENDP CLK CLKFLT CLK_MUXB DFTCLKEN DFTMASK_BCEN
+ DISCHG DLYPW FLOAT_RET LDFTX LS ME PROCOM[0] PROCOM[1] RA[0] RA[1] RM[0]
+ RM[1] RM[2] RM[3] RMDEF1[0] RMDEF1[1] RMDEF1[2] RMDEF1[3] RMDEF1_PROCOM00[0]
+ RMDEF1_PROCOM00[1] RMDEF1_PROCOM00[2] RMDEF1_PROCOM00[3] RMDEF1_PROCOM01[0]
+ RMDEF1_PROCOM01[1] RMDEF1_PROCOM01[2] RMDEF1_PROCOM01[3] RMDEF2[0] RMDEF2[1]
+ RMDEF2[2] RMDEF2[3] RMDEF2_PROCOM00[0] RMDEF2_PROCOM00[1] RMDEF2_PROCOM00[2]
+ RMDEF2_PROCOM00[3] RMDEF2_PROCOM01[0] RMDEF2_PROCOM01[1] RMDEF2_PROCOM01[2]
+ RMDEF2_PROCOM01[3] RME RMENI[0] RMENI[1] RMENI[2] RMSLOW[0] RMSLOW[1]
+ RMSLOW[2] RMSLOW[3] SD TEST1 TEST_RNM WA[0] WA[1] WA[2] WE WMDEF1[0]
+ WMDEF1[1] WMDEF1[2] WMDEF1[3] WMDEF1_PROCOM00[0] WMDEF1_PROCOM00[1]
+ WMDEF1_PROCOM00[2] WMDEF1_PROCOM00[3] WMDEF1_PROCOM01[0] WMDEF1_PROCOM01[1]
+ WMDEF1_PROCOM01[2] WMDEF1_PROCOM01[3] WMDEF2[0] WMDEF2[1] WMDEF2[2] WMDEF2[3]
+ WMDEF2_PROCOM00[0] WMDEF2_PROCOM00[1] WMDEF2_PROCOM00[2] WMDEF2_PROCOM00[3]
+ WMDEF2_PROCOM01[0] WMDEF2_PROCOM01[1] WMDEF2_PROCOM01[2] WMDEF2_PROCOM01[3]
+ WMSLOW[0] WMSLOW[1] WMSLOW[2] WMSLOW[3] WPULSE[0] WPULSE[1] WPULSE[2] XADR[0]
+ XADR[1] XADR[2] XADR[3] XADR[4] XADR[5] XADR[6] XADR[7] YADR[0] YADR[1]
XLSDB_BC_CTRL VDDP VSS VBP VBN LSDB LSDB_BC1 LSDB_BC2 LOG1 BC1 BC2 SD
+ mm19a04_u_bc_control_hs1prf
XRMCTRL VDDP VDDPI VDDPI_LOG1 VSS VBP VBN DEF1 DEF1B DEF2 DEF2B DEF_MODE
+ FAST1_MODE FAST2_MODE RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] WMT[0] WMT[1] WMT[2]
+ WMT[3] LOG0 LOG1 LOG1_RM DEF12B_PROG DEF12_PROG DEF_PROG FLOAT LSDB PROCOM[0]
+ PROCOM[1] RM[0] RM[1] RM[2] RM[3] RMDEF1[0] RMDEF1[1] RMDEF1[2] RMDEF1[3]
+ RMDEF1_PROCOM00[0] RMDEF1_PROCOM00[1] RMDEF1_PROCOM00[2] RMDEF1_PROCOM00[3]
+ RMDEF1_PROCOM01[0] RMDEF1_PROCOM01[1] RMDEF1_PROCOM01[2] RMDEF1_PROCOM01[3]
+ RMDEF2[0] RMDEF2[1] RMDEF2[2] RMDEF2[3] RME RMENI[0] RMENI[1] RMENI[2]
+ RMSLOW[0] RMSLOW[1] RMSLOW[2] RMSLOW[3] WMDEF1[0] WMDEF1[1] WMDEF1[2]
+ WMDEF1[3] WMDEF1_PROCOM00[0] WMDEF1_PROCOM00[1] WMDEF1_PROCOM00[2]
+ WMDEF1_PROCOM00[3] WMDEF1_PROCOM01[0] WMDEF1_PROCOM01[1] WMDEF1_PROCOM01[2]
+ WMDEF1_PROCOM01[3] WMDEF2[0] WMDEF2[1] WMDEF2[2] WMDEF2[3] WMSLOW[0]
+ WMSLOW[1] WMSLOW[2] WMSLOW[3] mm19a04_u_hs1prf_rmctrl
XLSLTCH VDDP VDDPI VSS VBP VBN LITESLP RWLCKB LS FLOAT FLOAT
+ mm19a04_u_hs1prf_pg_lsltch
XCTRLWR VDDP VDDPI VSS VBP VBN CLKB CLKDEL FLOAT FLOATT LBKADR LCLKB LCLKBIO
+ LCLKT LME LWE LWE_DFT LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+ LXADR[6] LXADR[7] LYADR[0] LYADR[1] MCLKB MCLKT T1T CKGATE_GCEN IN_2INV_ADDR
+ LDFTX LOG1 LSORMEORDFTCLKEN LS_INT MEB_LT MEORDFTCLKEN OUT_2INV OUT_4INV
+ OUT_6INV BKADR CLK CLKFLT CLK_MUXB CLPSEBUF DFTCLKEN DFTMASK_BCEN DLYPW
+ FLOAT_RET LS ME MEB_I MEORDFTCLKEN_IN TEST1 WE XADR[0] XADR[1] XADR[2]
+ XADR[3] XADR[4] XADR[5] XADR[6] XADR[7] YADR[0] YADR[1]
+ mm19a04_u_hs1prf_gcen_base_new
XINV_WE1 VDDPI VSS VBP VBN LWEIB LWE_DFT mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=8 m_p=8 nf_n=1 nf_p=1
+ wn=222n wp=222n
XI126[0] VDDPI VSS VBP VBN WABUF[0] WA[0] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI126[1] VDDPI VSS VBP VBN WABUF[1] WA[1] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=240n wp=240n
Xinv_testrnm VDDPI VSS VBP VBN TEST_RNMB TEST_RNM
+ mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=240n wp=240n
XI127[0] VDDPI VSS VBP VBN WPBUF[0] WPULSE[0] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI127[1] VDDPI VSS VBP VBN WPBUF[1] WPULSE[1] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI127[2] VDDPI VSS VBP VBN WPBUF[2] WPULSE[2] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI122[0] VDDPI VSS VBP VBN RAB[0] RA[0] mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI122[1] VDDPI VSS VBP VBN RAB[1] RA[1] mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI176[0] VDDPI VSS VBP VBN WABUF[2] WA[0] WA[1]
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=240n
+ wp2=240n
XI176[1] VDDPI VSS VBP VBN WABUF[2] WA[0] WA[1]
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=240n
+ wp2=240n
.ends

.subckt mm19a04_u_hs1prf_pg_arysd_buf VDDA VSS VBP VBN ARYSD ARYSD_BC1
+ ARYSD_BC2 ARYSDB ARYSDB_BC1 ARYSDB_BC2 SDCLPSB
XI12 VDDA VSS VBP VBN ARYSD ARYSDB_SDCLPSB mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=2 nf_n=1 nf_p=1
+ wn=323n wp=721n
XI9 VDDA VSS VBP VBN ARYSD_BC1 ARYSDB_BC1 mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=640n wp=721n
XI11 VDDA VSS VBP VBN ARYSD_BC2 ARYSDB_BC2 mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=640n wp=721n
XI17 VDDA VSS VBP VBN ARYSDB_SDCLPSB ARYSDB SDCLPSB
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=4 m_n2=4
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=323n wn2=323n wp1=721n
+ wp2=721n
.ends

.subckt mm19a04_u_hs1prf_gcenbuf VDDA VDDP VDDPI VSS VBP VBN DCLKT RASSIST[0]
+ RASSIST[1] ARYSD ARYSDB ARYSDB_BC1 ARYSDB_BC2 ARYSD_BC1 ARYSD_BC2 DLYPDB
+ GSE_DB GSE_DT LDFTYBUF LOG0 LOG1 PROCOML LCLKBIO RAB[0] RAB[1] SDCLPSB
XIdclktdriver VDDPI VSS VBP VBN DCLKT GDCLKB mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=7 m_p=12 nf_n=1 nf_p=1
+ wn=525n wp=721n
XIdclkt VDDPI VSS VBP VBN GDCLKB LCLKBIO mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=5 m_p=2 nf_n=1 nf_p=1
+ wn=525n wp=721n
XIRA[0] VDDPI VSS VBP VBN RASSIST[0] RAB[0] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=2 nf_n=1 nf_p=1
+ wn=320n wp=721n
XIRA[1] VDDPI VSS VBP VBN RASSIST[1] RAB[1] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=2 nf_n=1 nf_p=1
+ wn=320n wp=721n
XIPG_ARYSD_BUF VDDA VSS VBP VBN ARYSD ARYSD_BC1 ARYSD_BC2 ARYSDB ARYSDB_BC1
+ ARYSDB_BC2 SDCLPSB mm19a04_u_hs1prf_pg_arysd_buf
.ends

.subckt mm19a04_u_output_drv_gf22_cm4 VDDP VDDPI VSS VBP VBN Q_OUT Q_IN
XI4 VDDPI VSS VBP VBN Q_OUT Q_IN mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=3 nf_n=1 nf_p=1 wn=320n
+ wp=320n
.ends

.subckt mm19a04_u_hs1prf_do VDDP VDDPI VDDPI_DR VSS VBP VBN DIB_LT D_AL Q
+ WEM_AL WIB LQB DCLKT DIN DINB LDFTYBUF LQB_N[0] LQB_N[1] LQB_P[0] LQB_P[1]
+ SEB SET WEM WEMB
XI69_2 VDDPI VSS VBP VBN DWEMB DINT WEMH
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=320n
+ wp2=320n
XI16 VDDPI VSS VBP VBN DWEMT DINB WEMH
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=320n
+ wp2=320n
XI69 VDDPI VSS VBP VBN DWEMB DINT WEMH
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=240n
+ wp2=240n
XI65 VDDP VDDPI_DR VSS VBP VBN Q LQB mm19a04_u_output_drv_gf22_cm4
XI57 VDDPI VSS VBP VBN LDFTYBUFB LDFTYBUF mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=240n
XI59 VDDPI VSS VBP VBN WEM_AL WEM mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=160n
XI61 VDDPI VSS VBP VBN WEMH WEMB mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=240n
XI4 VDDPI VSS VBP VBN D_AL DIN mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI70 VDDPI VSS VBP VBN DINT DINB mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI207[1] VDDPI VSS VBP VBN DIB_LT DWEMT SEB SET
+ mm19a04_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n
+ wp1=240n wp2=240n
XI207[0] VDDPI VSS VBP VBN DIB_LT DWEMT SEB SET
+ mm19a04_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n
+ wp1=240n wp2=240n
XI68 VDDPI VSS VBP VBN WIB DIB_LT LDFTYBUF LDFTYBUFB
+ mm19a04_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n
+ wp1=320n wp2=320n
XI63 VDDPI VSS VBP VBN WIB DWEMB LDFTYBUFB LDFTYBUF
+ mm19a04_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n
+ wp1=320n wp2=320n
.ends

.subckt mm19a04_u_dclk_ct_cb_gen VDDPI VSS VBP VBN CB CT DCLK
XI2 VDDPI VSS VBP VBN CB CT mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=0
+ p_la_p=0 ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n wp=320n
XI1 VDDPI VSS VBP VBN CT DCLKB mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=0
+ p_la_p=0 ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n wp=320n
XI0 VDDPI VSS VBP VBN DCLKB DCLK mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=160n
+ wp=160n
.ends

.subckt mm19a04_u_l2bio_hs1prf VDDP VDDPI VSS VBP VBN Q QB CB CT DIN
XI7 VDDPI VSS VBP VBN Q QB mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n wp=240n
XI11_2 VDDPI VSS VBP VBN QB DIN CB CT
+ mm19a04_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n
+ wp1=240n wp2=240n
XI3 VDDPI VSS VBP VBN QB Q CT CB
+ mm19a04_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n
+ wp1=240n wp2=240n
XI11 VDDPI VSS VBP VBN QB DIN CB CT
+ mm19a04_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n
+ wp1=240n wp2=240n
.ends

.subckt mm19a04_u_di_dft_hs1prf VDDP VDDPI VSS VBP VBN CB CT LDIB LWIB WBI WTI
+ LQB SEB SET DCLKT DIB WIB
XI51 VDDPI VSS VBP VBN CB CT DCLKT mm19a04_u_dclk_ct_cb_gen
XD VDDP VDDPI VSS VBP VBN LDIB WTI CB CT DIB mm19a04_u_l2bio_hs1prf
XW VDDP VDDPI VSS VBP VBN LWIB WBI CB CT WIB mm19a04_u_l2bio_hs1prf
.ends

.subckt mm19a04_u_data_drv VDDP VDDPI VSS VBP VBN DATA_OUT DATA_IN
XI56 VDDPI VSS VBP VBN DATA_OUT DATA_IN mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=300n
+ wp=240n
.ends

.subckt mm19a04_u_hs1prf_xmux VDDP VDDPI VDDPI_RL VSS VBP VBN QBBI WB WT LQB
+ IV_WB IV_WT PDB QBB QTB
XI69 VDDP VDDPI VSS VBP VBN WT IV_WT mm19a04_u_data_drv
XI68 VDDP VDDPI VSS VBP VBN WB IV_WB mm19a04_u_data_drv
.ends

.subckt mm19a04_u_hs1prf_gio1 VDDP VDDPI VDDPI_DR VSS VBP VBN CB CT D_AL LDIB
+ LWIB ND_WB ND_WT Q WB WEM_AL WT DIB LOG0 LOG1 LQB DCLKT DIN DINB IV_WB IV_WT
+ LDFTYBUF PDB QBB QTB SEB SET WEM WEMB
XDO VDDP VDDPI VDDPI_DR VSS VBP VBN DIB D_AL Q WEM_AL WIB LQB DCLKT DIN DINB
+ LDFTYBUF QBBI QBBI QBB QBB SEB SET WEM WEMB mm19a04_u_hs1prf_do
XDI VDDP VDDPI VSS VBP VBN CB CT LDIB LWIB ND_WB ND_WT LQB SEB SET DCLKT DIB
+ WIB mm19a04_u_di_dft_hs1prf
X0 VDDP VDDPI net151 VSS VBP VBN QBBI WB WT LQB IV_WB IV_WT PDB QBB QTB
+ mm19a04_u_hs1prf_xmux
.ends

.subckt mm19a04_u_hs1prf_giom4x1 VDDA VDDP VDDPI VDDPI_DR VSS VBP VBN CB CT
+ D_AL LDIB LWIB ND_WB ND_WT Q WB WEM_AL WT DIB LOG0 LOG1 LQB D DCLKT DINB
+ DLYPDB IV_WB IV_WT LDFTYBUF SE_DB SE_DT WEM WEMB
Xgio0 VDDP VDDPI VDDPI VSS VBP VBN CB CT D_AL LDIB LWIB ND_WB ND_WT Q WB WEM_AL
+ WT DIB LOG0 LOG1 LQB DCLKT D DINB IV_WB IV_WT LDFTYBUF DLYPDB net102 net104
+ SE_DB SE_DT WEM WEMB mm19a04_u_hs1prf_gio1
.ends

.subckt mm19a04_u_logrepedge VDDP VSS VBP VBN LOG0 LOG1
MPLOG VDDP LOG0 LOG1 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=128n m=10
M0 LOG0 LOG1 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=128n m=10
.ends

.subckt mm19a04_u_hs1prf_capgio VDDA VDDP VDDPI VSS VBP VBN LOG0 LOG1 PWDO
+ VEDGE
XI8 VDDP VSS VBP VBN LOG0 LOG1 mm19a04_u_logrepedge
.ends

.subckt mm19a04_u_WACLK_PG_DELAY VDDP VDDPI VSS VBP VBN TAP1 TAP2 TAP3 LOG0
+ LOG1 TAP0
XITAP2_DR1 VDDPI VSS VBP VBN net214 TAP1 TAP1 TAP1
+ mm19a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=160n wp2=160n
XITAP3_DR2 VDDPI VSS VBP VBN TAP3 net221 net221 net221
+ mm19a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n
+ wp1=320n wp2=320n
XITAP1_DR1 VDDPI VSS VBP VBN net213 TAP0 TAP0 TAP0
+ mm19a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=160n wp2=160n
XITAP3_DR1 VDDPI VSS VBP VBN net221 TAP2 TAP2 TAP2
+ mm19a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=160n wp2=160n
XITAP_DR2 VDDPI VSS VBP VBN TAP1 net213 net213 net213
+ mm19a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n
+ wp1=320n wp2=320n
XITAP2_DR2 VDDPI VSS VBP VBN TAP2 net214 net214 net214
+ mm19a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n
+ wp1=320n wp2=320n
.ends

.subckt mm19a04_u_tg_bulk_n_vt3_p_vt3 VBP VBN A B S SB CPP=104n P_LA_n=4n
+ P_LA_p=4n ULP=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
MNS A S B VBN slvtnfet cpp=cpp p_la=p_la_n ulp=ulp nf=nf_n l=ln w=wn m=m_n
MPSB A SB B VBP slvtpfet cpp=cpp p_la=p_la_p ulp=ulp nf=nf_p l=lp w=wp m=m_p
.ends

.subckt mm19a04_u_WACLK_DELAY_HS1PRF VDDP VDDPI VSS VBP VBN WAPRCLK_OUT LOG1
+ WAPRCLK_IN WPBUFB[0] WPBUFB[1]
XI10_NAND VDDPI VSS VBP VBN CB WPBUFB[0] WP[1]
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=160n
+ wp2=160n
XI00_NAND VDDPI VSS VBP VBN AB WPBUFB[0] WPBUFB[1]
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=160n
+ wp2=160n
XI11_NAND VDDPI VSS VBP VBN DB WP[0] WP[1]
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=160n
+ wp2=160n
XI01_NAND VDDPI VSS VBP VBN BB WP[0] WPBUFB[1]
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=160n
+ wp2=160n
XIWP_INV[0] VDDPI VSS VBP VBN WP[0] WPBUFB[0] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=160n
XIWP_INV[1] VDDPI VSS VBP VBN WP[1] WPBUFB[1] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=160n
XI11_DR1 VDDPI VSS VBP VBN net76 net77 mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=160n
XI11_DR2 VDDPI VSS VBP VBN net74 net76 mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=160n
XI10_DR1 VDDPI VSS VBP VBN net72 net73 mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=160n
XI01_DR1 VDDPI VSS VBP VBN net68 WAPRCLK_IN mm19a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=160n
XI01_DR2 VDDPI VSS VBP VBN net73 net68 mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=160n
XI10_DR2 VDDPI VSS VBP VBN net77 net72 mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=160n
XI01_INV VDDPI VSS VBP VBN B BB mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=160n
XI10_INV VDDPI VSS VBP VBN C CB mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=160n
XI11_INV VDDPI VSS VBP VBN D DB mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=160n
XI00_INV VDDPI VSS VBP VBN A AB mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=160n
XI11_TR VBP VBN net74 WAPRCLK_OUT D DB mm19a04_u_tg_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=160n
XI10_TR VBP VBN net77 WAPRCLK_OUT C CB mm19a04_u_tg_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=160n
XI01_TR VBP VBN net73 WAPRCLK_OUT B BB mm19a04_u_tg_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=160n
XI00_TR VBP VBN WAPRCLK_IN WAPRCLK_OUT A AB mm19a04_u_tg_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=120n wp=160n
.ends

.subckt mm19a04_u_hs_wa_cntrl VDDP VDDPI VSS VBP VBN TAP0 TAP1 TAP2 TAP3
+ WAPRCLK LOG0 LOG1 RBLWA TEST_RNMB WABUF[2] WPBUF[0] WPBUF[1] WPBUF[2] LWEIB
+ PRCKDLY
MPA2 VDDPI net186 net10 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=214n
+ m=3
MPA1 net10 RBLWA TAP0 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=214n m=3
MNA2 TAP0 net186 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=4
MNA1 TAP0 RBLWA VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=4
XI77 VDDPI VSS VBP VBN WAPRCLK TAP0 PRCKDLY_INT
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=7 m_n2=7
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=248n wn2=248n wp1=480n
+ wp2=480n
XI41 VDDP VDDPI VSS VBP VBN TAP1 TAP2 TAP3 LOG0 LOG1 TAP0
+ mm19a04_u_WACLK_PG_DELAY
XI47 VDDP VDDPI VSS VBP VBN PRCKDLY_INT LOG1 PRCKDLY WPBUF[0] WPBUF[1]
+ mm19a04_u_WACLK_DELAY_HS1PRF
XI65 VDDPI VSS VBP VBN net188 TEST_RNMB mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=160n
XI63 VDDPI VSS VBP VBN net186 net346 mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=160n
XI64 VDDPI VSS VBP VBN net346 net188 WABUF[2] LWEIB
+ mm19a04_u_nr3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=120n
+ wn2=120n wn3=120n wp1=480n wp2=480n wp3=480n
.ends

.subckt mm19a04_u_hs1prf_sactrl_wa VDDA VDDF VDDP VDDPI VSS VBP VBN PM[0] PM[1]
+ PM[2] PM[3] BYP_VLOAD CENDP DEF_MODE DLYPW ENLPGB FAST1_MODE FAST2_MODE FLOAT
+ FLOATT FLOAT_RET LBKADR[0] LCGTHB LCGTHB_PCHG LCGTHLV LDFTX LITESLP LOG0 LOG1
+ LWEIB LWERD LWEWR PRCKDLY RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2]
+ RMT[3] RWLB RWLBHV RWLBLV T1T TAP0 TAP1 TAP2 TAP3 TEST_RNMB WABUF[0] WABUF[1]
+ WABUF[2] WAPRCLK WAPRCLKBUFB_RETI WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0]
+ WPBUF[1] WPBUF[2] LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+ LXADR[6] LXADR[7] LYADR[0] LYADR[1]
XI561 VDDP VDDPI VSS VBP VBN TAP0 TAP1 TAP2 TAP3 WAPRCLK LOG0 LOG1 RBLWA
+ TEST_RNMB WABUF[2] WPBUF[0] WPBUF[1] WPBUF[2] LWEIB PRCKDLY
+ mm19a04_u_hs_wa_cntrl
.ends

.subckt mm19a04_u_hs1prf_sacbuf_wa VDDA VDDP VDDPI VSS VBP VBN WA[0] WA[1]
+ WAPRCLKBUF ARYSD ARYSD_BC1 ARYSD_BC2 DLYPDB LCGTH PROCOML RASSIST[0]
+ RASSIST[1] SAEB_INT WAPRCLKBUFB_RETI WAB[0] WAB[1] WAPRCLK
XI118[0] VDDPI VSS VBP VBN WAB_INT[0] WAB[0] mm19a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI118[1] VDDPI VSS VBP VBN WAB_INT[1] WAB[1] mm19a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XIWAPRCLK_DR VDDPI VSS VBP VBN net148 net166 mm19a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=3 nf_n=1 nf_p=1
+ wn=361n wp=336n
XIWA_DR[0] VDDPI VSS VBP VBN WA[0] WAB_INT[0] mm19a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=361n wp=336n
XIWA_DR[1] VDDPI VSS VBP VBN WA[1] WAB_INT[1] mm19a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=361n wp=336n
XI116 VDDPI VSS VBP VBN WAPRCLKBUF net148 mm19a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=7 m_p=6 nf_n=1 nf_p=1
+ wn=500n wp=584n
XI8 VDDPI VSS VBP VBN net166 WAPRCLK mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=160n
.ends

.subckt mm19a04_u_WA_CAP_NMOSPD_RPB128_hs1prf VSS VSS_WA VBP VBN CC_0 CC_1
+ PRCHBWA
MI230 VSS_WA PRCHBWA VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=500n
+ m=4
MI233 CC_1 VSS_WA CC_1 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=721n
+ m=4
MI232 CC_0 VSS_WA CC_0 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=750n
+ m=4
MI233_0 CC_1 VSS_WA CC_1 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=361n
+ m=10
.ends

.subckt mm19a04_u_WA_CELL_RPB128_CM4_hs1prf VDDP VDDPI VSS VSS_WA VBP VBN WA[0]
+ WA[1] WAPRCLK
XI81 VDDPI VSS VBP VBN PRCHB_WA WAPRCLK mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1 wn=120n
+ wp=160n
XI80 VDDPI VSS VBP VBN net599 PRCHB_WA mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=160n
XI76 VSS VSS_WA VBP VBN CC_0 CC_1 PRCHB_WA
+ mm19a04_u_WA_CAP_NMOSPD_RPB128_hs1prf
XI78 VDDPI VSS VBP VBN CC_1 net599 WA[1]
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=800n wn2=800n wp1=150n
+ wp2=150n
XI79 VDDPI VSS VBP VBN CC_0 net599 WA[0]
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=533n wn2=533n wp1=150n
+ wp2=150n
.ends

.subckt mm19a04_u_hs1prf_sacm4x1_wa_128 VDDA VDDP VDDPI VSS VSS_WA VBP VBN LOG1
+ LQB RB RT WA[0] WA[1] WAPRCLKBUF WAPRCLKBUFB_RETI WB WB_IN WT WT_IN
XI82 VDDP VDDPI VSS VSS_WA VBP VBN WA[0] WA[1] WAPRCLKBUF
+ mm19a04_u_WA_CELL_RPB128_CM4_hs1prf
.ends

.subckt mm19a04_u_hs1prf_capsac_wa VDDA VDDP VDDPI VSS VBP VBN LOG0 LOG1 PWDO
+ VEDGE WAPRCLKBUF WAPRCLKBUFB_RETI
XIWR_RETURN VDDPI VSS VBP VBN WAPRCLKBUFB_RETI net23
+ mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=10 m_p=10 nf_n=1 nf_p=1 wn=128n wp=128n
XI87 VDDPI VSS VBP VBN net33 WAPRCLKBUF mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=128n
+ wp=128n
XI28 VDDPI VSS VBP VBN net23 net33 mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=128n
+ wp=128n
.ends

.subckt mm19a04_u_predec_2to4_hs1prf VDDP VDDPI VSS VBP VBN A[1] PM[0] PM[1]
+ PM[2] PM[3] AB[0] AB[1] PA[1] PAB[1]
Xinv_adr1 VDDPI VSS VBP VBN A[1] AB[1] mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=1 nf_n=1 nf_p=1 wn=200n
+ wp=360n
Xinv_adr0 VDDPI VSS VBP VBN A[0] AB[0] mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=1 nf_n=1 nf_p=1 wn=200n
+ wp=360n
XI77 VDDPI VSS VBP VBN PM[2] A[0] PA[1]
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=200n wn2=200n wp1=360n
+ wp2=360n
XI77_1 VDDPI VSS VBP VBN PM[2] A[0] PA[1]
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=200n wn2=200n wp1=360n
+ wp2=360n
XI80_1 VDDPI VSS VBP VBN PM[3] AB[0] PA[1]
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=200n wn2=200n wp1=360n
+ wp2=360n
XI78 VDDPI VSS VBP VBN PM[1] AB[0] PAB[1]
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=200n wn2=200n wp1=360n
+ wp2=360n
XI79 VDDPI VSS VBP VBN PM[0] A[0] PAB[1]
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=200n wn2=200n wp1=360n
+ wp2=360n
XI80 VDDPI VSS VBP VBN PM[3] AB[0] PA[1]
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=200n wn2=200n wp1=360n
+ wp2=360n
XI78_1 VDDPI VSS VBP VBN PM[1] AB[0] PAB[1]
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=200n wn2=200n wp1=360n
+ wp2=360n
XI79_1 VDDPI VSS VBP VBN PM[0] A[0] PAB[1]
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=200n wn2=200n wp1=360n
+ wp2=360n
.ends

.subckt mm19a04_u_mux_2x1_modesel VDDP VDDPI VSS VBP VBN OUT 0_1 1 SEL SELB
XI35 VBP VBN 1 OUT SEL SELB mm19a04_u_tg_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n wp=320n
XI29 VBP VBN 0_1 OUT SELB SEL mm19a04_u_tg_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n wp=320n
.ends

.subckt mm19a04_u_logrep_hs1prf_gf22 VDDP VSS VBP VBN LOG0 LOG1
MPLOG VDDP LOG0 LOG1 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=4
M0 LOG0 LOG1 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=4
.ends

.subckt mm19a04_u_mux_2x1_ulvt_pc_hs1prf_rd_wr VDDP VDDPI VSS VBP VBN OUT 0_1 1
+ SEL1 SEL2
XI561 VDDPI VSS VBP VBN SEL_1_2_B net103 SEL1
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=240n
+ wp2=240n
XI562 VDDPI VSS VBP VBN SEL_1_2 SEL_1_2_B mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=160n wp=240n
XI34 VDDPI VSS VBP VBN SEL1B SEL1 mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=240n
XI46 VDDPI VSS VBP VBN net103 SEL2 mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=160n
+ wp=240n
XI29 VBP VBN 0_1 OUT SEL1B SEL1 mm19a04_u_tg_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=160n
+ wp=240n
XI35 VBP VBN 1 OUT SEL_1_2 SEL_1_2_B mm19a04_u_tg_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=160n
+ wp=240n
.ends

.subckt mm19a04_u_hs1prf_sac_pwmg VDDA VDDP VDDPI VSS VBP VBN LCGTB LCGTHB_DR0
+ LCGTHLV LCGTH_PCHG ENLPGB LITESLP RM3CNT
XI16 VDDPI VSS VBP VBN LCGTH_PCHG LCGTB mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI0 VDDP VSS VBP VBN LCGTHB_DR0 LCGTHLV mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
Mdummy13x VDDP VDDP VDDPI VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
XI7 VDDP VSS VBP VBN LCGTB ENLPGB LITESLP
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI22 VDDP VSS VBP VBN LCGTHLV RM3CNT LCGTB
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
.ends

.subckt mm19a04_u_aoi21_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 VDD VSS
+ VBP VBN X A1 A2 B CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_n3=4n P_LA_p1=4n
+ P_LA_p2=4n P_LA_p3=4n ULP=0 ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n
+ m_n1=5 m_n2=5 m_n3=5 m_p1=5 m_p2=5 m_p3=5 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1
+ nf_p2=1 nf_p3=1 wn1=300n wn2=300n wn3=300n wp1=400n wp2=400n wp3=400n
MNA1 X A1 net26 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 net26 A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n3 ulp=ulp nf=nf_n3 l=ln3
+ w=wn3 m=m_n3
MNB X B VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MPA2 XP A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
MPA1 XP A1 VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MPB X B XP VBP slvtpfet cpp=cpp p_la=p_la_p3 ulp=ulp nf=nf_p3 l=lp3 w=wp3
+ m=m_p3
.ends

.subckt mm19a04_u_hs1prf_saetrack VDDPI VNWP VSS VBP VBN SAPRCH SAED SAOFF
*XI54 VBP VBN SAPRCH mm19a04_u_init0
M4 VDDPI SAOFF SAPRCH VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n m=4
M7 net0148 SAED SAPRCH VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n
+ m=1
MPA VDDPI SAPRCHB net0148 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n
+ m=1
XFWD VDDPI VSS VBP VBN SAPRCHB SAPRCH mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=160n
M0 net047 SAED VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n m=4
M1 SAPRCH SAOFF net047 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n
+ m=4
M3 net0137 SAPRCHB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n
+ m=1
M2 SAPRCH SAOFF net0137 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n
+ m=1
.ends

.subckt mm19a04_u_hs1prf_sacbufctrl VDDP VDDPI VSS VBP VBN SAET SAPRT FLOAT
+ SAEDL SAEDR SAOFF STCLK
XI61 VDDPI VSS VBP VBN SAET STCLK net78 SAPRCHB
+ mm19a04_u_aoi21_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=5 m_n2=5 m_n3=5 m_p1=5
+ m_p2=5 m_p3=5 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=300n
+ wn2=300n wn3=300n wp1=400n wp2=400n wp3=400n
XGPRCH[0] VDDPI VSS VBP VBN SAPRT SAOFF SAPRCHB
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=320n
+ wp2=320n
XGPRCH[1] VDDPI VSS VBP VBN SAPRT SAOFF SAPRCHB
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=320n
+ wp2=320n
XGPRCH[2] VDDPI VSS VBP VBN SAPRT SAOFF SAPRCHB
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=320n
+ wp2=320n
XGPRCH[3] VDDPI VSS VBP VBN SAPRT SAOFF SAPRCHB
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=320n
+ wp2=320n
XGPRCH[4] VDDPI VSS VBP VBN SAPRT SAOFF SAPRCHB
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=320n
+ wp2=320n
XGPRCH[5] VDDPI VSS VBP VBN SAPRT SAOFF SAPRCHB
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=320n
+ wp2=320n
XGPRCH[6] VDDPI VSS VBP VBN SAPRT SAOFF SAPRCHB
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=320n
+ wp2=320n
XI52 VDDPI VDDP VSS VBP VBN SAPRCHT SAEDR SAOFF mm19a04_u_hs1prf_saetrack
XI62 VDDPI VSS VBP VBN net78 FLOAT mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1 wn=300n
+ wp=400n
XI50 VDDPI VSS VBP VBN SAPRCHB SAPRCHT mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1 wn=240n
+ wp=320n
.ends

.subckt mm19a04_u_hs1prf_sacbuf_dly_opt VDDP VDDPI VSS VBP VBN FLOAT SAOFFOUT
+ LWE_TESTRNM_RST RDT1B
MI51[0] net154 LWE_TESTRNM_RST VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=160n m=1
MI51[1] net154 LWE_TESTRNM_RST VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=160n m=1
MI54[0] net154 LWE_TESTRNM_RST VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=160n m=1
MI54[1] net154 LWE_TESTRNM_RST VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=160n m=1
XI44[0] net185[0] VSS VBP VBN net154 sadlyt1 T1T RDT1B
+ mm19a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n
+ wp1=160n wp2=160n
XI44[1] net185[1] VSS VBP VBN net154 sadlyt1 T1T RDT1B
+ mm19a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n
+ wp1=160n wp2=160n
XI0[0] net187[0] VSS VBP VBN net154 FLOAT RDT1B T1T
+ mm19a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n
+ wp1=160n wp2=160n
XI0[1] net187[1] VSS VBP VBN net154 FLOAT RDT1B T1T
+ mm19a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n
+ wp1=160n wp2=160n
XI35 VDDPI VSS VBP VBN sadlyb0 FLOAT mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI22 VDDPI VSS VBP VBN T1T RDT1B mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI30 VDDPI VSS VBP VBN sadlyt1 sadlyb0 mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI40 VDDPI VSS VBP VBN SAOFFOUT net154 mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=2 nf_n=1 nf_p=1 wn=240n
+ wp=320n
MI53[0] VDDPI LWE_TESTRNM_RST net187[0] VBP slvtpfet cpp=104n p_la=4n ulp=0
+ nf=1 l=20n w=160n m=1
MI53[1] VDDPI LWE_TESTRNM_RST net187[1] VBP slvtpfet cpp=104n p_la=4n ulp=0
+ nf=1 l=20n w=160n m=1
Mdummy18 VDDPI VDDP sadlyt1 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=1
MI52[0] VDDPI LWE_TESTRNM_RST net185[0] VBP slvtpfet cpp=104n p_la=4n ulp=0
+ nf=1 l=20n w=160n m=1
MI52[1] VDDPI LWE_TESTRNM_RST net185[1] VBP slvtpfet cpp=104n p_la=4n ulp=0
+ nf=1 l=20n w=160n m=1
.ends

.subckt mm19a04_u_hs1prf_rdctrl_opt VDDP VDDPI VSS VBP VBN LWERD LWEWR
+ LWE_TESTRNM_RST FLOAT TEST_RNM BKSA LDFTX LWEIB
XI34 VDDPI VSS VBP VBN LWERD LWE_TESTRNM_RST mm19a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=2 nf_n=1 nf_p=1
+ wn=160n wp=360n
XI14 VDDPI VSS VBP VBN net57 LDFTX mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=300n
+ wp=400n
XI5 VDDPI VSS VBP VBN CCLK TEST_RNM mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI6[0] VDDPI VSS VBP VBN LWE_TESTRNM_RST LWEIB CCLK
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=160n
+ wp2=160n
XI6[1] VDDPI VSS VBP VBN LWE_TESTRNM_RST LWEIB CCLK
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=160n
+ wp2=160n
XI16[0] VDDPI VSS VBP VBN LWEWR net57 LWEIB
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=160n
+ wp2=160n
XI16[1] VDDPI VSS VBP VBN LWEWR net57 LWEIB
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=160n
+ wp2=160n
XI16[2] VDDPI VSS VBP VBN LWEWR net57 LWEIB
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=160n
+ wp2=160n
XI16[3] VDDPI VSS VBP VBN LWEWR net57 LWEIB
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=160n
+ wp2=160n
XI16[4] VDDPI VSS VBP VBN LWEWR net57 LWEIB
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=160n
+ wp2=160n
XI16[5] VDDPI VSS VBP VBN LWEWR net57 LWEIB
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=160n
+ wp2=160n
.ends

.subckt mm19a04_u_rdctrl_sa_hs1prf VDDP VDDPI VSS VBP VBN LWERD LWEWR SAET
+ SAPRT FLOAT TEST_RNM BKSA LDFTX LWEIB SAEDL SAEDR STCLK T1T
XI15 VDDP VDDPI VSS VBP VBN SAET SAPRT FLOAT SAEDL SAEDR net107 STCLK
+ mm19a04_u_hs1prf_sacbufctrl
XI69 VDDP VDDPI VSS VBP VBN FLOAT net107 net106 T1T
+ mm19a04_u_hs1prf_sacbuf_dly_opt
XI17 VDDP VDDPI VSS VBP VBN LWERD LWEWR net106 FLOAT TEST_RNM BKSA LDFTX LWEIB
+ mm19a04_u_hs1prf_rdctrl_opt
.ends

.subckt mm19a04_u_hs1prf_timer_sactrl_pc VDDP VDDPI VSS VBP VBN RMT3B STCLK
+ DEFAULT_DLY1 DEFAULT_DLY2 DEFAULT_IN DLY_FT1 DLY_FT1_INT LOG1 DEF FLOAT_RET
+ FLOAT_RETB FT1 FT2 REFBP RMT3
MI177 net358 sactrl_rblwr_wa VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=320n m=6
MI176 STCLK FLOAT_RETB net358 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=320n m=6
MI46 DEFAULT_DLY2 net356 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=4
MI164 DEFAULT_DLY1 REFBP VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=160n m=2
XI103 VBP VBN DLY_FT1 sactrl_rblwr_wa FT1 net426 mm19a04_u_tg_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=2 nf_n=1 nf_p=1
+ wn=120n wp=320n
XI94 VBP VBN DEFAULT_IN sactrl_rblwr_wa DEF net211
+ mm19a04_u_tg_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=320n wp=320n
XI106 VBP VBN DEFAULT_DLY1 sactrl_rblwr_wa FT2 net225
+ mm19a04_u_tg_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=1 m_p=2 nf_n=1 nf_p=1 wn=120n wp=320n
XI161 VDDPI VSS VBP VBN net337 DEFAULT_DLY1 mm19a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=160n wp=160n
XI162 VDDPI VSS VBP VBN DLY_FT1_INT net337 mm19a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=160n wp=160n
XI137 VDDPI VSS VBP VBN net356 DLY_FT1_INT mm19a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=120n wp=160n
XI102 VDDPI VSS VBP VBN net211 DEF mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=320n
XI105 VDDPI VSS VBP VBN net225 FT2 mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=320n
XI104 VDDPI VSS VBP VBN net426 FT1 mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=320n
MI174 VDDPI sactrl_rblwr_wa STCLK VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=320n m=1
MI163 VDDPI REFBP DEFAULT_DLY1 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=160n m=4
MI175 VDDPI FLOAT_RETB STCLK VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=320n m=1
MIdummy1 sactrl_rblwr_wa LOG1 net225 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=320n m=1
MIdummy2 sactrl_rblwr_wa LOG1 net211 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=320n m=1
MI45 VDDPI net356 DEFAULT_DLY2 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=160n m=5
MI63_2 VDDPI REFBP DEFAULT_DLY1 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=158n m=2
.ends

.subckt mm19a04_u_mux_2x1_ulvt_pc_hs1prf_rmt3 VDDP VDDPI VSS VBP VBN OUT LOG1
+ SEL_1B_2 0_1 1 LWEIB SEL1 SEL2
MIdummy SEL_1B_2_B LOG1 SEL_1_2_B VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=240n m=1
XI561 VDDPI VSS VBP VBN SEL_1_2_B LWEIB SEL1 SEL2
+ mm19a04_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=160n
+ wn2=160n wn3=160n wp1=240n wp2=240n wp3=240n
XI564 VDDPI VSS VBP VBN SEL_1B_2_B LWEIB SEL1B SEL2
+ mm19a04_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=160n
+ wn2=160n wn3=160n wp1=240n wp2=240n wp3=240n
XI562 VDDPI VSS VBP VBN SEL_1_2 SEL_1_2_B mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=160n wp=240n
XI563 VDDPI VSS VBP VBN SEL_1B_2 SEL_1B_2_B mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=160n wp=240n
XI34 VDDPI VSS VBP VBN SEL1B SEL1 mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=240n
XI29 VBP VBN 0_1 OUT SEL_1B_2 SEL_1B_2_B mm19a04_u_tg_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=160n
+ wp=240n
XI35 VBP VBN 1 OUT SEL_1_2 SEL_1_2_B mm19a04_u_tg_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=160n
+ wp=240n
.ends

.subckt mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt3_p2_vt3 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=125n wn2=125n wp1=120n wp2=120n
MNA1 X A1 VSS VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 X A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MPA2 net10 A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2
+ w=wp2 m=m_p2
MPA1 X A1 net10 VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
.ends

.subckt mm19a04_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt2_p2_vt2 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=125n wn2=125n wp1=120n wp2=120n
MNA1 X A1 VSS VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 X A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MPA2 net10 A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2
+ w=wp2 m=m_p2
MPA1 X A1 net10 VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
.ends

.subckt mm19a04_u_inv_bulk_n_vt2_p_vt3 VDD VSS VBP VBN X A CPP=104n P_LA_n=4n
+ P_LA_p=4n ULP=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
MNA X A VSS VBN slvtnfet cpp=cpp p_la=p_la_n ulp=ulp nf=nf_n l=ln w=wn m=m_n
MPA X A VDD VBP slvtpfet cpp=cpp p_la=p_la_p ulp=ulp nf=nf_p l=lp w=wp m=m_p
.ends

.subckt mm19a04_u_float_selftimed_wa_hs1prf2 VDDA VDDP VDDPI VSS VBP VBN
+ FLOAT_RET RWLB RWLBLV STCLK DEF DEFAULT_DLY1 DEFAULT_DLY2 DEFAULT_IN DLY_FT1
+ DLY_FT1_INT FLOAT FLOAT_T1_B FLOAT_T1_B_2 FLOAT_T1_B_3 FT1 FT2 LOG1 RBL
+ RMT[2] RMT[3] RMT3B RWLB_IN RWLB_INT RWLB_OUT WABUFB WAPRCLKBUFB_RET
+ BKSA_T1TB FLTRET LWEIB RWLBHV STCLK_RST_PGM TRNM
XTIMER VDDP VDDPI VSS VBP VBN RMT3B STCLK DEFAULT_DLY1 DEFAULT_DLY2 DEFAULT_IN
+ DLY_FT1 DLY_FT1_INT LOG1 DEF FLOAT_RET float_retb_wa FT1 FT2 RBL RMT[3]
+ mm19a04_u_hs1prf_timer_sactrl_pc
XMUX VDDP VDDPI VSS VBP VBN RBL LOG1 net385 net384 RWLB_OUT LWEIB RMT[2] RMT[3]
+ mm19a04_u_mux_2x1_ulvt_pc_hs1prf_rmt3
XIfloat_lockup_inv2_rwlb VDDPI VSS VBP VBN FLOAT_T1_B_2 FLOAT BKSA_T1TB
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=3 m_p2=3 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=298n wn2=298n wp1=320n
+ wp2=320n
XIfloat_lockup_nor2 VDDPI VSS VBP VBN FLOAT_T1_B_0 FLOAT BKSA_T1TB
+ mm19a04_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=350n wn2=350n wp1=250n
+ wp2=250n
XI47 VDDPI VSS VBP VBN RWLB_OUT net398 net351
+ mm19a04_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=180n wn2=180n wp1=250n
+ wp2=250n
XI82 VDDPI VSS VBP VBN net398 net356 mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=180n
+ wp=250n
XI81 VDDPI VSS VBP VBN net356 net355 mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=160n
XI74 VDDP VSS VBP VBN net346 FLOAT_T1_B_2 mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=250n
XI73 VDDP VSS VBP VBN FLOAT_T1_B_3 net346 mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=250n wp=250n
XI8 VDDPI VSS VBP VBN net94 RWLB_OUT mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI7 VDDPI VSS VBP VBN net384 net94 mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XIfloat_lockup_inv2_floatreturn VDDPI VSS VBP VBN net239 FLOAT
+ mm19a04_u_inv_bulk_n_vt2_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=1 m_p=3 nf_n=1 nf_p=1 wn=250n wp=320n
XI48 VDDPI VSS VBP VBN net351 RWLB_IN mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=160n
XI32 VDDP VSS VBP VBN RWLBLV FLOAT_T1_B mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=8 m_p=8 nf_n=1 nf_p=1 wn=300n
+ wp=250n
XI80 VDDPI VSS VBP VBN net355 net353 mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=160n
XI79 VDDPI VSS VBP VBN net353 net351 mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=160n
XI21 VDDPI VSS VBP VBN float_retb_wa WAPRCLKBUFB_RET net184 FLOAT_RET
+ mm19a04_u_aoi21_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=2 m_n2=2 m_n3=2 m_p1=2
+ m_p2=2 m_p3=2 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=160n
+ wn2=160n wn3=160n wp1=160n wp2=160n wp3=160n
MIdummy3 VDDPI LOG1 net356 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=160n m=1
MIdummy2 VDDPI LOG1 net351 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=160n m=1
MIdummy1 net355 LOG1 net353 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=160n m=1
Mifloat_lockup_mp3_1 VDDP STCLK FLOAT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=320n m=7
Mifloat_lockup_mp3_2 VDDP STCLK FLOAT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=417n m=2
MI6 VDDP net239 FLOAT_RET VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=3
MIfloat_lockup_mp3 FLOAT STCLK VDDP VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=535n m=7
MIfloat_lockup_mn3 net14 FLOAT_T1_B_0 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0
+ nf=1 l=20n w=250n m=2
M17 FLOAT_RET net239 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=350n
+ m=7
MIIfloat_lockup_mn2 net14 STCLK FLOAT VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=250n m=1
XI117[0] VDDPI VSS VBP VBN net184 WABUFB LWEIB TRNM
+ mm19a04_u_nr3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=120n
+ wn2=120n wn3=120n wp1=320n wp2=320n wp3=320n
XI117[1] VDDPI VSS VBP VBN net184 WABUFB LWEIB TRNM
+ mm19a04_u_nr3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=120n
+ wn2=120n wn3=120n wp1=320n wp2=320n wp3=320n
.ends

.subckt mm19a04_u_log01_gen_hs1prf VDDP VNWP VSS VBP VBN LCGTHB_PCHG LOG0 LOG1
*XI11 VBP VBN always1 mm19a04_u_init1
XI10 VDDP VSS VBP VBN alway0 always1 mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
Xinv_1 VDDP VSS VBP VBN always1 ST0 mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
Mdummy19 alway0 LOG1 LCGTHB_PCHG VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=1
M0 LOG0 always1 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=2
M1 ST0 always1 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
M2 ST0 alway0 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
.ends

.subckt mm19a04_u_hs1prf_sactrl VDDA VDDF VDDP VDDPI VSS VBP VBN LCGTHB
+ LCGTHB_DR0 LCGTHB_PCHG LCGTHLV LWERD LWEWR LYADRB[1] PM[0] PM[1] PM[2] PM[3]
+ PRCLKB RWLBLV SAET SAETHV SAPRT BYPASS BYP_VLOAD DEFAULT_DLY1 DEFAULT_DLY2
+ DEFAULT_IN DEF_MODE DLY_FT1 DLY_FT1_INT FAST1_MODE FAST2_MODE FLOAT FLOAT_RET
+ FLOAT_T1_B FLOAT_T1_B_2 FLOAT_T1_B_3 LBKADR[0] LCGTB LOG0 LOG1 RBLRD RBLWA
+ RBLWR RMT[0] RMT[1] RMT[2] RMT[3] RWLB RWLB_IN RWLB_INT RWLB_OUT T1T
+ TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WAPRCLKBUFB_RET WMT[0] WMT[1] WMT[2]
+ WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] CENDP CKGATE DLYPW ENLPGB FLOATT LDFTX
+ LITESLP LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6]
+ LXADR[7] LYADR[0] LYADR[1] PLYADR[1] PLYADRB[1] RM3CNT RWLBHV SAED
XI360 VDDP VDDPI VSS VBP VBN LYADRB[1] PM[3] PM[2] PM[1] PM[0] LYADR[0]
+ LYADR[1] PLYADR[1] PLYADRB[1] mm19a04_u_predec_2to4_hs1prf
MI66 VSS T1T T1TB VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=2
Mdummy17 VDDP LOG1 LCGTHLV VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=1
Mdummy2 WMT[2] LOG1 WMT[3] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=320n m=1
MI67 T1TB T1T VDDPI VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=2
XRMWMSEL[0] VDDP VDDPI VSS VBP VBN INT[2] WMT[2] RMT[2] LWEIB LWEIBB
+ mm19a04_u_mux_2x1_modesel
XRMWMSEL[1] VDDP VDDPI VSS VBP VBN INT[3] WMT[3] RMT[3] LWEIB LWEIBB
+ mm19a04_u_mux_2x1_modesel
XI401 VDDP VSS VBP VBN LOG0 LOG1 mm19a04_u_logrep_hs1prf_gf22
XI515 VDDP VDDPI VSS VBP VBN RBL RBLWR RBLRD LWEIB RMT[3]
+ mm19a04_u_mux_2x1_ulvt_pc_hs1prf_rd_wr
XI337 VDDA VDDP VDDPI VSS VBP VBN LCGTB LCGTHB_DR0 LCGTHLV LCGTHB_PCHG ENLPGB
+ LITESLP RM3CNT mm19a04_u_hs1prf_sac_pwmg
XRDCTRL VDDP VDDPI VSS VBP VBN LWERD LWEWR SAET SAPRT FLOAT TEST_RNM LOG1 LDFTX
+ LWEIB net1509 SAED STCLK T1TB mm19a04_u_rdctrl_sa_hs1prf
XLCEN_SELFTIMED_WR VDDA VDDP VDDPI VSS VBP VBN FLOAT_RET RWLB RWLBLV STCLK
+ DEF_MODE DEFAULT_DLY1 DEFAULT_DLY2 DEFAULT_IN DLY_FT1 DLY_FT1_INT FLOAT
+ FLOAT_T1_B FLOAT_T1_B_2 FLOAT_T1_B_3 FAST1_MODE FAST2_MODE LOG1 RBL INT[2]
+ INT[3] net1616 RWLB_IN RWLB_INT RWLB_OUT WABUF[2] WAPRCLKBUFB_RET T1T net1618
+ LWEIB RWLBHV net1617 TEST_RNM mm19a04_u_float_selftimed_wa_hs1prf2
XI122 VDDPI VSS VBP VBN TEST_RNM TEST_RNMB mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI543 VDDPI VSS VBP VBN LWEIBB LWEIB mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=160n
XI400 VDDP VDDP VSS VBP VBN LCGTHB_PCHG LOG0 LOG1 mm19a04_u_log01_gen_hs1prf
.ends

.subckt mm19a04_u_hs1prf_sacbuf VDDA VDDP VDDPI VSS VBP VBN LCGTH SAEB SAPR
+ ARYSD ARYSD_BC1 ARYSD_BC2 BYPASS DLYPDB PROCOML RASSIST[0] RASSIST[1]
+ RASSISTT[0] RASSISTT[1] SAEB_INT SAED LCGTHB SAET SAPRT
XI78[0] VDDPI VSS VBP VBN RASSISTT[0] RASSISTB[0]
+ mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=432n wp=480n
XI78[1] VDDPI VSS VBP VBN RASSISTT[1] RASSISTB[1]
+ mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=432n wp=480n
XI77[0] VDDPI VSS VBP VBN RASSISTB[0] RASSIST[0] mm19a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=432n wp=480n
XI77[1] VDDPI VSS VBP VBN RASSISTB[1] RASSIST[1] mm19a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=432n wp=480n
XLCGTHB VDDA VSS VBP VBN LCGTH LCGTHB mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=3 nf_n=1 nf_p=1 wn=480n
+ wp=320n
MI76_mn SAEB net110 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=577n
+ m=7
MI111 net110 SAET VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=577n m=4
Mi57_n SAPR SAPRT VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=504n
+ m=14
MI76_mp1 VDDPI net110 SAEB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=480n m=11
MI76_mp0 VDDPI net110 SAEB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=645n m=7
Mi57_p2 VDDPI SAPRT SAPR VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=350n
+ m=3
MI110 VDDPI SAET net110 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=645n
+ m=4
Mi57_p1 VDDPI SAPRT SAPR VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=480n
+ m=2
.ends

.subckt mm19a04_u_lsa_gf22_hs1prf_cm4 VDDP VDDPI VSS VBP VBN XB XT RB RT SAEN
+ SAEP SAPR
M9 net41 SAEN VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=360n m=4
M7 XT XB net41 VBN slvtnfet cpp=104n p_la=8n ulp=0 nf=1 l=20n w=780n m=6
M6 XB XT net41 VBN slvtnfet cpp=104n p_la=8n ulp=0 nf=1 l=20n w=780n m=6
M4 XT SAEP RT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=206n m=2
M3 XB SAEP RB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=206n m=2
M2 XB SAPR XT VBP slvtpfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=225n m=1
M0 VDDPI SAPR XB VBP slvtpfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=225n m=1
M1 VDDPI SAPR XT VBP slvtpfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=225n m=1
M5 VDDPI XT XB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=206n m=3
M11 VDDPI XB XT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=206n m=3
.ends

.subckt mm19a04_u_hs1prf_sac_st_cm4 VDDP VDDPI VSS VBP VBN LQB RB RT VGND WB
+ WB_IN WT WT_IN SAEB SAPRB
XI52 VDDP VDDPI VSS VBP VBN XB XT RB RT SAE SAE SAPR
+ mm19a04_u_lsa_gf22_hs1prf_cm4
XI51 VDDPI VSS VBP VBN XBB XB mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n wp=412n
XI40 VDDPI VSS VBP VBN IFF LQB mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=412n
XSAE VDDPI VSS VBP VBN SAE SAEB mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=128n
+ wp=180n
MI47 net170 IFF LQB VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=180n m=1
MI46 VSS XT net170 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=180n m=2
MI39 VGND XBB LQB VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=4
MI41 net151 XBB VDDP VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=180n m=1
MI42 LQB IFF net151 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=180n m=1
MXQBIP LQB XT VDDP VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=4
XI49 VDDPI VSS VBP VBN SAPR SAEB SAPRB
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=128n wn2=128n wp1=180n
+ wp2=180n
.ends

.subckt mm19a04_u_wrdrv_hs1prf_cm4 VDDP VDDPI VSS VSS_WA VBP VBN WB WT RB RT
+ WB_IN WT_IN
MI74 VDDPI WT_IN WT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=206n m=4
MI22 VDDPI WB_IN WB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=206n m=4
MI75 WT WT_IN VSS_WA VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=326n m=4
MI23 WB WB_IN VSS_WA VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=326n m=4
.ends

.subckt mm19a04_u_hsrf1p_sac_cm4 VDDP VDDPI VSS VSS_WA VBP VBN LQB RB RT VGND
+ WB WT BADB SAEB SAPRB WB_IN WT_IN
XS VDDP VDDPI VSS VBP VBN LQB RB RT VGND WB WB_IN WT WT_IN SAEB SAPRB
+ mm19a04_u_hs1prf_sac_st_cm4
XW VDDP VDDPI VSS VSS_WA VBP VBN WB WT RB RT WB_IN WT_IN
+ mm19a04_u_wrdrv_hs1prf_cm4
.ends

.subckt mm19a04_u_hs1prf_sacm4x1 VDDA VDDP VDDPI VSS VSS_WA VBP VBN BYPASS
+ LCGTH LOG1 LQB RASSISTT[0] RASSISTT[1] RB RT SAED VGND WB WB_IN WT WT_IN BADB
+ SAEB SAPRB
XIinv_sae_2 VDDPI VSS VBP VBN SAEBB SAEB mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=128n wp=180n
Xinv_sae VDDPI VSS VBP VBN SAEBB SAEB mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=128n
+ wp=180n
XSFF VDDP VDDPI VSS VSS_WA VBP VBN LQB RB RT VGND WB WT BADB SAEBB SAPRB WB_IN
+ WT_IN mm19a04_u_hsrf1p_sac_cm4
.ends

.subckt mm19a04_u_hs1prf_capsac VDDA VDDP VDDPI VSS VBP VBN SAED BYPASS LOG0
+ LOG1 PWDO VEDGE SAEB
XI17 VDDPI VSS VBP VBN net19 SAEB mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI10 VDDPI VSS VBP VBN SAED net19 mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=8 m_p=8 nf_n=1 nf_p=1 wn=120n
+ wp=120n
.ends

.subckt mm19a04_u_hs1prf_cdec_nd3rf VDDPI VNWP VSS VBP VBN PRCH DECB_CMN A
+ CMUX_CLK LLWE
M31 VDDPI LLWE PRCH VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
M20 VDDPI CMUX_CLK PRCH VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n
+ m=2
M18 VDDPI A PRCH VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
M17 PRCH A DECB_CMN VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=250n m=4
.ends

.subckt mm19a04_u_hs1prf_cdec_wr VDDP VDDPI VSS VBP VBN PRCH[0] PRCH[1] PRCH[2]
+ PRCH[3] A[0] A[1] A[2] A[3] CMUX_CLK LLWE
M17 CMN_LLWE LLWE VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=262n m=8
M27 CMUX_CLKB CMUX_CLK CMN_LLWE VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=262n m=8
XI26 VDDPI VDDP VSS VBP VBN PRCH[0] CMUX_CLKB A[0] CMUX_CLK LLWE
+ mm19a04_u_hs1prf_cdec_nd3rf
XI25 VDDPI VDDP VSS VBP VBN PRCH[1] CMUX_CLKB A[1] CMUX_CLK LLWE
+ mm19a04_u_hs1prf_cdec_nd3rf
XI24 VDDPI VDDP VSS VBP VBN PRCH[2] CMUX_CLKB A[2] CMUX_CLK LLWE
+ mm19a04_u_hs1prf_cdec_nd3rf
XI23 VDDPI VDDP VSS VBP VBN PRCH[3] CMUX_CLKB A[3] CMUX_CLK LLWE
+ mm19a04_u_hs1prf_cdec_nd3rf
.ends

.subckt mm19a04_u_hs1prf_cdec_nd3_rd VDDPI VNWP VSS VBP VBN PRCH DECB_CMN A
+ CMUX_CLK LLWE
M31 VDDPI LLWE PRCH VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
M20 VDDPI CMUX_CLK PRCH VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n
+ m=1
M18 VDDPI A PRCH VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
M17 PRCH A DECB_CMN VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=150n m=2
.ends

.subckt mm19a04_u_cdec VDDP VDDPI VSS VBP VBN PRCH[0] PRCH[1] PRCH[2] PRCH[3]
+ A[0] A[1] A[2] A[3] CMUX_CLK LLWE
M17 CMN_LLWE LLWE VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=260n m=3
M27 CMUX_CLKB CMUX_CLK CMN_LLWE VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=260n m=3
XI26 VDDPI VDDP VSS VBP VBN PRCH[0] CMUX_CLKB A[0] CMUX_CLK LLWE
+ mm19a04_u_hs1prf_cdec_nd3_rd
XI25 VDDPI VDDP VSS VBP VBN PRCH[1] CMUX_CLKB A[1] CMUX_CLK LLWE
+ mm19a04_u_hs1prf_cdec_nd3_rd
XI24 VDDPI VDDP VSS VBP VBN PRCH[2] CMUX_CLKB A[2] CMUX_CLK LLWE
+ mm19a04_u_hs1prf_cdec_nd3_rd
XI23 VDDPI VDDP VSS VBP VBN PRCH[3] CMUX_CLKB A[3] CMUX_CLK LLWE
+ mm19a04_u_hs1prf_cdec_nd3_rd
.ends

.subckt mm19a04_u_hs1prf_xpredec_3to8 VDDP VDDPI VSS VBP VBN POUT[0] POUT[1]
+ POUT[2] POUT[3] POUT[4] POUT[5] POUT[6] POUT[7] PD A[0] A[1] A[2]
XI3to8dec_1 VDDPI PD VBP VBN POUT[1] A[0] AB[1] AB[2]
+ mm19a04_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=0 p_la_n2=0 p_la_n3=0 p_la_p1=0 p_la_p2=0 p_la_p3=0 ulp=0 ln1=20n
+ ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1 m_p2=1
+ m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=720n wn2=720n
+ wn3=720n wp1=320n wp2=320n wp3=320n
XI3to8dec_0 VDDPI PD VBP VBN POUT[0] AB[0] AB[1] AB[2]
+ mm19a04_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=0 p_la_n2=0 p_la_n3=0 p_la_p1=0 p_la_p2=0 p_la_p3=0 ulp=0 ln1=20n
+ ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1 m_p2=1
+ m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=720n wn2=720n
+ wn3=720n wp1=320n wp2=320n wp3=320n
XI3to8dec_5 VDDPI PD VBP VBN POUT[5] A[0] AB[1] A[2]
+ mm19a04_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=0 p_la_n2=0 p_la_n3=0 p_la_p1=0 p_la_p2=0 p_la_p3=0 ulp=0 ln1=20n
+ ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1 m_p2=1
+ m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=720n wn2=720n
+ wn3=720n wp1=320n wp2=320n wp3=320n
XI3to8dec_2 VDDPI PD VBP VBN POUT[2] AB[0] A[1] AB[2]
+ mm19a04_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=0 p_la_n2=0 p_la_n3=0 p_la_p1=0 p_la_p2=0 p_la_p3=0 ulp=0 ln1=20n
+ ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1 m_p2=1
+ m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=720n wn2=720n
+ wn3=720n wp1=320n wp2=320n wp3=320n
XI3to8dec_6 VDDPI PD VBP VBN POUT[6] AB[0] A[1] A[2]
+ mm19a04_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=0 p_la_n2=0 p_la_n3=0 p_la_p1=0 p_la_p2=0 p_la_p3=0 ulp=0 ln1=20n
+ ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1 m_p2=1
+ m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=720n wn2=720n
+ wn3=720n wp1=320n wp2=320n wp3=320n
XI3to8dec_7 VDDPI PD VBP VBN POUT[7] A[0] A[1] A[2]
+ mm19a04_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=0 p_la_n2=0 p_la_n3=0 p_la_p1=0 p_la_p2=0 p_la_p3=0 ulp=0 ln1=20n
+ ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1 m_p2=1
+ m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=720n wn2=720n
+ wn3=720n wp1=320n wp2=320n wp3=320n
XI3to8dec_4 VDDPI PD VBP VBN POUT[4] AB[0] AB[1] A[2]
+ mm19a04_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=0 p_la_n2=0 p_la_n3=0 p_la_p1=0 p_la_p2=0 p_la_p3=0 ulp=0 ln1=20n
+ ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1 m_p2=1
+ m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=720n wn2=720n
+ wn3=720n wp1=320n wp2=320n wp3=320n
XI3to8dec_3 VDDPI PD VBP VBN POUT[3] A[0] A[1] AB[2]
+ mm19a04_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=0 p_la_n2=0 p_la_n3=0 p_la_p1=0 p_la_p2=0 p_la_p3=0 ulp=0 ln1=20n
+ ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1 m_p2=1
+ m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=720n wn2=720n
+ wn3=720n wp1=320n wp2=320n wp3=320n
XINV_ADD[0] VDDPI VSS VBP VBN AB[0] A[0] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=0 p_la_p=0 ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=320n wp=320n
XINV_ADD[1] VDDPI VSS VBP VBN AB[1] A[1] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=0 p_la_p=0 ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=320n wp=320n
XINV_ADD[2] VDDPI VSS VBP VBN AB[2] A[2] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=0 p_la_p=0 ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=320n wp=320n
.ends

.subckt mm19a04_u_hs1prf_predec_2to4_nd3 VDDP VDDPI VSS VBP VBN PMB[0] PMB[1]
+ PMB[2] PMB[3] A[0] A[1] BK_INT
XI142 VDDPI VSS VBP VBN PMB[1] BK_INT A[0] AB[1]
+ mm19a04_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=2 m_n2=2 m_n3=2 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=500n
+ wn2=500n wn3=500n wp1=400n wp2=400n wp3=400n
Xi2to4dec_0 VDDPI VSS VBP VBN PMB[0] BK_INT AB[0] AB[1]
+ mm19a04_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=2 m_n2=2 m_n3=2 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=500n
+ wn2=500n wn3=500n wp1=400n wp2=400n wp3=400n
XI143 VDDPI VSS VBP VBN PMB[2] BK_INT AB[0] A[1]
+ mm19a04_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=2 m_n2=2 m_n3=2 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=500n
+ wn2=500n wn3=500n wp1=400n wp2=400n wp3=400n
XI144 VDDPI VSS VBP VBN PMB[3] BK_INT A[0] A[1]
+ mm19a04_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=2 m_n2=2 m_n3=2 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=500n
+ wn2=500n wn3=500n wp1=400n wp2=400n wp3=400n
Xinv_adr[0] VDDPI VSS VBP VBN AB[0] A[0] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=320n wp=320n
Xinv_adr[1] VDDPI VSS VBP VBN AB[1] A[1] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=320n wp=320n
.ends

.subckt mm19a04_u_hs1prf_pdec_nr2_wclkb VDDA VSS VBP VBN WCLK DECB_CMN CLK_WL
+ LDFTXA XPRB
M17 WCLKB XPRB VSS VBN slvtnfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=623n m=1
MI34 WCLKB CLK_WL VSS VBN slvtnfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=623n m=1
Xwclk VDDA VSS VBP VBN WCLK WCLKB mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=10 m_p=4 nf_n=1 nf_p=1 wn=540n
+ wp=400n
M31 net99 CLK_WL WCLKB VBP slvtpfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=375n m=4
MI35 VDDA XPRB net99 VBP slvtpfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=375n m=4
.ends

.subckt mm19a04_u_hs1prf_predec_2to4_wclkb VDDA VSS VBP VBN WCLKB[0] WCLKB[1]
+ WCLKB[2] WCLKB[3] CLK_WLB LDFTXA XPRB[0] XPRB[1] XPRB[2] XPRB[3]
XI28 VDDA VSS VBP VBN WCLKB[0] net176 CLK_WLB LDFTXA XPRB[0]
+ mm19a04_u_hs1prf_pdec_nr2_wclkb
XI27 VDDA VSS VBP VBN WCLKB[3] net179 CLK_WLB LDFTXA XPRB[3]
+ mm19a04_u_hs1prf_pdec_nr2_wclkb
XI26 VDDA VSS VBP VBN WCLKB[2] net178 CLK_WLB LDFTXA XPRB[2]
+ mm19a04_u_hs1prf_pdec_nr2_wclkb
XI25 VDDA VSS VBP VBN WCLKB[1] net177 CLK_WLB LDFTXA XPRB[1]
+ mm19a04_u_hs1prf_pdec_nr2_wclkb
.ends

.subckt mm19a04_u_hs1prf_xpred_rf VDDA VDDP VDDPI VSS VBP VBN PBB[0] PBB[1]
+ PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4]
+ PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] LOG1 XPRBH[0]
+ XPRBH[1] XPRBH[2] XPRBH[3] XPRBL[0] XPRBL[1] XPRBL[2] XPRBL[3] BKB_IN BK_IN
+ CLK_WLB LDFTX XADR[0] XADR[1] XADR[2] XADR[3] XADR[4] XADR[5] XADR[6] XADR[7]
XI62 VDDP VDDPI VSS VBP VBN PC[0] PC[1] PC[2] PC[3] PC[4] PC[5] PC[6] PC[7] VSS
+ XADR[5] XADR[6] XADR[7] mm19a04_u_hs1prf_xpredec_3to8
XI61 VDDP VDDPI VSS VBP VBN PB[0] PB[1] PB[2] PB[3] PB[4] PB[5] PB[6] PB[7] VSS
+ XADR[2] XADR[3] XADR[4] mm19a04_u_hs1prf_xpredec_3to8
XI53 VDDP VDDPI VSS VBP VBN XPRBL[0] XPRBL[1] XPRBL[2] XPRBL[3] XADR[0] XADR[1]
+ BK_IN mm19a04_u_hs1prf_predec_2to4_nd3
Xpcb[0] VDDPI VSS VBP VBN PCB[0] PC[0] mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=0 p_la_p=0 ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=400n
Xpcb[1] VDDPI VSS VBP VBN PCB[1] PC[1] mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=0 p_la_p=0 ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=400n
Xpcb[2] VDDPI VSS VBP VBN PCB[2] PC[2] mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=0 p_la_p=0 ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=400n
Xpcb[3] VDDPI VSS VBP VBN PCB[3] PC[3] mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=0 p_la_p=0 ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=400n
Xpcb[4] VDDPI VSS VBP VBN PCB[4] PC[4] mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=0 p_la_p=0 ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=400n
Xpcb[5] VDDPI VSS VBP VBN PCB[5] PC[5] mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=0 p_la_p=0 ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=400n
Xpcb[6] VDDPI VSS VBP VBN PCB[6] PC[6] mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=0 p_la_p=0 ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=400n
Xpcb[7] VDDPI VSS VBP VBN PCB[7] PC[7] mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=0 p_la_p=0 ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=400n
XIpbb[0] VDDPI VSS VBP VBN PBB[0] PB[0] mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=0 p_la_p=0 ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=400n
XIpbb[1] VDDPI VSS VBP VBN PBB[1] PB[1] mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=0 p_la_p=0 ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=400n
XIpbb[2] VDDPI VSS VBP VBN PBB[2] PB[2] mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=0 p_la_p=0 ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=400n
XIpbb[3] VDDPI VSS VBP VBN PBB[3] PB[3] mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=0 p_la_p=0 ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=400n
XIpbb[4] VDDPI VSS VBP VBN PBB[4] PB[4] mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=0 p_la_p=0 ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=400n
XIpbb[5] VDDPI VSS VBP VBN PBB[5] PB[5] mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=0 p_la_p=0 ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=400n
XIpbb[6] VDDPI VSS VBP VBN PBB[6] PB[6] mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=0 p_la_p=0 ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=400n
XIpbb[7] VDDPI VSS VBP VBN PBB[7] PB[7] mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=0 p_la_p=0 ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=400n
XI52 VDDA VSS VBP VBN WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] CLK_WLB net171
+ XPRBH[0] XPRBH[1] XPRBH[2] XPRBH[3] mm19a04_u_hs1prf_predec_2to4_wclkb
.ends

.subckt mm19a04_u_hs1prf_lcen VDDA VDDF VDDP VDDPI VSS VSSWLL VSSWLR VBP VBN
+ CKPRCH PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1]
+ PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] PRCHRD[0] PRCHRD[1] PRCHRD[2]
+ PRCHRD[3] PRCHWR[0] PRCHWR[1] PRCHWR[2] PRCHWR[3] PRCHWRH[0] PRCHWRH[1]
+ PRCHWRH[2] PRCHWRH[3] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] BYP_VLOAD CENDP
+ CKGATE DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATH FLOATT FLOAT_RET
+ LBKADRB[0] LBKADR_TOP[0] LCGTHB LDFTX LITESLP LOG0 LOG1 LWEIB LWERD LWEWR
+ LXADR_TOP[0] LXADR_TOP[1] LXADR_TOP[2] LXADR_TOP[3] LXADR_TOP[4] LXADR_TOP[5]
+ LXADR_TOP[6] LXADR_TOP[7] LYADR_TOP[0] LYADR_TOP[1] RBLRD RBLWA RBLWR RM3CNT
+ RWLB WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+ WPBUF[2] XPRBH[0] XPRBH[1] XPRBH[2] XPRBH[3] XPRBL[0] XPRBL[1] XPRBL[2]
+ XPRBL[3] LBKADR[0] LCGTHB_PCHG LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+ LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PLBKADRB[0] PM[0] PM[1] PM[2]
+ PM[3] RMT[0] RMT[1] RMT[2] RMT[3] T1T TEST_RNMB
MI173 VSS LCGTHB VSSWLR VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=980n
+ m=3
MI178 VSS LCGTHB VSSWLL VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=336n
+ m=10
MNA2 CKPRCH LCGTHB_PCHG VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=2
MI170 ckprchb_int1 FLOAT VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=275n m=2
XI146[0] net315 VSS VBP VBN CKPRCH ckprchb_int1 ckprchb_int2
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=560n wn2=560n wp1=240n
+ wp2=240n
XI146[1] net315 VSS VBP VBN CKPRCH ckprchb_int1 ckprchb_int2
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=560n wn2=560n wp1=240n
+ wp2=240n
XI146[2] net315 VSS VBP VBN CKPRCH ckprchb_int1 ckprchb_int2
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=560n wn2=560n wp1=240n
+ wp2=240n
XI151 VDDP VDDP VSS VBP VBN PRCHWR[0] PRCHWR[1] PRCHWR[2] PRCHWR[3] PM[0] PM[1]
+ PM[2] PM[3] PRCLK LWEWR mm19a04_u_hs1prf_cdec_wr
XI152 VDDP VDDP VSS VBP VBN net500[0] net500[1] net500[2] net500[3] PM[0] PM[1]
+ PM[2] PM[3] PRCLK LWERD mm19a04_u_cdec
Xpredec VDDA VDDP VDDPI VSS VBP VBN PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5]
+ PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7]
+ WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] LOG1 XPRBH[0] XPRBH[1] XPRBH[2] XPRBH[3]
+ XPRBL[0] XPRBL[1] XPRBL[2] XPRBL[3] BKB_IN BK_IN FLOATH LDFTX LXADR[0]
+ LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+ mm19a04_u_hs1prf_xpred_rf
Mdummy4 VDDPI VDDP net315 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n
+ m=1
MI169 VDDPI FLOAT ckprchb_int1 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=2
MPA2 VDDPI LCGTHB_PCHG net315 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=4
XI261 VDDPI VSS VBP VBN BK_IN PLBKADRB[0] LDFTX
+ mm19a04_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=4 m_n2=4
+ m_p1=4 m_p2=4 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=300n
+ wp2=300n
XI147 VDDPI VSS VBP VBN ckprchb_int2 PLBKADRB[0] test_rnm
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=3 m_n2=3
+ m_p1=3 m_p2=3 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=167n wn2=167n wp1=334n
+ wp2=334n
XI148 VDDPI VSS VBP VBN net430 test_rnm PLBKADRB[0]
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=240n
+ wp2=240n
XI150[0] VDDPI VSS VBP VBN PRCLK FLOAT net429
+ mm19a04_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=150n wn2=150n wp1=300n
+ wp2=300n
XI150[1] VDDPI VSS VBP VBN PRCLK FLOAT net429
+ mm19a04_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=150n wn2=150n wp1=300n
+ wp2=300n
XI150[2] VDDPI VSS VBP VBN PRCLK FLOAT net429
+ mm19a04_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=150n wn2=150n wp1=300n
+ wp2=300n
XI150[3] VDDPI VSS VBP VBN PRCLK FLOAT net429
+ mm19a04_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=150n wn2=150n wp1=300n
+ wp2=300n
XI250 VDDPI VSS VBP VBN LBKADRB[0] LBKADR[0] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=320n wp=320n
XI145 VDDPI VSS VBP VBN test_rnm TEST_RNMB mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI127[0] VDDP VSS VBP VBN PRCHRD[0] net500[0] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=120n wp=350n
XI127[1] VDDP VSS VBP VBN PRCHRD[1] net500[1] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=120n wp=350n
XI127[2] VDDP VSS VBP VBN PRCHRD[2] net500[2] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=120n wp=350n
XI127[3] VDDP VSS VBP VBN PRCHRD[3] net500[3] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=120n wp=350n
XI149 VDDPI VSS VBP VBN net429 net430 mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=200n
.ends

.subckt mm19a04_u_hs1prf_vddwl_header VDDA VDDWL VBP VBN LCGTH
MI11 VDDWL VDDWL VDDA VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=167n m=2
MI10 VDDA LCGTH VDDWL VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=1000n
+ m=10
M0 VDDA LCGTH VDDWL VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=167n m=2
.ends

.subckt mm19a04_u_inv_bulk_n_vt1_p_vt1 VDD VSS VBP VBN X A CPP=104n P_LA_n=4n
+ P_LA_p=4n ULP=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
MNA X A VSS VBN lvtnfet cpp=cpp p_la=p_la_n ulp=ulp nf=nf_n l=ln w=wn m=m_n
MPA X A VDD VBP lvtpfet cpp=cpp p_la=p_la_p ulp=ulp nf=nf_p l=lp w=wp m=m_p
.ends

.subckt mm19a04_u_hs1prf_pg_wlstkrw VDDA VDDWL VDDWL_PCOM VSS VBP VBN LCGTHB
+ LCGTH PROCOML
XIwlheader VDDA VDDWL VBP VBN LCGTH mm19a04_u_hs1prf_vddwl_header
XI15 VDDA VSS VBP VBN LCGTHB LCGTH mm19a04_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=167n
.ends

.subckt mm19a04_u_hs1prf_lcenrebuf VDDA VDDP VDDPI VDDWL VDDWL_PCOM VNWP VSS
+ VBP VBN PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+ PRCHWRB[2] PRCHWRB[3] RASSISTB[0] RASSISTB[1] LCGTHB LCGTH PRCHRD[0]
+ PRCHRD[1] PRCHRD[2] PRCHRD[3] PRCHWR[0] PRCHWR[1] PRCHWR[2] PRCHWR[3] PROCOML
+ RASSIST[0] RASSIST[1]
XI22 VDDA VDDWL VDDWL_PCOM VSS VBP VBN LCGTHB LCGTH PROCOML
+ mm19a04_u_hs1prf_pg_wlstkrw
Xprchrdb[0] VDDA VSS VBP VBN PRCHWRB[0] PRCHWR[0]
+ mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=0 p_la_p=0 ulp=0 ln=20n lp=20n
+ m_n=6 m_p=3 nf_n=1 nf_p=1 wn=1000n wp=667n
Xprchrdb[1] VDDA VSS VBP VBN PRCHWRB[1] PRCHWR[1]
+ mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=0 p_la_p=0 ulp=0 ln=20n lp=20n
+ m_n=6 m_p=3 nf_n=1 nf_p=1 wn=1000n wp=667n
Xprchrdb[2] VDDA VSS VBP VBN PRCHWRB[2] PRCHWR[2]
+ mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=0 p_la_p=0 ulp=0 ln=20n lp=20n
+ m_n=6 m_p=3 nf_n=1 nf_p=1 wn=1000n wp=667n
Xprchrdb[3] VDDA VSS VBP VBN PRCHWRB[3] PRCHWR[3]
+ mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=0 p_la_p=0 ulp=0 ln=20n lp=20n
+ m_n=6 m_p=3 nf_n=1 nf_p=1 wn=1000n wp=667n
XI78[0] VDDPI VSS VBP VBN RASSISTB[0] RASSIST[0] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=120n wp=142n
XI78[1] VDDPI VSS VBP VBN RASSISTB[1] RASSIST[1] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=120n wp=142n
XI6[0] VDDPI VSS VBP VBN PRCHRDB[0] PRCHRD[0] mm19a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=6 nf_n=1 nf_p=1
+ wn=667n wp=1000n
XI6[1] VDDPI VSS VBP VBN PRCHRDB[1] PRCHRD[1] mm19a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=6 nf_n=1 nf_p=1
+ wn=667n wp=1000n
XI6[2] VDDPI VSS VBP VBN PRCHRDB[2] PRCHRD[2] mm19a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=6 nf_n=1 nf_p=1
+ wn=667n wp=1000n
XI6[3] VDDPI VSS VBP VBN PRCHRDB[3] PRCHRD[3] mm19a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=6 nf_n=1 nf_p=1
+ wn=667n wp=1000n
.ends

.subckt mm19a04_u_hs1prf_lcenbuf_base_exp VDDA VDDP VDDPI VDDWL VDDWL_PCOM VSS
+ VBP VBN CKPRCH GCKPRCHB PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3]
+ PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] RASSISTB[0] RASSISTB[1] LCGTHB
+ CKPRCHB LCGTH PRCHRD[0] PRCHRD[1] PRCHRD[2] PRCHRD[3] PRCHWR[0] PRCHWR[1]
+ PRCHWR[2] PRCHWR[3] PROCOML RASSIST[0] RASSIST[1]
MI130_1 CKPRCH GCKPRCHB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=453n m=5
MI130 CKPRCH GCKPRCHB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=452n
+ m=8
MImdummy8 VDDP VDDP GCKPRCHB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=142n m=1
MI129 VDDPI GCKPRCHB CKPRCH VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=367n m=6
Xinv_prckwr[0] VDDA VSS VBP VBN net281[0] PRCHWR[0]
+ mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1 wn=167n wp=334n
Xinv_prckwr[1] VDDA VSS VBP VBN net281[1] PRCHWR[1]
+ mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1 wn=167n wp=334n
Xinv_prckwr[2] VDDA VSS VBP VBN net281[2] PRCHWR[2]
+ mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1 wn=167n wp=334n
Xinv_prckwr[3] VDDA VSS VBP VBN net281[3] PRCHWR[3]
+ mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1 wn=167n wp=334n
XI128 VDDPI VSS VBP VBN GCKPRCHB CKPRCHB mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=7 nf_n=1 nf_p=1
+ wn=125n wp=142n
XInv_prchrd[0] VDDP VSS VBP VBN PRCHRD_INT[0] PRCHRD[0]
+ mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1 wn=334n wp=167n
XInv_prchrd[1] VDDP VSS VBP VBN PRCHRD_INT[1] PRCHRD[1]
+ mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1 wn=334n wp=167n
XInv_prchrd[2] VDDP VSS VBP VBN PRCHRD_INT[2] PRCHRD[2]
+ mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1 wn=334n wp=167n
XInv_prchrd[3] VDDP VSS VBP VBN PRCHRD_INT[3] PRCHRD[3]
+ mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1 wn=334n wp=167n
Xprch VDDA VDDP VDDPI VDDWL VDDWL_PCOM VDDP VSS VBP VBN PRCHRDB[0] PRCHRDB[1]
+ PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] RASSISTB[0]
+ RASSISTB[1] LCGTHB LCGTH PRCHRD_INT[0] PRCHRD_INT[1] PRCHRD_INT[2]
+ PRCHRD_INT[3] net281[0] net281[1] net281[2] net281[3] PROCOML RASSIST[0]
+ RASSIST[1] mm19a04_u_hs1prf_lcenrebuf
.ends

.subckt mm19a04_u_ram6t_corner_hs1prf VSS VBA
MNPD_corner noconnect1 noconnect_gate1 VSS VBA spjnfetpd cpp=110n p_la=0 ulp=0
+ nf=1 l=30n w=100n m=1
.ends

.subckt mm19a04_u_hs1prf_lcenbuf VDDA VDDP VDDPI VDDWL VDDWL_PCOM VSS VBP VBN
+ CKPRCHB PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+ PRCHWRB[2] PRCHWRB[3] RASSISTB[0] RASSISTB[1] ARYSD ARYSD_BC1 ARYSD_BC2
+ DLYPDB DRAIN_RIGHT2 GATE_RIGHT1 GATE_RIGHT2 LCGTHB VBA CKPRCH LCGTH LOG0 LOG1
+ PRCHRD[0] PRCHRD[1] PRCHRD[2] PRCHRD[3] PRCHWRH[0] PRCHWRH[1] PRCHWRH[2]
+ PRCHWRH[3] PROCOML RASSIST[0] RASSIST[1]
Xlcbuf VDDA VDDP VDDPI VDDWL VDDWL_PCOM VSS VBP VBN CKPRCHB net103 PRCHRDB[0]
+ PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3]
+ RASSISTB[0] RASSISTB[1] LCGTHB CKPRCH LCGTH PRCHRD[0] PRCHRD[1] PRCHRD[2]
+ PRCHRD[3] PRCHWRH[0] PRCHWRH[1] PRCHWRH[2] PRCHWRH[3] PROCOML RASSIST[0]
+ RASSIST[1] mm19a04_u_hs1prf_lcenbuf_base_exp
XIDUMMY VSS VBA mm19a04_u_ram6t_corner_hs1prf
.ends

.subckt mm19a04_u_hc_cmux_pg VDDP VSS VBP VBN BB BT RB RT WB WT RPASS WPASS
MPRT BT RPASS RT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=350n m=1
MPRB BB RPASS RB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=350n m=1
MNWT BT WPASS WT VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=350n m=3
MNWB BB WPASS WB VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=350n m=3
.ends

.subckt mm19a04_u_hc_cmux_pch VDDPI VBP VBN BB BT PRCHB
MBB_PCH VDDPI PRCHB BB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=350n
+ m=1
M_EQU BT PRCHB BB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=350n m=1
MBT_PCH VDDPI PRCHB BT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=350.0n
+ m=1
.ends

.subckt mm19a04_u_hc_cmux VDDA VDDAI VDDP VDDPI VSS VBP VBN BB BT LOG1 RB RT WB
+ WT PCWRX PRCHB RPASS
XWPASS VDDA VSS VBP VBN WPASS PCWRX mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120.0n
+ wp=120.0n
XPG VDDP VSS VBP VBN BB BT RB RT WB WT RPASS WPASS mm19a04_u_hc_cmux_pg
XPCH VDDPI VBP VBN BB BT PRCHB mm19a04_u_hc_cmux_pch
.ends

.subckt mm19a04_u_hc_cmux2 VDDA VDDAI VDDP VDDPI VSS VBP VBN BB[0] BB[1] BT[0]
+ BT[1] RB[0] RB[1] RT[0] RT[1] WB[0] WB[1] WT[0] WT[1] PRCHB PRCHWRB[0]
+ PRCHWRB[1] RPASS[0] RPASS[1]
X[0] VDDA VDDAI VDDP VDDPI VSS VBP VBN BB[0] BT[0] net90[0] RB[0] RT[0] WB[0]
+ WT[0] PRCHWRB[0] PRCHB RPASS[0] mm19a04_u_hc_cmux
X[1] VDDA VDDAI VDDP VDDPI VSS VBP VBN BB[1] BT[1] net90[1] RB[1] RT[1] WB[1]
+ WT[1] PRCHWRB[1] PRCHB RPASS[1] mm19a04_u_hc_cmux
.ends

.subckt mm19a04_u_strap_x1_hs1prf VDDA VDDAI VSS VBP VBN BB BT DR_COM_0
+ DR_COM_1 DR_COM_2 GT_COM_0 GT_COM_1 GT_COM_2 VBA
MPPU_strap noconnect2 floatgate1 VDDAI VBA spjpfetpu cpp=110n p_la=0 ulp=0 nf=1
+ l=30n w=50n m=1
MNPG_strap noconnect1 VSS BB VBA spjnfetwl cpp=110n p_la=0 ulp=0 nf=1 l=30n
+ w=96n m=1
MNPD_strap noconnect3 floatgate1 VSS VBA spjnfetpd cpp=110n p_la=0 ulp=0 nf=1
+ l=30n w=100n m=1
.ends

.subckt mm19a04_u_ram6t_strapx4_hs1prf VDDA VDDAI VSS VBP VBN BB[0] BB[1] BB[2]
+ BB[3] BT[0] BT[1] BT[2] BT[3] DR_BOT[1] DR_BOT[2] DR_TOP[1] DR_TOP[2]
+ GT_BOT[1] GT_BOT[2] GT_TOP[1] GT_TOP[2] VBA
Xtr0 VDDA VDDAI VSS VBP VBN BB[0] BT[0] DR_BOT[1] DR_BOT[2] DR20 GT_BOT[1]
+ GT_BOT[2] VSS VBA mm19a04_u_strap_x1_hs1prf
Xtr2 VDDA VDDAI VSS VBP VBN BB[2] BT[2] DR01 DR11 DR21 GT01 GT11 VSS VBA
+ mm19a04_u_strap_x1_hs1prf
Xtr3 VDDA VDDAI VSS VBP VBN BB[3] BT[3] DR_TOP[1] DR_TOP[2] DR21 GT_TOP[1]
+ GT_TOP[2] VSS VBA mm19a04_u_strap_x1_hs1prf
Xtr1 VDDA VDDAI VSS VBP VBN BB[1] BT[1] DR01 DR11 DR20 GT01 GT11 VSS VBA
+ mm19a04_u_strap_x1_hs1prf
.ends

.subckt mm19a04_u_hs1prf_cmux4x1 VDDA VDDAI VDDP VDDPI VSS VBP VBN BB[0] BB[1]
+ BB[2] BB[3] BT[0] BT[1] BT[2] BT[3] DRAIN_LEFT1 DRAIN_LEFT2 DRAIN_RIGHT1
+ DRAIN_RIGHT2 GATE_LEFT1 GATE_LEFT2 GATE_RIGHT1 GATE_RIGHT2 LOG0 LOG1 LQB RB
+ RT VBA WB WBI WT WTI BADB CKPRCHB PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3]
+ PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] SEL
Mdummy1[0] VDDPI VDDP BB[0] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=350n m=1
Mdummy1[1] VDDPI VDDP BB[1] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=350n m=1
Mdummy1[2] VDDPI VDDP BB[2] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=350n m=1
Mdummy1[3] VDDPI VDDP BB[3] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=350n m=1
Mdummy2[0] VDDPI VDDP BT[0] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=350n m=1
Mdummy2[1] VDDPI VDDP BT[1] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=350n m=1
Mdummy2[2] VDDPI VDDP BT[2] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=350n m=1
Mdummy2[3] VDDPI VDDP BT[3] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=350n m=1
XMX00 VDDA VDDA VDDP VDDPI VSS VBP VBN BB[0] BB[1] BT[0] BT[1] RB RB RT RT WB
+ WB WT WT PRCHB PRCHWRB[0] PRCHWRB[1] RPASS[0] RPASS[1] mm19a04_u_hc_cmux2
XMXFF VDDA VDDA VDDP VDDPI VSS VBP VBN BB[2] BB[3] BT[2] BT[3] RB RB RT RT WB
+ WB WT WT PRCHB PRCHWRB[2] PRCHWRB[3] RPASS[2] RPASS[3] mm19a04_u_hc_cmux2
XI60 VDDA VDDAI VSS VBP VBN BB[0] BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3]
+ net206[0] net206[1] net208[0] net208[1] net209[0] net209[1] net204[0]
+ net204[1] VBA mm19a04_u_ram6t_strapx4_hs1prf
XIrpass[0] VDDPI VSS VBP VBN RPASS[0] PRCHRDB[0] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XIrpass[1] VDDPI VSS VBP VBN RPASS[1] PRCHRDB[1] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XIrpass[2] VDDPI VSS VBP VBN RPASS[2] PRCHRDB[2] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XIrpass[3] VDDPI VSS VBP VBN RPASS[3] PRCHRDB[3] mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI120 VDDPI VSS VBP VBN PRCHB CKPRCHB mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=4 nf_n=1 nf_p=1 wn=120n
+ wp=120n
.ends

.subckt mm19a04_u_logrepedge_hs1prf VDDP VSS VBP VBN LOG0 LOG1
MPLOG VDDP LOG0 LOG1 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=8
M0 LOG0 LOG1 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n m=8
.ends

.subckt mm19a04_u_hs1prf_capmux VDDA VDDAI VDDP VDDPI VSS VBP VBN DRAIN_LEFT2
+ GATE_LEFT1 GATE_LEFT2 LOG0 LOG1 PGIOI VBA VEDGE
XIDUMMY VSS VBA mm19a04_u_ram6t_corner_hs1prf
XI8 VDDP VSS VBP VBN LOG0 LOG1 mm19a04_u_logrepedge_hs1prf
.ends

.subckt mm19a04_u_hs1prf_rbl_load VSS VBP VBN LOG0 RBLRD RBLWA RBLWR
MI17 X4 LOG0 RBLWA VBN slvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI16 X3 LOG0 RBLWA VBN slvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI15 X2 LOG0 RBLWA VBN slvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI14 X1 LOG0 RBLWA VBN slvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M13 X4 LOG0 RBLWR VBN slvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M12 X4 LOG0 RBLRD VBN slvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=2
M11 X3 LOG0 RBLWR VBN slvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M10 X3 LOG0 RBLRD VBN slvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=2
M9 X2 LOG0 RBLWR VBN slvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M8 X2 LOG0 RBLRD VBN slvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=2
M1 X1 LOG0 RBLWR VBN slvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M0 X1 LOG0 RBLRD VBN slvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=2
.ends

.subckt mm19a04_u_xdec_nr2 VDDWL VSS VBP VBN WLBB SOFTVDDA DEC WCLKB
M17 WLBB WCLKB VSS VBN slvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI39 WLBB DEC VSS VBN slvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M33 SOFTVDDA WCLKB WLBB VBP slvtpfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=480n
+ m=2
.ends

.subckt mm19a04_u_xdec_base_hs1prf VDDP VDDPI VDDWL VSS VBP VBN DEC_LV WLBB[0]
+ WLBB[1] WLBB[2] WLBB[3] B C DEC_HV WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
XI74[1] VDDWL VSS VBP VBN WLBB[1] net223 DEC_HV WCLKB[1] mm19a04_u_xdec_nr2
XI73[2] VDDWL VSS VBP VBN WLBB[2] net246 DEC_HV WCLKB[2] mm19a04_u_xdec_nr2
XDEC_NR2[0] VDDWL VSS VBP VBN WLBB[0] net246 DEC_HV WCLKB[0] mm19a04_u_xdec_nr2
XDEC_NR2[3] VDDWL VSS VBP VBN WLBB[3] net223 DEC_HV WCLKB[3] mm19a04_u_xdec_nr2
MI72 VDDWL DEC_HV net246 VBP slvtpfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=480n
+ m=2
M33 VDDWL DEC_HV net223 VBP slvtpfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=480n
+ m=2
XI82 VDDPI VSS VBP VBN DEC_LV B C
+ mm19a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=110n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=480n wn2=480n wp1=240n
+ wp2=240n
.ends

.subckt mm19a04_u_hs1prf_x4dec VDDA VDDF VDDP VDDPI VDDWL VSS VSSWLL VSSWLR VBP
+ VBN DEC_LV WLBH[0] WLBH[1] WLBH[2] WLBH[3] WLBL[0] WLBL[1] WLBL[2] WLBL[3]
+ BYP_VLOAD CKGATE DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET LDFTX LOG0
+ LOG1 LWEIB RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB T1T
+ TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0]
+ WPBUF[1] WPBUF[2] B C CENDP DEC_HV FLOAT LBKADR[0] LITESLP LXADR[0] LXADR[1]
+ LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+ PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+ PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
XREFBL VSS VBP VBN LOG0 RBLRD RBLWA RBLWR mm19a04_u_hs1prf_rbl_load
MI114[0] WLBL[0] WLBB[0] VSSWLL VBN slvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n
+ w=800n m=2
MI114[1] WLBL[1] WLBB[1] VSSWLL VBN slvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n
+ w=800n m=2
MI114[2] WLBL[2] WLBB[2] VSSWLL VBN slvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n
+ w=800n m=2
MI114[3] WLBL[3] WLBB[3] VSSWLL VBN slvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n
+ w=800n m=2
M17[0] WLBH[0] WLBB[0] VSSWLR VBN slvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n
+ w=800n m=2
M17[1] WLBH[1] WLBB[1] VSSWLR VBN slvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n
+ w=800n m=2
M17[2] WLBH[2] WLBB[2] VSSWLR VBN slvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n
+ w=800n m=2
M17[3] WLBH[3] WLBB[3] VSSWLR VBN slvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n
+ w=800n m=2
XDECBASE VDDP VDDPI VDDWL VSS VBP VBN DEC_LV WLBB[0] WLBB[1] WLBB[2] WLBB[3] B
+ C DEC_HV WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] mm19a04_u_xdec_base_hs1prf
MI115[0] VDDA WLBB[0] WLBL[0] VBP slvtpfet cpp=110n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=2
MI115[1] VDDA WLBB[1] WLBL[1] VBP slvtpfet cpp=110n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=2
MI115[2] VDDA WLBB[2] WLBL[2] VBP slvtpfet cpp=110n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=2
MI115[3] VDDA WLBB[3] WLBL[3] VBP slvtpfet cpp=110n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=2
M33[0] VDDA WLBB[0] WLBH[0] VBP slvtpfet cpp=110n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=2
M33[1] VDDA WLBB[1] WLBH[1] VBP slvtpfet cpp=110n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=2
M33[2] VDDA WLBB[2] WLBH[2] VBP slvtpfet cpp=110n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=2
M33[3] VDDA WLBB[3] WLBH[3] VBP slvtpfet cpp=110n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=2
.ends

.subckt mm19a04_u_edge1_hs1prf VSS VBA WL
MNPD_edge net93 floatgate1 VSS VBA spjnfetpd cpp=110n p_la=0 ulp=0 nf=1 l=30n
+ w=100n m=1
MNPG_edge net93 WL VSS VBA spjnfetwl cpp=110n p_la=0 ulp=0 nf=1 l=30n w=96n m=1
.ends

.subckt mm19a04_u_edge4_hs1prf_gf22 VDDA VDDP VDDPI VSS VBP VBN EDGEB EDGET
+ LOG0 LOG1 PGIOI VBA VEDGE WL[0] WL[1] WL[2] WL[3]
XDUMMY[0] VSS VBA WL[0] mm19a04_u_edge1_hs1prf
XDUMMY[1] VSS VBA WL[1] mm19a04_u_edge1_hs1prf
XDUMMY[2] VSS VBA WL[2] mm19a04_u_edge1_hs1prf
XDUMMY[3] VSS VBA WL[3] mm19a04_u_edge1_hs1prf
.ends

.subckt mm19a04_u_read_assist_hs1prf VDD_BULK VSS VBP VBN RD_ASSIST_BIAS[0]
+ RD_ASSIST_BIAS[1] WL
M0 WL RD_ASSIST_BIAS[0] VSS VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=140n m=2
M1 WL RD_ASSIST_BIAS[1] VSS VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=360n m=2
.ends

.subckt mm19a04_u_xbuf1_gf22_hs1prf VDDWL VDDWL_PCOM VDD_BK VSS VBP VBN WL WLB
M18 VDDWL WLB WL VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=740n m=2
Xwldriver VDDWL VSS VBP VBN WL WLB mm19a04_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=945n
+ wp=1040n
.ends

.subckt mm19a04_u_hs1prf_xbuf4 VDDWL VDDWL_PCOM VDD_BK VSS VBP VBN WL[0] WL[1]
+ WL[2] WL[3] RD_ASSIST_BIAS[0] RD_ASSIST_BIAS[1] WLB[0] WLB[1] WLB[2] WLB[3]
XI21 VDD_BK VSS VBP VBN RD_ASSIST_BIAS[0] RD_ASSIST_BIAS[1] WL[2]
+ mm19a04_u_read_assist_hs1prf
XI20 VDD_BK VSS VBP VBN RD_ASSIST_BIAS[0] RD_ASSIST_BIAS[1] WL[3]
+ mm19a04_u_read_assist_hs1prf
XI22 VDD_BK VSS VBP VBN RD_ASSIST_BIAS[0] RD_ASSIST_BIAS[1] WL[1]
+ mm19a04_u_read_assist_hs1prf
XI23 VDD_BK VSS VBP VBN RD_ASSIST_BIAS[0] RD_ASSIST_BIAS[1] WL[0]
+ mm19a04_u_read_assist_hs1prf
XWL3 VDDWL VDDWL_PCOM VDD_BK VSS VBP VBN WL[3] WLB[3]
+ mm19a04_u_xbuf1_gf22_hs1prf
XWL2 VDDWL VDDWL_PCOM VDD_BK VSS VBP VBN WL[2] WLB[2]
+ mm19a04_u_xbuf1_gf22_hs1prf
XWL0 VDDWL VDDWL_PCOM VDD_BK VSS VBP VBN WL[0] WLB[0]
+ mm19a04_u_xbuf1_gf22_hs1prf
XWL1 VDDWL VDDWL_PCOM VDD_BK VSS VBP VBN WL[1] WLB[1]
+ mm19a04_u_xbuf1_gf22_hs1prf
.ends

.subckt mm19a04_u_hs1prf_x4buf_base VDDWL VDDWL_PCOM VDDA VSS VBP VBN WL[0]
+ WL[1] WL[2] WL[3] RD_ASSIST_BIAS[0] RD_ASSIST_BIAS[1] WLB[0] WLB[1] WLB[2]
+ WLB[3]
XDEC VDDWL VDDWL_PCOM VDDA VSS VBP VBN WL[0] WL[1] WL[2] WL[3]
+ RD_ASSIST_BIAS[0] RD_ASSIST_BIAS[1] WLB[0] WLB[1] WLB[2] WLB[3]
+ mm19a04_u_hs1prf_xbuf4
.ends

.subckt mm19a04_u_hs1prf_x4buf VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[0] WL[1]
+ WL[2] WL[3] ARYSD ARYSD_BC1 ARYSD_BC2 DLYPDB EDGEB EDGET LCGTH LOG0 LOG1
+ PROCOML RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[0] WLB[1]
+ WLB[2] WLB[3]
XDUMMY VDDA VDDP VDDPI VSS VBP VBN EDGEB EDGET LOG0 LOG1 A VBA VDDPI WL[0]
+ WL[1] WL[2] WL[3] mm19a04_u_edge4_hs1prf_gf22
XBUF VDDWL VDDWL VDDA VSS VBP VBN WL[0] WL[1] WL[2] WL[3] RASSISTB[0]
+ RASSISTB[1] WLB[0] WLB[1] WLB[2] WLB[3] mm19a04_u_hs1prf_x4buf_base
.ends

.subckt mm19a04_u_ram6x_base VDDA_RB VDDA_RT VNWA VSSC_RB VSS VBP VBN BB BT RB
+ RT VBA VSCS_RT WL_RB WL_RT
MPPU_T VDDA_RT RB RT VBA spjpfetpu cpp=110n p_la=0 ulp=0 nf=1 l=30n w=50n m=1
MPPU_B VDDA_RB RT RB VBA spjpfetpu cpp=110n p_la=0 ulp=0 nf=1 l=30n w=50n m=1
MNPG_B BB WL_RB RB VBA spjnfetwl cpp=110n p_la=0 ulp=0 nf=1 l=30n w=96n m=1
MNPD_T VSCS_RT RB RT VBA spjnfetpd cpp=110n p_la=0 ulp=0 nf=1 l=30n w=100n m=1
MNPG_T BT WL_RT RT VBA spjnfetwl cpp=110n p_la=0 ulp=0 nf=1 l=30n w=96n m=1
MNPD_B VSSC_RB RT RB VBA spjnfetpd cpp=110n p_la=0 ulp=0 nf=1 l=30n w=100n m=1
.ends

.subckt mm19a04_u_ram6x VDDA_RB VDDA_RT VNWA VSS VSSC_RB VBP VBN BB BT RB RT
+ VBA VSCS_RT WL_RB WL_RT
XBASE VDDA_RB VDDA_RT VNWA VSSC_RB VSS VBP VBN BB BT RB RT VBA VSCS_RT WL_RB
+ WL_RT mm19a04_u_ram6x_base
.ends

.subckt mm19a04_u_ram6t VDDA VNWA VSS VSSC VBP VBN BB BT VBA WL
XRAM VDDA VDDA VNWA VSS VSSC VBP VBN BB BT RB RT VBA VSSC WL WL mm19a04_u_ram6x
.ends

.subckt mm19a04_u_hsrf1p_bar4x4m4 VDDA VDDNW VDDP VDDPI VSS VSSC VBP VBN BADB
+ BB[0] BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3] QBB QTB VBA WBI WTI WL[0]
+ WL[1] WL[2] WL[3]
XA00 VDDA VDDNW VSS VSSC VBP VBN BB[0] BT[0] VBA WL[0] mm19a04_u_ram6t
XA01 VDDA VDDNW VSS VSSC VBP VBN BB[1] BT[1] VBA WL[0] mm19a04_u_ram6t
XA02 VDDA VDDNW VSS VSSC VBP VBN BB[2] BT[2] VBA WL[0] mm19a04_u_ram6t
XAFF VDDA VDDNW VSS VSSC VBP VBN BB[3] BT[3] VBA WL[0] mm19a04_u_ram6t
XC00 VDDA VDDNW VSS VSSC VBP VBN BB[0] BT[0] VBA WL[2] mm19a04_u_ram6t
XCFF VDDA VDDNW VSS VSSC VBP VBN BB[3] BT[3] VBA WL[2] mm19a04_u_ram6t
XC01 VDDA VDDNW VSS VSSC VBP VBN BB[1] BT[1] VBA WL[2] mm19a04_u_ram6t
XBFF VDDA VDDNW VSS VSSC VBP VBN BB[3] BT[3] VBA WL[1] mm19a04_u_ram6t
XB02 VDDA VDDNW VSS VSSC VBP VBN BB[2] BT[2] VBA WL[1] mm19a04_u_ram6t
XB01 VDDA VDDNW VSS VSSC VBP VBN BB[1] BT[1] VBA WL[1] mm19a04_u_ram6t
XB00 VDDA VDDNW VSS VSSC VBP VBN BB[0] BT[0] VBA WL[1] mm19a04_u_ram6t
XD02 VDDA VDDNW VSS VSSC VBP VBN BB[2] BT[2] VBA WL[3] mm19a04_u_ram6t
XC02 VDDA VDDNW VSS VSSC VBP VBN BB[2] BT[2] VBA WL[2] mm19a04_u_ram6t
XD01 VDDA VDDNW VSS VSSC VBP VBN BB[1] BT[1] VBA WL[3] mm19a04_u_ram6t
XD00 VDDA VDDNW VSS VSSC VBP VBN BB[0] BT[0] VBA WL[3] mm19a04_u_ram6t
XDFF VDDA VDDNW VSS VSSC VBP VBN BB[3] BT[3] VBA WL[3] mm19a04_u_ram6t
.ends

.subckt mm19a04_u_hs1prf_ar4x4m4 VDDA VDDAI VDDP VDDPI VSS VBP VBN BADB BB[0]
+ BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3] LQB VBA WBI WTI WL[0] WL[1] WL[2]
+ WL[3]
XBAR4 VDDAI VDDA VDDP VDDPI VSS VSS VBP VBN BADB BB[0] BB[1] BB[2] BB[3] BT[0]
+ BT[1] BT[2] BT[3] LQB net23 VBA WBI WTI WL[0] WL[1] WL[2] WL[3]
+ mm19a04_u_hsrf1p_bar4x4m4
.ends

.subckt mm19a04_u_edge4_hs1prf VDDA VDDAI VDDP VSS VBP VBN PGIOI VBA VEDGE
+ WL[0] WL[1] WL[2] WL[3]
XDUMMy[0] VSS VBA WL[0] mm19a04_u_edge1_hs1prf
XDUMMy[1] VSS VBA WL[1] mm19a04_u_edge1_hs1prf
XDUMMy[2] VSS VBA WL[2] mm19a04_u_edge1_hs1prf
XDUMMy[3] VSS VBA WL[3] mm19a04_u_edge1_hs1prf
.ends

.subckt mm19a04_u_write_delay_slow_hs1prf_slow_mode VDDP VDDPI VSS VBP VBN OUT
+ OUT_RD_DLY10 OUT_RD_DLY2 IN RWLB WMT3
MI30 net114 OUT_RD_DLY2 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=1
MI22_nmos_a1 OUT RWLB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=2
MI49 net254 net247 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
MI46 net251 net241 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
MI22_nmos_a2 OUT DEF_BYPASS VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=2
MI45 VDDPI net239 net250 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n
+ m=1
MI47 VDDPI net243 net252 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n
+ m=1
MI48 VDDPI DLY_ND1 net253 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n
+ m=1
MI50 VDDPI net249 net255 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n
+ m=1
XI36 net255 VSS VBP VBN OUT_RD_DLY10 net249 mm19a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=160n
XI34 VDDPI VSS VBP VBN WMSLOW WMT3 mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=160n
XI31 VDDPI VSS VBP VBN OUT_RD_DLY2 INB mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI29 VDDPI net251 VBP VBN net243 net241 mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=160n
XI27 net252 VSS VBP VBN net236 net243 mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=160n
XI26 VDDPI net254 VBP VBN net249 net247 mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=160n
XI25 VDDPI VSS VBP VBN WMSLOWB WMSLOW mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=160n
XI24 net250 VSS VBP VBN net241 net239 mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=160n
XI21 net253 VSS VBP VBN net247 DLY_ND1 mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=160n
XI18 VDDPI VSS VBP VBN INB IN mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=1 nf_n=1 nf_p=1 wn=160n wp=160n
XI17 VDDPI net114 VBP VBN net239 OUT_RD_DLY2 mm19a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=160n
XI37 VDDPI VSS VBP VBN DLY_ND2 OUT_RD_DLY2 OUT_RD_DLY10
+ mm19a04_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=160n
+ wp2=160n
XI39 VDDPI VSS VBP VBN DLY_ND1 OUT_RD_DLY2 net236
+ mm19a04_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=160n
+ wp2=160n
XI33 VBP VBN INB DEF_BYPASS WMSLOWB WMSLOW mm19a04_u_tg_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=120n wp=160n
XI32 VBP VBN DLY_ND2 DEF_BYPASS WMSLOW WMSLOWB mm19a04_u_tg_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=160n
XI22 VDDPI VSS VBP VBN OUT RWLB DEF_BYPASS
+ mm19a04_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=360n
+ wp2=360n
.ends

.subckt mm19a04_u_wrtimer_logic_hs1prf VSS VBP VBN DBL LOG1 RMT[0] RMT[1]
+ RMT[2] RWL_AND_RWLD
MI20 net78 LOG1 VSS VBN slvtnfet cpp=104n p_la=8n ulp=0 nf=1 l=20n w=120n m=1
M0 W0 LOG1 net48 VBN slvtnfet cpp=104n p_la=8n ulp=0 nf=1 l=20n w=120n m=1
M1 DBL RWL_AND_RWLD W0 VBN slvtnfet cpp=104n p_la=8n ulp=0 nf=1 l=20n w=120n
+ m=1
M2 DBL RWL_AND_RWLD W3 VBN slvtnfet cpp=104n p_la=8n ulp=0 nf=1 l=20n w=160n
+ m=2
M3 W3 RMT[0] VSS VBN slvtnfet cpp=104n p_la=8n ulp=0 nf=1 l=20n w=160n m=2
M4 W4 RMT[1] VSS VBN slvtnfet cpp=104n p_la=8n ulp=0 nf=1 l=20n w=160n m=3
M5 DBL RWL_AND_RWLD W4 VBN slvtnfet cpp=104n p_la=8n ulp=0 nf=1 l=20n w=160n
+ m=3
M6 DBL RWL_AND_RWLD W5 VBN slvtnfet cpp=104n p_la=8n ulp=0 nf=1 l=20n w=512n
+ m=5
M7 W5 RMT[2] VSS VBN slvtnfet cpp=104n p_la=8n ulp=0 nf=1 l=20n w=512n m=5
MI16 net48 LOG1 net58 VBN slvtnfet cpp=104n p_la=8n ulp=0 nf=1 l=20n w=120n m=1
MI19 net76 LOG1 net78 VBN slvtnfet cpp=104n p_la=8n ulp=0 nf=1 l=20n w=120n m=1
MI18 net58 LOG1 net76 VBN slvtnfet cpp=104n p_la=8n ulp=0 nf=1 l=20n w=120n m=1
.ends

.subckt mm19a04_u_rdtimer_logic_hs1prf VSS VBP VBN DBL LOG1 RMT[0] RMT[1]
+ RMT[2] RWL_AND_RWLD
MI21 net78 LOG1 VSS VBN slvtnfet cpp=104n p_la=8n ulp=0 nf=1 l=20n w=120n m=1
MI20 net74 RMT[0] VSS VBN slvtnfet cpp=104n p_la=8n ulp=0 nf=1 l=20n w=120n m=1
M0 W0 LOG1 net47 VBN slvtnfet cpp=104n p_la=8n ulp=0 nf=1 l=20n w=120n m=1
M1 DBL RWL_AND_RWLD W0 VBN slvtnfet cpp=104n p_la=8n ulp=0 nf=1 l=20n w=120n
+ m=1
M2 DBL RWL_AND_RWLD W3 VBN slvtnfet cpp=104n p_la=8n ulp=0 nf=1 l=20n w=120n
+ m=1
M3 W3 RMT[0] net74 VBN slvtnfet cpp=104n p_la=8n ulp=0 nf=1 l=20n w=120n m=1
M4 W4 RMT[1] VSS VBN slvtnfet cpp=104n p_la=8n ulp=0 nf=1 l=20n w=120n m=1
M5 DBL RWL_AND_RWLD W4 VBN slvtnfet cpp=104n p_la=8n ulp=0 nf=1 l=20n w=120n
+ m=1
M6 DBL RWL_AND_RWLD W5 VBN slvtnfet cpp=104n p_la=8n ulp=0 nf=1 l=20n w=200n
+ m=2
M7 W5 RMT[2] VSS VBN slvtnfet cpp=104n p_la=8n ulp=0 nf=1 l=20n w=200n m=2
MI18 net52 LOG1 net72 VBN slvtnfet cpp=104n p_la=8n ulp=0 nf=1 l=20n w=120n m=1
MI19 net72 LOG1 net78 VBN slvtnfet cpp=104n p_la=8n ulp=0 nf=1 l=20n w=120n m=1
MI17 net47 LOG1 net52 VBN slvtnfet cpp=104n p_la=8n ulp=0 nf=1 l=20n w=120n m=1
.ends

.subckt mm19a04_u_rwl_and_rwld_hs1prf_slow_mode VDDA VSS VBP VBN RWL_AND_RWLD
+ RWLB RWLD
XI6 VDDA VSS VBP VBN RWLT RWLB mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=298n
+ wp=300n
M3 RWL_AND_RWLD RWLB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n
+ m=6
XI93 VBP VBN RWLD RWL_AND_RWLD RWLT RWLB mm19a04_u_tg_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=1 nf_n=1 nf_p=1 wn=230n
+ wp=440n
.ends

.subckt mm19a04_u_rwtimer_hs1prf_gf22_slow_mode VDDA VDDP VDDPI VSS VBP VBN
+ LOG0 LOG1 OUT_RD_DLY10 OUT_RD_DLY2 RBL RWLB_RD RWLB_WR RWLD_RD RWLD_RD_DLY
+ RWLD_WR WBL LWEIBB RMT[0] RMT[1] RMT[2] RWL_INT WMT[0] WMT[1] WMT[2] WMT[3]
MI174 VDDPI RWLD_WR_AND WBL VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=256n m=5
MI140 VDDPI RWLD_RD_AND RBL VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=256n m=5
MI33_2 RWLD_RD_DLY SEL_SLOWB OUT_RD_DLY2 VBN slvtnfet cpp=104n p_la=4n ulp=0
+ nf=1 l=20n w=250n m=1
XI172 VDDP VDDPI VSS VBP VBN RWLD_WR_AND OUT_RD_DLY10 OUT_RD_DLY2 RWLD_WR
+ RWLB_WR WMT[3] mm19a04_u_write_delay_slow_hs1prf_slow_mode
XI175 VSS VBP VBN WBL LOG1 WMT[0] WMT[1] WMT[2] RWLD_WR_AND
+ mm19a04_u_wrtimer_logic_hs1prf
XI22 VDDPI VSS VBP VBN SEL_SLOW RMT[2] RMT[1]
+ mm19a04_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=240n
+ wp2=240n
XI141 VSS VBP VBN RBL LOG1 RMT[0] RMT[1] RMT[2] RWLD_RD_AND
+ mm19a04_u_rdtimer_logic_hs1prf
XI178 VDDPI VSS VBP VBN SEL_SLOWB SEL_SLOW mm19a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=240n
XI32 VBP VBN OUT_RD_DLY10 RWLD_RD_DLY SEL_SLOW SEL_SLOWB
+ mm19a04_u_tg_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=160n
XI33 VBP VBN OUT_RD_DLY2 RWLD_RD_DLY SEL_SLOWB SEL_SLOW
+ mm19a04_u_tg_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=230n wp=440n
XI132 VDDA VSS VBP VBN RWLD_RD_AND RWLB_RD RWLD_RD_DLY
+ mm19a04_u_rwl_and_rwld_hs1prf_slow_mode
.ends

.subckt mm19a04_u_hs1prf_rwlgen VDDA VDDPI VSS VBP VBN LWEIBB RWLB_RD RWLB_WR
+ RWL_INT RWLB_BUF LWEIB_HV RWLB_SAC
XI98 VDDA VSS VBP VBN LWEIBB RWLB_SAC LWEIB_HV
+ mm19a04_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=220n wn2=220n wp1=440n
+ wp2=440n
MI104 VSS LWEIBB RWL_INT VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=340n
+ m=1
MI80 RWL_INT RWLB_SAC VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=340n
+ m=1
MI111 RWLB_WR LWEIBB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=220n
+ m=2
MI113 RWLB_RD RWL_INT VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=340n
+ m=1
XI192 VDDA VSS VBP VBN RWLB_BUF net256 mm19a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=340n
+ wp=440n
XInr2_rwlb VDDA VSS VBP VBN net256 RWLB_SAC mm19a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=170n wp=300n
MI79 net219 RWLB_SAC RWL_INT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=440n m=1
MI105 net219 LWEIBB VDDA VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=440n
+ m=1
MI110 VDDA LWEIBB RWLB_WR VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=440n
+ m=1
MI114 VDDA RWL_INT RWLB_RD VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=440n m=1
.ends

.subckt mm19a04_u_hs1prf_rw_gf22 VDDA VDDF VDDP VDDPI VSS VSSWLL VSSWLR VBP VBN
+ RWLB_RD RWLB_WR CENDP CKGATE DEF_MODE FAST1_MODE FAST2_MODE FLOAT_RET
+ LBKADR[0] LCGTHB LDFTX LITESLP LOG0 LOG1 LWEIB_HV LXADR[0] LXADR[1] LXADR[2]
+ LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] RBLRD RBLWA
+ RBLWR RM3CNT RWLB RWLB_BUF T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WPBUF[0]
+ WPBUF[1] WPBUF[2] FLOAT FLOATT LWEIB RMT[0] RMT[1] RMT[2] RMT[3] RWLD WMT[0]
+ WMT[1] WMT[2] WMT[3]
XIfloat_lockup_inv2_rblwa VDDPI VSS VBP VBN net681 FLOAT LWEIB
+ mm19a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=360n
+ wp2=360n
MI166 VSSWLL LCGTHB VSSWLL VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=400n m=2
MI179 VSS LCGTHB VSSWLR VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=800n
+ m=4
MI178 VSS LCGTHB VSSWLL VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=400n
+ m=8
XI102 VDDA VDDP VDDPI VSS VBP VBN LOG0 LOG1 net677 net676 RBLRD RWLB_RD RWLB_WR
+ RWLD net678 RWLD RBLWR net671 RMT[0] RMT[1] RMT[2] net670 WMT[0] WMT[1]
+ WMT[2] WMT[3] mm19a04_u_rwtimer_hs1prf_gf22_slow_mode
XI101 VDDA VDDPI VSS VBP VBN net671 RWLB_RD RWLB_WR net670 RWLB_BUF LWEIB_HV
+ RWLB mm19a04_u_hs1prf_rwlgen
MIfloat_lockup_inv2_rblwa_2_p2 net679 FLOAT net681 VBP slvtpfet cpp=104n
+ p_la=4n ulp=0 nf=1 l=20n w=360n m=1
MIfloat_lockup_inv2_rblwa_2_p1 VDDPI LWEIB net679 VBP slvtpfet cpp=104n p_la=4n
+ ulp=0 nf=1 l=20n w=360n m=1
XI196 VDDPI VSS VBP VBN RBLWA net681 mm19a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1 wn=320n
+ wp=360n
.ends

.subckt mm19a04_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=125n wn2=125n wp1=120n wp2=120n
MNA1 X A1 VSS VBN lvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 X A2 VSS VBN lvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MPA2 net10 A2 VDD VBP lvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
MPA1 X A1 net10 VBP lvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
.ends

.subckt mm19a04_u_hs1prf_pg_aryslpbuf_rf VDDA VSS VBP VBN ARYSDB_BC1 ARYSDB_BC2
+ ARYSD_INT LLSB RESDOR_RET ARYSD_BC1 ARYSD_BC2 ARYSD_IN LCGTH LOG0
XI52 VDDA VSS VBP VBN net150 LCGTH ARYSD_INT
+ mm19a04_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=240n
+ wp2=240n
XI54 VDDAI_R VSS VBP VBN net167 ARYSD_BC1 ARYSD_INT
+ mm19a04_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=240n
+ wp2=240n
XI53 VDDAI_R VSS VBP VBN net166 ARYSD_BC2 ARYSD_INT
+ mm19a04_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=240n
+ wp2=240n
XI28 VDDA VSS VBP VBN ARYSDB_BC2 net166 mm19a04_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=200n
+ wp=200n
XI34 VDDA VSS VBP VBN LLSB net150 mm19a04_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1 wn=200n
+ wp=200n
XI30 VDDA VSS VBP VBN ARYSDB_BC1 net167 mm19a04_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=200n
+ wp=200n
XI25 VDDA VSS VBP VBN ARYSD_INT ARYSD_IN mm19a04_u_inv_bulk_n_vt1_p_vt1
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=240n wp=240n
MPA VDDA ARYSD_INT VDDAI_R VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=267n
+ m=6
.ends

.subckt mm19a04_u_logrepw VDDP VSS VBP VBN LOG0 LOG1
M0 LOG0 LOG1 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=150n m=4
MPLOG VDDP LOG0 LOG1 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=150n m=4
.ends

.subckt mm19a04_u_xbuf1_gf22_rwbuf_hs1prf VDDWL VDDWL_PCOM VDD_BK VSS VBP VBN
+ WL WLB
Xwldriver VDDWL VSS VBP VBN WL WLB mm19a04_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=10 m_p=11 nf_n=1 nf_p=1 wn=190n
+ wp=323n
.ends

.subckt mm19a04_u_hs1prf_vddwl_header_rw VDDA VDDWL VBP VBN LCGTH
MI11 VDDWL VDDWL VDDA VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=2
M0 VDDA LCGTH VDDWL VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=480n m=22
.ends

.subckt mm19a04_u_hs1prf_pg_wlstkrw_rw VDDA VDDWL VSS VBP VBN LCGTHB LCGTH
XIhs1prf_wl_header VDDA VDDWL VBP VBN LCGTH mm19a04_u_hs1prf_vddwl_header_rw
XI15 VDDA VSS VBP VBN LCGTHB LCGTH mm19a04_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
.ends

.subckt mm19a04_u_hs1prf_rwbuf VDDA VDDP VDDPI VDDWL VDDWL_PCOM VSS VBP VBN
+ ARYSD_TOP LCGTHB LLSB SDB_BC1T SDB_BC2T DLYPDB DRAIN_RIGHT2 GATE_RIGHT1
+ GATE_RIGHT2 LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] RWL
+ RWLB_BUF RWLD SDOR_IN TOPEDGE VBA ARYSD_BC1 ARYSD_BC2 ARYSD_IN LCGTH PROCOML
+ SDOR_OUT
XI25 VDDA VSS VBP VBN SDB_BC1T SDB_BC2T SDOR_IN LLSB ARYSD_TOP ARYSD_BC1
+ ARYSD_BC2 ARYSD_IN LCGTH SDOR_OUT mm19a04_u_hs1prf_pg_aryslpbuf_rf
XIDUMMY VSS VBA mm19a04_u_ram6t_corner_hs1prf
XI11 VDDP VSS VBP VBN LOG0 LOG1 mm19a04_u_logrepw
XWLRD VDDA VDDA VBP VSS VBP VBN RWL RWLB_BUF mm19a04_u_xbuf1_gf22_rwbuf_hs1prf
XWLSTACK VDDA VDDWL VSS VBP VBN LCGTHB LCGTH mm19a04_u_hs1prf_pg_wlstkrw_rw
.ends

.subckt mm19a04_u_hc_wrwlload VDDA VBP VBN RT RWL RWLD
M3 RT RWL VDDA VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
M2 VDDA RWLD RT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
.ends

.subckt mm19a04_u_corebias_gf22_hs1prf VDDA VDDAI VBP VBN SDBD1 SDBD2 LLSB
+ SDB_BC1T SDB_BC2T
M3_2 SDBD1 SDBD1 VDDA VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=200n m=2
M0 VDDAI LLSB VDDA VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n m=5
M2 SDBD1 SDB_BC1T VDDAI VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=155n
+ m=2
M3 SDBD1 SDBD1 VDDA VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=2
M7 SDBD2 SDB_BC2T VDDAI VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=155n
+ m=1
M1 SDBD2 SDBD2 VDDA VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=310n m=1
.ends

.subckt mm19a04_u_hs1prf_rarm4x1 VDDA VDDAI VDDP VDDPI VSS VBP VBN BADB BB[0]
+ BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3] DRAIN_LEFT1 DRAIN_LEFT2
+ DRAIN_RIGHT1 DRAIN_RIGHT2 GATE_LEFT1 GATE_LEFT2 GATE_RIGHT1 GATE_RIGHT2 LOG0
+ LOG1 LQB RWL RWLD SDOR_OUT VBA WBI WTI LLSB SDB_BC1T SDB_BC2T
XI32 VDDA VBP VBN net84 RWL RWLD mm19a04_u_hc_wrwlload
XWLLOAD VDDA VBP VBN net84 RWL RWLD mm19a04_u_hc_wrwlload
XCOREBIAS VDDA VDDAI VBP VBN SDBD1 SDBD2 LLSB SDB_BC1T SDB_BC2T
+ mm19a04_u_corebias_gf22_hs1prf
XI45 VDDA VDDAI VSS VBP VBN BB[0] BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3]
+ net139[0] net139[1] net140[0] net140[1] net141[0] net141[1] net137[0]
+ net137[1] VBA mm19a04_u_ram6t_strapx4_hs1prf
.ends

.subckt mm19a04_u_hs1prf_rarm4x1_ret VDDA VDDAI VDDP VDDPI VSS VBP VBN BADB
+ BB[0] BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3] DRAIN_LEFT1 DRAIN_LEFT2
+ DRAIN_RIGHT1 DRAIN_RIGHT2 GATE_LEFT1 GATE_LEFT2 GATE_RIGHT1 GATE_RIGHT2 LOG0
+ LOG1 LQB RWL RWLD SDOR_OUT VBA WBI WTI LLSB SDB_BC1T SDB_BC2T
XI33 VDDA VBP VBN net82 RWL RWLD mm19a04_u_hc_wrwlload
XI34 VDDA VBP VBN net82 RWL RWLD mm19a04_u_hc_wrwlload
XCOREBIAS VDDA VDDAI VBP VBN SDBD1 SDBD2 LLSB SDB_BC1T SDB_BC2T
+ mm19a04_u_corebias_gf22_hs1prf
XI45 VDDA VDDAI VSS VBP VBN BB[0] BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3]
+ POWINT[0] POWINT[1] net128[0] net128[1] net129[0] net129[1] net126[0]
+ net126[1] VBA mm19a04_u_ram6t_strapx4_hs1prf
.ends

.subckt mm19a04_u_hs1prf_pg_pwedge VDDA VDDAI VDDP VDDPI VSS VBP VBN VEDGE_O
+ DRAIN_LEFT2 GATE_LEFT1 GATE_LEFT2 LOG0 LOG1 PGIOI SDOR_OUT VBA SDOR_IN
XIDUMMY VSS VBA mm19a04_u_ram6t_corner_hs1prf
.ends

.SUBCKT SNPS_RF_SP_UHS_256x28_gio_cnt ARYSDR ARYSD_BC1 ARYSD_BC2 BC0 BC1 BC2
+       BKADR CENDP CKGATE CLK CLKB CLKDEL CLKFLT CLK_MUXB CLPSEBUF DCLKT DEF1
+       DEF12B_PROG DEF12_PROG DEF1B DEF2 DEF2B DEF_MODE DEF_PROG DFTCLKEN
+       DFTMASK_BCEN DISCHG DLYPDB DLYPW FAST1_MODE FAST2_MODE FISO FLOAT
+       FLOAT_RET GSE_DB GSE_DT LBKADR LCLKB LCLKT LDFTX LDFTYBUF LITESLP LME
+       LOG0 LOG1 LS LWE LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+       LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] MCLKB MCLKT ME MEB_I MEB_LT
+       MEORDFTCLKEN MEORDFTCLKEN_IN PLBKADR PROCOM[0] PROCOM[1] PROCOML RA[0]
+       RA[1] RASSIST[0] RASSIST[1] RM[0] RM[1] RM[2] RM3CNT RMDEF1[0] RMDEF1[1]
+       RMDEF1[2] RMDEF1[3] RMDEF1_PROCOM00[0] RMDEF1_PROCOM00[1]
+       RMDEF1_PROCOM00[2] RMDEF1_PROCOM00[3] RMDEF1_PROCOM01[0]
+       RMDEF1_PROCOM01[1] RMDEF1_PROCOM01[2] RMDEF1_PROCOM01[3] RMDEF2[0]
+       RMDEF2[1] RMDEF2[2] RMDEF2[3] RMDEF2_PROCOM00[0] RMDEF2_PROCOM00[1]
+       RMDEF2_PROCOM00[2] RMDEF2_PROCOM00[3] RMDEF2_PROCOM01[0]
+       RMDEF2_PROCOM01[1] RMDEF2_PROCOM01[2] RMDEF2_PROCOM01[3] RME RMENI[0]
+       RMENI[1] RMENI[2] RMSLOW[0] RMSLOW[1] RMSLOW[2] RMSLOW[3] RMT[0] RMT[1]
+       RMT[2] RMT[3] RSCEN RSCIN RSCLK RSCOUT RSCRST RWLCKB SD T1T TEST1
+       TEST_RNM TEST_RNMB VBN[0] VBN[1] VBP[0] VBP[1] VDDA[0] VDDA[1] VDDF
+       VDDP[0] VDDP[1] VDDPI[0] VDDPI[1] VDDPI_LOG1 VSS[0] VSS[1] WA[0] WA[1]
+       WA[2] WABUF[0] WABUF[1] WABUF[2] WE WFLOAT WMDEF1[0] WMDEF1[1] WMDEF1[2]
+       WMDEF1[3] WMDEF1_PROCOM00[0] WMDEF1_PROCOM00[1] WMDEF1_PROCOM00[2]
+       WMDEF1_PROCOM00[3] WMDEF1_PROCOM01[0] WMDEF1_PROCOM01[1]
+       WMDEF1_PROCOM01[2] WMDEF1_PROCOM01[3] WMDEF2[0] WMDEF2[1] WMDEF2[2]
+       WMDEF2[3] WMDEF2_PROCOM00[0] WMDEF2_PROCOM00[1] WMDEF2_PROCOM00[2]
+       WMDEF2_PROCOM00[3] WMDEF2_PROCOM01[0] WMDEF2_PROCOM01[1]
+       WMDEF2_PROCOM01[2] WMDEF2_PROCOM01[3] WMSLOW[0] WMSLOW[1] WMSLOW[2]
+       WMSLOW[3] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]
+       WPULSE[0] WPULSE[1] WPULSE[2] XADR[0] XADR[1] XADR[2] XADR[3] XADR[4]
+       XADR[5] XADR[6] XADR[7] YADR[0] YADR[1]

*** Jumper Report ***
* Jumper: ARYSDB LSDB
* Jumper: ARYSDB_BC1 LSDB_BC1
* Jumper: ARYSDB_BC2 LSDB_BC2
* Jumper: CLKB CLK_MUXB
* Jumper: CLKDEL CLKFLT
* Jumper: DEF1 DEF_PROG
* Jumper: LOG0 CLPSEBUF DFTMASK_BCEN DLYPW GSE_DT LDFTYBUF RMENI[2]
* Jumper: LOG1 DLYPDB GSE_DB MEORDFTCLKEN_IN RMENI[0] RMENI[1] IN_2INV_ADDR SDCLPSB
* Jumper: LSORMEORDFTCLKEN LS_INT
* Jumper: MEB_I MEB_LT
* Jumper: RMDEF1[0] RMDEF1[1] RMDEF1[2] RMDEF2[1] RMSLOW[0] VSS[0] WMDEF1[0] WMDEF1[1] WMDEF1[2] WMDEF1[3] WMDEF2[2] WMSLOW[0] WMSLOW[1]
* Jumper: RMDEF1[3] RMDEF2[0] RMDEF2[2] RMDEF2[3] RMSLOW[1] RMSLOW[2] RMSLOW[3] VDDPI_LOG1 WMDEF2[0] WMDEF2[1] WMDEF2[3] WMSLOW[2] WMSLOW[3] LOG1_RM
* Jumper: VDDA[1] VDDP[1] VDDPI[1]
* Jumper: VDDF VDDP[0] VDDPI[0]

*X_mm19a04_u_gcen_cm4_edge_cd0 mm19a04_u_gcen_edge_cd0
X_mm19a04_u_hs1prf_gcen_cm4 VDDA[0] VDDF VDDP[0] VDDPI[0] VDDPI_LOG1 VSS[0]
+   VBP[0] VBN[0] ARYSDB ARYSDB_BC1 ARYSDB_BC2 CKGATE CLKDEL DEF_MODE FAST1_MODE
+   FAST2_MODE LBKADR LCLKB LCLKBIO LCLKT LITESLP LME ARYSDB ARYSDB_BC1
+   ARYSDB_BC2 LWE LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+   LXADR[6] LXADR[7] LYADR[0] LYADR[1] MCLKB MCLKT RAB[0] RAB[1] RM3CNT RMT[0]
+   RMT[1] RMT[2] RMT[3] RWLCKB T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WMT[0]
+   WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] CKGATE_GCEN CLKB CLPSEBUF
+   DEF1 DEF12B_PROG DEF12_PROG DEF1B DEF2 DEF2B DEF_PROG FISO FLOAT LOG1 LOG0
+   LOG1 RMDEF1[3] LSORMEORDFTCLKEN LSORMEORDFTCLKEN MEB_I MEB_LT MEORDFTCLKEN
+   MEORDFTCLKEN_IN OUT_2INV OUT_4INV OUT_6INV PLBKADR RM3CLPSB RSCEN RSCIN
+   RSCLK RSCOUT RSCRST LOG1 WFLOAT BC1 BC2 BKADR CENDP CLK CLKFLT CLK_MUXB
+   DFTCLKEN DFTMASK_BCEN DISCHG DLYPW FLOAT_RET LDFTX LS ME PROCOM[0] PROCOM[1]
+   RA[0] RA[1] RM[0] RM[1] RM[2] BC0 RMDEF1[0] RMDEF1[1] RMDEF1[2] RMDEF1[3]
+   RMDEF1_PROCOM00[0] RMDEF1_PROCOM00[1] RMDEF1_PROCOM00[2] RMDEF1_PROCOM00[3]
+   RMDEF1_PROCOM01[0] RMDEF1_PROCOM01[1] RMDEF1_PROCOM01[2] RMDEF1_PROCOM01[3]
+   RMDEF2[0] RMDEF2[1] RMDEF2[2] RMDEF2[3] RMDEF2_PROCOM00[0]
+   RMDEF2_PROCOM00[1] RMDEF2_PROCOM00[2] RMDEF2_PROCOM00[3] RMDEF2_PROCOM01[0]
+   RMDEF2_PROCOM01[1] RMDEF2_PROCOM01[2] RMDEF2_PROCOM01[3] RME RMENI[0]
+   RMENI[1] RMENI[2] RMSLOW[0] RMSLOW[1] RMSLOW[2] RMSLOW[3] SD TEST1 TEST_RNM
+   WA[0] WA[1] WA[2] WE WMDEF1[0] WMDEF1[1] WMDEF1[2] WMDEF1[3]
+   WMDEF1_PROCOM00[0] WMDEF1_PROCOM00[1] WMDEF1_PROCOM00[2] WMDEF1_PROCOM00[3]
+   WMDEF1_PROCOM01[0] WMDEF1_PROCOM01[1] WMDEF1_PROCOM01[2] WMDEF1_PROCOM01[3]
+   WMDEF2[0] WMDEF2[1] WMDEF2[2] WMDEF2[3] WMDEF2_PROCOM00[0]
+   WMDEF2_PROCOM00[1] WMDEF2_PROCOM00[2] WMDEF2_PROCOM00[3] WMDEF2_PROCOM01[0]
+   WMDEF2_PROCOM01[1] WMDEF2_PROCOM01[2] WMDEF2_PROCOM01[3] WMSLOW[0] WMSLOW[1]
+   WMSLOW[2] WMSLOW[3] WPULSE[0] WPULSE[1] WPULSE[2] XADR[0] XADR[1] XADR[2]
+   XADR[3] XADR[4] XADR[5] XADR[6] XADR[7] YADR[0] YADR[1]
+   mm19a04_u_hs1prf_gcen
X_mm19a04_u_hs1prf_gcenbuf VDDA[1] VDDP[1] VDDPI[1] VSS[1] VBP[1] VBN[1] DCLKT
+   RASSIST[0] RASSIST[1] ARYSDR ARYSDB ARYSDB_BC1 ARYSDB_BC2 ARYSD_BC1
+   ARYSD_BC2 DLYPDB GSE_DB GSE_DT LDFTYBUF LOG0 LOG1 PROCOML LCLKBIO RAB[0]
+   RAB[1] LOG1 mm19a04_u_hs1prf_gcenbuf
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_gio_rt_seg1 CB[0] CB[1] CB[2] CB[3] CB[4] CB[5]
+       CB[6] CB[7] CB[8] CB[9] CB[10] CB[11] CB[12] CB[13] CB[14] CB[15] CB[16]
+       CB[17] CB[18] CB[19] CB[20] CB[21] CB[22] CB[23] CB[24] CB[25] CB[26]
+       CB[27] CT[0] CT[1] CT[2] CT[3] CT[4] CT[5] CT[6] CT[7] CT[8] CT[9]
+       CT[10] CT[11] CT[12] CT[13] CT[14] CT[15] CT[16] CT[17] CT[18] CT[19]
+       CT[20] CT[21] CT[22] CT[23] CT[24] CT[25] CT[26] CT[27] D[0] D[1] D[2]
+       D[3] D[4] D[5] D[6] D[7] D[8] D[9] D[10] D[11] D[12] D[13] D[14] D[15]
+       D[16] D[17] D[18] D[19] D[20] D[21] D[22] D[23] D[24] D[25] D[26] D[27]
+       DCLKT DIB[0] DIB[1] DIB[2] DIB[3] DIB[4] DIB[5] DIB[6] DIB[7] DIB[8]
+       DIB[9] DIB[10] DIB[11] DIB[12] DIB[13] DIB[14] DIB[15] DIB[16] DIB[17]
+       DIB[18] DIB[19] DIB[20] DIB[21] DIB[22] DIB[23] DIB[24] DIB[25] DIB[26]
+       DIB[27] DINB[0] DINB[1] DINB[2] DINB[3] DINB[4] DINB[5] DINB[6] DINB[7]
+       DINB[8] DINB[9] DINB[10] DINB[11] DINB[12] DINB[13] DINB[14] DINB[15]
+       DINB[16] DINB[17] DINB[18] DINB[19] DINB[20] DINB[21] DINB[22] DINB[23]
+       DINB[24] DINB[25] DINB[26] DINB[27] DLYPDB D_AL[0] D_AL[1] D_AL[2]
+       D_AL[3] D_AL[4] D_AL[5] D_AL[6] D_AL[7] D_AL[8] D_AL[9] D_AL[10]
+       D_AL[11] D_AL[12] D_AL[13] D_AL[14] D_AL[15] D_AL[16] D_AL[17] D_AL[18]
+       D_AL[19] D_AL[20] D_AL[21] D_AL[22] D_AL[23] D_AL[24] D_AL[25] D_AL[26]
+       D_AL[27] IV_WB[0] IV_WB[1] IV_WB[2] IV_WB[3] IV_WB[4] IV_WB[5] IV_WB[6]
+       IV_WB[7] IV_WB[8] IV_WB[9] IV_WB[10] IV_WB[11] IV_WB[12] IV_WB[13]
+       IV_WB[14] IV_WB[15] IV_WB[16] IV_WB[17] IV_WB[18] IV_WB[19] IV_WB[20]
+       IV_WB[21] IV_WB[22] IV_WB[23] IV_WB[24] IV_WB[25] IV_WB[26] IV_WB[27]
+       IV_WT[0] IV_WT[1] IV_WT[2] IV_WT[3] IV_WT[4] IV_WT[5] IV_WT[6] IV_WT[7]
+       IV_WT[8] IV_WT[9] IV_WT[10] IV_WT[11] IV_WT[12] IV_WT[13] IV_WT[14]
+       IV_WT[15] IV_WT[16] IV_WT[17] IV_WT[18] IV_WT[19] IV_WT[20] IV_WT[21]
+       IV_WT[22] IV_WT[23] IV_WT[24] IV_WT[25] IV_WT[26] IV_WT[27] LDFTYBUF
+       LDIB[0] LDIB[1] LDIB[2] LDIB[3] LDIB[4] LDIB[5] LDIB[6] LDIB[7] LDIB[8]
+       LDIB[9] LDIB[10] LDIB[11] LDIB[12] LDIB[13] LDIB[14] LDIB[15] LDIB[16]
+       LDIB[17] LDIB[18] LDIB[19] LDIB[20] LDIB[21] LDIB[22] LDIB[23] LDIB[24]
+       LDIB[25] LDIB[26] LDIB[27] LOG0 LOG1 LQB[0] LQB[1] LQB[2] LQB[3] LQB[4]
+       LQB[5] LQB[6] LQB[7] LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13]
+       LQB[14] LQB[15] LQB[16] LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22]
+       LQB[23] LQB[24] LQB[25] LQB[26] LQB[27] LWIB[0] LWIB[1] LWIB[2] LWIB[3]
+       LWIB[4] LWIB[5] LWIB[6] LWIB[7] LWIB[8] LWIB[9] LWIB[10] LWIB[11]
+       LWIB[12] LWIB[13] LWIB[14] LWIB[15] LWIB[16] LWIB[17] LWIB[18] LWIB[19]
+       LWIB[20] LWIB[21] LWIB[22] LWIB[23] LWIB[24] LWIB[25] LWIB[26] LWIB[27]
+       ND_WB[0] ND_WB[1] ND_WB[2] ND_WB[3] ND_WB[4] ND_WB[5] ND_WB[6] ND_WB[7]
+       ND_WB[8] ND_WB[9] ND_WB[10] ND_WB[11] ND_WB[12] ND_WB[13] ND_WB[14]
+       ND_WB[15] ND_WB[16] ND_WB[17] ND_WB[18] ND_WB[19] ND_WB[20] ND_WB[21]
+       ND_WB[22] ND_WB[23] ND_WB[24] ND_WB[25] ND_WB[26] ND_WB[27] ND_WT[0]
+       ND_WT[1] ND_WT[2] ND_WT[3] ND_WT[4] ND_WT[5] ND_WT[6] ND_WT[7] ND_WT[8]
+       ND_WT[9] ND_WT[10] ND_WT[11] ND_WT[12] ND_WT[13] ND_WT[14] ND_WT[15]
+       ND_WT[16] ND_WT[17] ND_WT[18] ND_WT[19] ND_WT[20] ND_WT[21] ND_WT[22]
+       ND_WT[23] ND_WT[24] ND_WT[25] ND_WT[26] ND_WT[27] Q[0] Q[1] Q[2] Q[3]
+       Q[4] Q[5] Q[6] Q[7] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13] Q[14] Q[15] Q[16]
+       Q[17] Q[18] Q[19] Q[20] Q[21] Q[22] Q[23] Q[24] Q[25] Q[26] Q[27] SE_DB
+       SE_DT VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+       VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+       VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+       VBN[27] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8]
+       VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VBP[17]
+       VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25] VBP[26]
+       VBP[27] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+       VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+       VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23]
+       VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+       VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11]
+       VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19]
+       VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27]
+       VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+       VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+       VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21]
+       VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI_DR[0]
+       VDDPI_DR[1] VDDPI_DR[2] VDDPI_DR[3] VDDPI_DR[4] VDDPI_DR[5] VDDPI_DR[6]
+       VDDPI_DR[7] VDDPI_DR[8] VDDPI_DR[9] VDDPI_DR[10] VDDPI_DR[11]
+       VDDPI_DR[12] VDDPI_DR[13] VDDPI_DR[14] VDDPI_DR[15] VDDPI_DR[16]
+       VDDPI_DR[17] VDDPI_DR[18] VDDPI_DR[19] VDDPI_DR[20] VDDPI_DR[21]
+       VDDPI_DR[22] VDDPI_DR[23] VDDPI_DR[24] VDDPI_DR[25] VDDPI_DR[26]
+       VDDPI_DR[27] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+       VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+       VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+       VSS[26] VSS[27] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7]
+       WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16]
+       WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25]
+       WBI[26] WBI[27] WEM[0] WEM[1] WEM[2] WEM[3] WEM[4] WEM[5] WEM[6] WEM[7]
+       WEM[8] WEM[9] WEM[10] WEM[11] WEM[12] WEM[13] WEM[14] WEM[15] WEM[16]
+       WEM[17] WEM[18] WEM[19] WEM[20] WEM[21] WEM[22] WEM[23] WEM[24] WEM[25]
+       WEM[26] WEM[27] WEMB[0] WEMB[1] WEMB[2] WEMB[3] WEMB[4] WEMB[5] WEMB[6]
+       WEMB[7] WEMB[8] WEMB[9] WEMB[10] WEMB[11] WEMB[12] WEMB[13] WEMB[14]
+       WEMB[15] WEMB[16] WEMB[17] WEMB[18] WEMB[19] WEMB[20] WEMB[21] WEMB[22]
+       WEMB[23] WEMB[24] WEMB[25] WEMB[26] WEMB[27] WEM_AL[0] WEM_AL[1]
+       WEM_AL[2] WEM_AL[3] WEM_AL[4] WEM_AL[5] WEM_AL[6] WEM_AL[7] WEM_AL[8]
+       WEM_AL[9] WEM_AL[10] WEM_AL[11] WEM_AL[12] WEM_AL[13] WEM_AL[14]
+       WEM_AL[15] WEM_AL[16] WEM_AL[17] WEM_AL[18] WEM_AL[19] WEM_AL[20]
+       WEM_AL[21] WEM_AL[22] WEM_AL[23] WEM_AL[24] WEM_AL[25] WEM_AL[26]
+       WEM_AL[27] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+       WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16]
+       WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25]
+       WTI[26] WTI[27]

*** Jumper Report ***
* Jumper: DINB[0] D_AL[0]
* Jumper: DINB[1] D_AL[1]
* Jumper: DINB[2] D_AL[2]
* Jumper: DINB[3] D_AL[3]
* Jumper: DINB[4] D_AL[4]
* Jumper: DINB[5] D_AL[5]
* Jumper: DINB[6] D_AL[6]
* Jumper: DINB[7] D_AL[7]
* Jumper: DINB[8] D_AL[8]
* Jumper: DINB[9] D_AL[9]
* Jumper: DINB[10] D_AL[10]
* Jumper: DINB[11] D_AL[11]
* Jumper: DINB[12] D_AL[12]
* Jumper: DINB[13] D_AL[13]
* Jumper: DINB[14] D_AL[14]
* Jumper: DINB[15] D_AL[15]
* Jumper: DINB[16] D_AL[16]
* Jumper: DINB[17] D_AL[17]
* Jumper: DINB[18] D_AL[18]
* Jumper: DINB[19] D_AL[19]
* Jumper: DINB[20] D_AL[20]
* Jumper: DINB[21] D_AL[21]
* Jumper: DINB[22] D_AL[22]
* Jumper: DINB[23] D_AL[23]
* Jumper: DINB[24] D_AL[24]
* Jumper: DINB[25] D_AL[25]
* Jumper: DINB[26] D_AL[26]
* Jumper: DINB[27] D_AL[27]
* Jumper: IV_WB[0] ND_WB[0]
* Jumper: IV_WB[1] ND_WB[1]
* Jumper: IV_WB[2] ND_WB[2]
* Jumper: IV_WB[3] ND_WB[3]
* Jumper: IV_WB[4] ND_WB[4]
* Jumper: IV_WB[5] ND_WB[5]
* Jumper: IV_WB[6] ND_WB[6]
* Jumper: IV_WB[7] ND_WB[7]
* Jumper: IV_WB[8] ND_WB[8]
* Jumper: IV_WB[9] ND_WB[9]
* Jumper: IV_WB[10] ND_WB[10]
* Jumper: IV_WB[11] ND_WB[11]
* Jumper: IV_WB[12] ND_WB[12]
* Jumper: IV_WB[13] ND_WB[13]
* Jumper: IV_WB[14] ND_WB[14]
* Jumper: IV_WB[15] ND_WB[15]
* Jumper: IV_WB[16] ND_WB[16]
* Jumper: IV_WB[17] ND_WB[17]
* Jumper: IV_WB[18] ND_WB[18]
* Jumper: IV_WB[19] ND_WB[19]
* Jumper: IV_WB[20] ND_WB[20]
* Jumper: IV_WB[21] ND_WB[21]
* Jumper: IV_WB[22] ND_WB[22]
* Jumper: IV_WB[23] ND_WB[23]
* Jumper: IV_WB[24] ND_WB[24]
* Jumper: IV_WB[25] ND_WB[25]
* Jumper: IV_WB[26] ND_WB[26]
* Jumper: IV_WB[27] ND_WB[27]
* Jumper: IV_WT[0] ND_WT[0]
* Jumper: IV_WT[1] ND_WT[1]
* Jumper: IV_WT[2] ND_WT[2]
* Jumper: IV_WT[3] ND_WT[3]
* Jumper: IV_WT[4] ND_WT[4]
* Jumper: IV_WT[5] ND_WT[5]
* Jumper: IV_WT[6] ND_WT[6]
* Jumper: IV_WT[7] ND_WT[7]
* Jumper: IV_WT[8] ND_WT[8]
* Jumper: IV_WT[9] ND_WT[9]
* Jumper: IV_WT[10] ND_WT[10]
* Jumper: IV_WT[11] ND_WT[11]
* Jumper: IV_WT[12] ND_WT[12]
* Jumper: IV_WT[13] ND_WT[13]
* Jumper: IV_WT[14] ND_WT[14]
* Jumper: IV_WT[15] ND_WT[15]
* Jumper: IV_WT[16] ND_WT[16]
* Jumper: IV_WT[17] ND_WT[17]
* Jumper: IV_WT[18] ND_WT[18]
* Jumper: IV_WT[19] ND_WT[19]
* Jumper: IV_WT[20] ND_WT[20]
* Jumper: IV_WT[21] ND_WT[21]
* Jumper: IV_WT[22] ND_WT[22]
* Jumper: IV_WT[23] ND_WT[23]
* Jumper: IV_WT[24] ND_WT[24]
* Jumper: IV_WT[25] ND_WT[25]
* Jumper: IV_WT[26] ND_WT[26]
* Jumper: IV_WT[27] ND_WT[27]
* Jumper: VDDP[0] VDDPI[0]
* Jumper: VDDP[1] VDDPI[1]
* Jumper: VDDP[2] VDDPI[2]
* Jumper: VDDP[3] VDDPI[3]
* Jumper: VDDP[4] VDDPI[4]
* Jumper: VDDP[5] VDDPI[5]
* Jumper: VDDP[6] VDDPI[6]
* Jumper: VDDP[7] VDDPI[7]
* Jumper: VDDP[8] VDDPI[8]
* Jumper: VDDP[9] VDDPI[9]
* Jumper: VDDP[10] VDDPI[10]
* Jumper: VDDP[11] VDDPI[11]
* Jumper: VDDP[12] VDDPI[12]
* Jumper: VDDP[13] VDDPI[13]
* Jumper: VDDP[14] VDDPI[14]
* Jumper: VDDP[15] VDDPI[15]
* Jumper: VDDP[16] VDDPI[16]
* Jumper: VDDP[17] VDDPI[17]
* Jumper: VDDP[18] VDDPI[18]
* Jumper: VDDP[19] VDDPI[19]
* Jumper: VDDP[20] VDDPI[20]
* Jumper: VDDP[21] VDDPI[21]
* Jumper: VDDP[22] VDDPI[22]
* Jumper: VDDP[23] VDDPI[23]
* Jumper: VDDP[24] VDDPI[24]
* Jumper: VDDP[25] VDDPI[25]
* Jumper: VDDP[26] VDDPI[26]
* Jumper: VDDP[27] VDDPI[27]
* Jumper: WEMB[0] WEM_AL[0]
* Jumper: WEMB[1] WEM_AL[1]
* Jumper: WEMB[2] WEM_AL[2]
* Jumper: WEMB[3] WEM_AL[3]
* Jumper: WEMB[4] WEM_AL[4]
* Jumper: WEMB[5] WEM_AL[5]
* Jumper: WEMB[6] WEM_AL[6]
* Jumper: WEMB[7] WEM_AL[7]
* Jumper: WEMB[8] WEM_AL[8]
* Jumper: WEMB[9] WEM_AL[9]
* Jumper: WEMB[10] WEM_AL[10]
* Jumper: WEMB[11] WEM_AL[11]
* Jumper: WEMB[12] WEM_AL[12]
* Jumper: WEMB[13] WEM_AL[13]
* Jumper: WEMB[14] WEM_AL[14]
* Jumper: WEMB[15] WEM_AL[15]
* Jumper: WEMB[16] WEM_AL[16]
* Jumper: WEMB[17] WEM_AL[17]
* Jumper: WEMB[18] WEM_AL[18]
* Jumper: WEMB[19] WEM_AL[19]
* Jumper: WEMB[20] WEM_AL[20]
* Jumper: WEMB[21] WEM_AL[21]
* Jumper: WEMB[22] WEM_AL[22]
* Jumper: WEMB[23] WEM_AL[23]
* Jumper: WEMB[24] WEM_AL[24]
* Jumper: WEMB[25] WEM_AL[25]
* Jumper: WEMB[26] WEM_AL[26]
* Jumper: WEMB[27] WEM_AL[27]

X_mm19a04_u_hs1prf_giom4x1_cm4_S0 VDDA[0] VDDP[0] VDDPI[0] VDDPI_DR[0] VSS[0]
+   VBP[0] VBN[0] CB[0] CT[0] D_AL[0] LDIB[0] LWIB[0] ND_WB[0] ND_WT[0] Q[0]
+   WBI[0] WEM_AL[0] WTI[0] DIB[0] LOG0 LOG1 LQB[0] D[0] DCLKT DINB[0] DLYPDB
+   IV_WB[0] IV_WT[0] LDFTYBUF SE_DB SE_DT WEM[0] WEMB[0]
+   mm19a04_u_hs1prf_giom4x1
X_mm19a04_u_hs1prf_giom4x1_cm4_S1 VDDA[1] VDDP[1] VDDPI[1] VDDPI_DR[1] VSS[1]
+   VBP[1] VBN[1] CB[1] CT[1] D_AL[1] LDIB[1] LWIB[1] ND_WB[1] ND_WT[1] Q[1]
+   WBI[1] WEM_AL[1] WTI[1] DIB[1] LOG0 LOG1 LQB[1] D[1] DCLKT DINB[1] DLYPDB
+   IV_WB[1] IV_WT[1] LDFTYBUF SE_DB SE_DT WEM[1] WEMB[1]
+   mm19a04_u_hs1prf_giom4x1
X_mm19a04_u_hs1prf_giom4x1_cm4_S2 VDDA[2] VDDP[2] VDDPI[2] VDDPI_DR[2] VSS[2]
+   VBP[2] VBN[2] CB[2] CT[2] D_AL[2] LDIB[2] LWIB[2] ND_WB[2] ND_WT[2] Q[2]
+   WBI[2] WEM_AL[2] WTI[2] DIB[2] LOG0 LOG1 LQB[2] D[2] DCLKT DINB[2] DLYPDB
+   IV_WB[2] IV_WT[2] LDFTYBUF SE_DB SE_DT WEM[2] WEMB[2]
+   mm19a04_u_hs1prf_giom4x1
X_mm19a04_u_hs1prf_giom4x1_cm4_S3 VDDA[3] VDDP[3] VDDPI[3] VDDPI_DR[3] VSS[3]
+   VBP[3] VBN[3] CB[3] CT[3] D_AL[3] LDIB[3] LWIB[3] ND_WB[3] ND_WT[3] Q[3]
+   WBI[3] WEM_AL[3] WTI[3] DIB[3] LOG0 LOG1 LQB[3] D[3] DCLKT DINB[3] DLYPDB
+   IV_WB[3] IV_WT[3] LDFTYBUF SE_DB SE_DT WEM[3] WEMB[3]
+   mm19a04_u_hs1prf_giom4x1
X_mm19a04_u_hs1prf_giom4x1_cm4_S4 VDDA[4] VDDP[4] VDDPI[4] VDDPI_DR[4] VSS[4]
+   VBP[4] VBN[4] CB[4] CT[4] D_AL[4] LDIB[4] LWIB[4] ND_WB[4] ND_WT[4] Q[4]
+   WBI[4] WEM_AL[4] WTI[4] DIB[4] LOG0 LOG1 LQB[4] D[4] DCLKT DINB[4] DLYPDB
+   IV_WB[4] IV_WT[4] LDFTYBUF SE_DB SE_DT WEM[4] WEMB[4]
+   mm19a04_u_hs1prf_giom4x1
X_mm19a04_u_hs1prf_giom4x1_cm4_S5 VDDA[5] VDDP[5] VDDPI[5] VDDPI_DR[5] VSS[5]
+   VBP[5] VBN[5] CB[5] CT[5] D_AL[5] LDIB[5] LWIB[5] ND_WB[5] ND_WT[5] Q[5]
+   WBI[5] WEM_AL[5] WTI[5] DIB[5] LOG0 LOG1 LQB[5] D[5] DCLKT DINB[5] DLYPDB
+   IV_WB[5] IV_WT[5] LDFTYBUF SE_DB SE_DT WEM[5] WEMB[5]
+   mm19a04_u_hs1prf_giom4x1
X_mm19a04_u_hs1prf_giom4x1_cm4_S6 VDDA[6] VDDP[6] VDDPI[6] VDDPI_DR[6] VSS[6]
+   VBP[6] VBN[6] CB[6] CT[6] D_AL[6] LDIB[6] LWIB[6] ND_WB[6] ND_WT[6] Q[6]
+   WBI[6] WEM_AL[6] WTI[6] DIB[6] LOG0 LOG1 LQB[6] D[6] DCLKT DINB[6] DLYPDB
+   IV_WB[6] IV_WT[6] LDFTYBUF SE_DB SE_DT WEM[6] WEMB[6]
+   mm19a04_u_hs1prf_giom4x1
X_mm19a04_u_hs1prf_giom4x1_cm4_S7 VDDA[7] VDDP[7] VDDPI[7] VDDPI_DR[7] VSS[7]
+   VBP[7] VBN[7] CB[7] CT[7] D_AL[7] LDIB[7] LWIB[7] ND_WB[7] ND_WT[7] Q[7]
+   WBI[7] WEM_AL[7] WTI[7] DIB[7] LOG0 LOG1 LQB[7] D[7] DCLKT DINB[7] DLYPDB
+   IV_WB[7] IV_WT[7] LDFTYBUF SE_DB SE_DT WEM[7] WEMB[7]
+   mm19a04_u_hs1prf_giom4x1
X_mm19a04_u_hs1prf_giom4x1_cm4_S8 VDDA[8] VDDP[8] VDDPI[8] VDDPI_DR[8] VSS[8]
+   VBP[8] VBN[8] CB[8] CT[8] D_AL[8] LDIB[8] LWIB[8] ND_WB[8] ND_WT[8] Q[8]
+   WBI[8] WEM_AL[8] WTI[8] DIB[8] LOG0 LOG1 LQB[8] D[8] DCLKT DINB[8] DLYPDB
+   IV_WB[8] IV_WT[8] LDFTYBUF SE_DB SE_DT WEM[8] WEMB[8]
+   mm19a04_u_hs1prf_giom4x1
X_mm19a04_u_hs1prf_giom4x1_cm4_S9 VDDA[9] VDDP[9] VDDPI[9] VDDPI_DR[9] VSS[9]
+   VBP[9] VBN[9] CB[9] CT[9] D_AL[9] LDIB[9] LWIB[9] ND_WB[9] ND_WT[9] Q[9]
+   WBI[9] WEM_AL[9] WTI[9] DIB[9] LOG0 LOG1 LQB[9] D[9] DCLKT DINB[9] DLYPDB
+   IV_WB[9] IV_WT[9] LDFTYBUF SE_DB SE_DT WEM[9] WEMB[9]
+   mm19a04_u_hs1prf_giom4x1
X_mm19a04_u_hs1prf_giom4x1_cm4_S10 VDDA[10] VDDP[10] VDDPI[10] VDDPI_DR[10]
+   VSS[10] VBP[10] VBN[10] CB[10] CT[10] D_AL[10] LDIB[10] LWIB[10] ND_WB[10]
+   ND_WT[10] Q[10] WBI[10] WEM_AL[10] WTI[10] DIB[10] LOG0 LOG1 LQB[10] D[10]
+   DCLKT DINB[10] DLYPDB IV_WB[10] IV_WT[10] LDFTYBUF SE_DB SE_DT WEM[10]
+   WEMB[10] mm19a04_u_hs1prf_giom4x1
X_mm19a04_u_hs1prf_giom4x1_cm4_S11 VDDA[11] VDDP[11] VDDPI[11] VDDPI_DR[11]
+   VSS[11] VBP[11] VBN[11] CB[11] CT[11] D_AL[11] LDIB[11] LWIB[11] ND_WB[11]
+   ND_WT[11] Q[11] WBI[11] WEM_AL[11] WTI[11] DIB[11] LOG0 LOG1 LQB[11] D[11]
+   DCLKT DINB[11] DLYPDB IV_WB[11] IV_WT[11] LDFTYBUF SE_DB SE_DT WEM[11]
+   WEMB[11] mm19a04_u_hs1prf_giom4x1
X_mm19a04_u_hs1prf_giom4x1_cm4_S12 VDDA[12] VDDP[12] VDDPI[12] VDDPI_DR[12]
+   VSS[12] VBP[12] VBN[12] CB[12] CT[12] D_AL[12] LDIB[12] LWIB[12] ND_WB[12]
+   ND_WT[12] Q[12] WBI[12] WEM_AL[12] WTI[12] DIB[12] LOG0 LOG1 LQB[12] D[12]
+   DCLKT DINB[12] DLYPDB IV_WB[12] IV_WT[12] LDFTYBUF SE_DB SE_DT WEM[12]
+   WEMB[12] mm19a04_u_hs1prf_giom4x1
X_mm19a04_u_hs1prf_giom4x1_cm4_S13 VDDA[13] VDDP[13] VDDPI[13] VDDPI_DR[13]
+   VSS[13] VBP[13] VBN[13] CB[13] CT[13] D_AL[13] LDIB[13] LWIB[13] ND_WB[13]
+   ND_WT[13] Q[13] WBI[13] WEM_AL[13] WTI[13] DIB[13] LOG0 LOG1 LQB[13] D[13]
+   DCLKT DINB[13] DLYPDB IV_WB[13] IV_WT[13] LDFTYBUF SE_DB SE_DT WEM[13]
+   WEMB[13] mm19a04_u_hs1prf_giom4x1
X_mm19a04_u_hs1prf_giom4x1_cm4_F13 VDDA[14] VDDP[14] VDDPI[14] VDDPI_DR[14]
+   VSS[14] VBP[14] VBN[14] CB[14] CT[14] D_AL[14] LDIB[14] LWIB[14] ND_WB[14]
+   ND_WT[14] Q[14] WBI[14] WEM_AL[14] WTI[14] DIB[14] LOG0 LOG1 LQB[14] D[14]
+   DCLKT DINB[14] DLYPDB IV_WB[14] IV_WT[14] LDFTYBUF SE_DB SE_DT WEM[14]
+   WEMB[14] mm19a04_u_hs1prf_giom4x1
X_mm19a04_u_hs1prf_giom4x1_cm4_F12 VDDA[15] VDDP[15] VDDPI[15] VDDPI_DR[15]
+   VSS[15] VBP[15] VBN[15] CB[15] CT[15] D_AL[15] LDIB[15] LWIB[15] ND_WB[15]
+   ND_WT[15] Q[15] WBI[15] WEM_AL[15] WTI[15] DIB[15] LOG0 LOG1 LQB[15] D[15]
+   DCLKT DINB[15] DLYPDB IV_WB[15] IV_WT[15] LDFTYBUF SE_DB SE_DT WEM[15]
+   WEMB[15] mm19a04_u_hs1prf_giom4x1
X_mm19a04_u_hs1prf_giom4x1_cm4_F11 VDDA[16] VDDP[16] VDDPI[16] VDDPI_DR[16]
+   VSS[16] VBP[16] VBN[16] CB[16] CT[16] D_AL[16] LDIB[16] LWIB[16] ND_WB[16]
+   ND_WT[16] Q[16] WBI[16] WEM_AL[16] WTI[16] DIB[16] LOG0 LOG1 LQB[16] D[16]
+   DCLKT DINB[16] DLYPDB IV_WB[16] IV_WT[16] LDFTYBUF SE_DB SE_DT WEM[16]
+   WEMB[16] mm19a04_u_hs1prf_giom4x1
X_mm19a04_u_hs1prf_giom4x1_cm4_F10 VDDA[17] VDDP[17] VDDPI[17] VDDPI_DR[17]
+   VSS[17] VBP[17] VBN[17] CB[17] CT[17] D_AL[17] LDIB[17] LWIB[17] ND_WB[17]
+   ND_WT[17] Q[17] WBI[17] WEM_AL[17] WTI[17] DIB[17] LOG0 LOG1 LQB[17] D[17]
+   DCLKT DINB[17] DLYPDB IV_WB[17] IV_WT[17] LDFTYBUF SE_DB SE_DT WEM[17]
+   WEMB[17] mm19a04_u_hs1prf_giom4x1
X_mm19a04_u_hs1prf_giom4x1_cm4_F9 VDDA[18] VDDP[18] VDDPI[18] VDDPI_DR[18]
+   VSS[18] VBP[18] VBN[18] CB[18] CT[18] D_AL[18] LDIB[18] LWIB[18] ND_WB[18]
+   ND_WT[18] Q[18] WBI[18] WEM_AL[18] WTI[18] DIB[18] LOG0 LOG1 LQB[18] D[18]
+   DCLKT DINB[18] DLYPDB IV_WB[18] IV_WT[18] LDFTYBUF SE_DB SE_DT WEM[18]
+   WEMB[18] mm19a04_u_hs1prf_giom4x1
X_mm19a04_u_hs1prf_giom4x1_cm4_F8 VDDA[19] VDDP[19] VDDPI[19] VDDPI_DR[19]
+   VSS[19] VBP[19] VBN[19] CB[19] CT[19] D_AL[19] LDIB[19] LWIB[19] ND_WB[19]
+   ND_WT[19] Q[19] WBI[19] WEM_AL[19] WTI[19] DIB[19] LOG0 LOG1 LQB[19] D[19]
+   DCLKT DINB[19] DLYPDB IV_WB[19] IV_WT[19] LDFTYBUF SE_DB SE_DT WEM[19]
+   WEMB[19] mm19a04_u_hs1prf_giom4x1
X_mm19a04_u_hs1prf_giom4x1_cm4_F7 VDDA[20] VDDP[20] VDDPI[20] VDDPI_DR[20]
+   VSS[20] VBP[20] VBN[20] CB[20] CT[20] D_AL[20] LDIB[20] LWIB[20] ND_WB[20]
+   ND_WT[20] Q[20] WBI[20] WEM_AL[20] WTI[20] DIB[20] LOG0 LOG1 LQB[20] D[20]
+   DCLKT DINB[20] DLYPDB IV_WB[20] IV_WT[20] LDFTYBUF SE_DB SE_DT WEM[20]
+   WEMB[20] mm19a04_u_hs1prf_giom4x1
X_mm19a04_u_hs1prf_giom4x1_cm4_F6 VDDA[21] VDDP[21] VDDPI[21] VDDPI_DR[21]
+   VSS[21] VBP[21] VBN[21] CB[21] CT[21] D_AL[21] LDIB[21] LWIB[21] ND_WB[21]
+   ND_WT[21] Q[21] WBI[21] WEM_AL[21] WTI[21] DIB[21] LOG0 LOG1 LQB[21] D[21]
+   DCLKT DINB[21] DLYPDB IV_WB[21] IV_WT[21] LDFTYBUF SE_DB SE_DT WEM[21]
+   WEMB[21] mm19a04_u_hs1prf_giom4x1
X_mm19a04_u_hs1prf_giom4x1_cm4_F5 VDDA[22] VDDP[22] VDDPI[22] VDDPI_DR[22]
+   VSS[22] VBP[22] VBN[22] CB[22] CT[22] D_AL[22] LDIB[22] LWIB[22] ND_WB[22]
+   ND_WT[22] Q[22] WBI[22] WEM_AL[22] WTI[22] DIB[22] LOG0 LOG1 LQB[22] D[22]
+   DCLKT DINB[22] DLYPDB IV_WB[22] IV_WT[22] LDFTYBUF SE_DB SE_DT WEM[22]
+   WEMB[22] mm19a04_u_hs1prf_giom4x1
X_mm19a04_u_hs1prf_giom4x1_cm4_F4 VDDA[23] VDDP[23] VDDPI[23] VDDPI_DR[23]
+   VSS[23] VBP[23] VBN[23] CB[23] CT[23] D_AL[23] LDIB[23] LWIB[23] ND_WB[23]
+   ND_WT[23] Q[23] WBI[23] WEM_AL[23] WTI[23] DIB[23] LOG0 LOG1 LQB[23] D[23]
+   DCLKT DINB[23] DLYPDB IV_WB[23] IV_WT[23] LDFTYBUF SE_DB SE_DT WEM[23]
+   WEMB[23] mm19a04_u_hs1prf_giom4x1
X_mm19a04_u_hs1prf_giom4x1_cm4_F3 VDDA[24] VDDP[24] VDDPI[24] VDDPI_DR[24]
+   VSS[24] VBP[24] VBN[24] CB[24] CT[24] D_AL[24] LDIB[24] LWIB[24] ND_WB[24]
+   ND_WT[24] Q[24] WBI[24] WEM_AL[24] WTI[24] DIB[24] LOG0 LOG1 LQB[24] D[24]
+   DCLKT DINB[24] DLYPDB IV_WB[24] IV_WT[24] LDFTYBUF SE_DB SE_DT WEM[24]
+   WEMB[24] mm19a04_u_hs1prf_giom4x1
X_mm19a04_u_hs1prf_giom4x1_cm4_F2 VDDA[25] VDDP[25] VDDPI[25] VDDPI_DR[25]
+   VSS[25] VBP[25] VBN[25] CB[25] CT[25] D_AL[25] LDIB[25] LWIB[25] ND_WB[25]
+   ND_WT[25] Q[25] WBI[25] WEM_AL[25] WTI[25] DIB[25] LOG0 LOG1 LQB[25] D[25]
+   DCLKT DINB[25] DLYPDB IV_WB[25] IV_WT[25] LDFTYBUF SE_DB SE_DT WEM[25]
+   WEMB[25] mm19a04_u_hs1prf_giom4x1
X_mm19a04_u_hs1prf_giom4x1_cm4_F1 VDDA[26] VDDP[26] VDDPI[26] VDDPI_DR[26]
+   VSS[26] VBP[26] VBN[26] CB[26] CT[26] D_AL[26] LDIB[26] LWIB[26] ND_WB[26]
+   ND_WT[26] Q[26] WBI[26] WEM_AL[26] WTI[26] DIB[26] LOG0 LOG1 LQB[26] D[26]
+   DCLKT DINB[26] DLYPDB IV_WB[26] IV_WT[26] LDFTYBUF SE_DB SE_DT WEM[26]
+   WEMB[26] mm19a04_u_hs1prf_giom4x1
X_mm19a04_u_hs1prf_giom4x1_cm4_F0 VDDA[27] VDDP[27] VDDPI[27] VDDPI_DR[27]
+   VSS[27] VBP[27] VBN[27] CB[27] CT[27] D_AL[27] LDIB[27] LWIB[27] ND_WB[27]
+   ND_WT[27] Q[27] WBI[27] WEM_AL[27] WTI[27] DIB[27] LOG0 LOG1 LQB[27] D[27]
+   DCLKT DINB[27] DLYPDB IV_WB[27] IV_WT[27] LDFTYBUF SE_DB SE_DT WEM[27]
+   WEMB[27] mm19a04_u_hs1prf_giom4x1
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_gio_rt CB[0] CB[1] CB[2] CB[3] CB[4] CB[5] CB[6]
+       CB[7] CB[8] CB[9] CB[10] CB[11] CB[12] CB[13] CB[14] CB[15] CB[16]
+       CB[17] CB[18] CB[19] CB[20] CB[21] CB[22] CB[23] CB[24] CB[25] CB[26]
+       CB[27] CT[0] CT[1] CT[2] CT[3] CT[4] CT[5] CT[6] CT[7] CT[8] CT[9]
+       CT[10] CT[11] CT[12] CT[13] CT[14] CT[15] CT[16] CT[17] CT[18] CT[19]
+       CT[20] CT[21] CT[22] CT[23] CT[24] CT[25] CT[26] CT[27] D[0] D[1] D[2]
+       D[3] D[4] D[5] D[6] D[7] D[8] D[9] D[10] D[11] D[12] D[13] D[14] D[15]
+       D[16] D[17] D[18] D[19] D[20] D[21] D[22] D[23] D[24] D[25] D[26] D[27]
+       DCLKT DIB[0] DIB[1] DIB[2] DIB[3] DIB[4] DIB[5] DIB[6] DIB[7] DIB[8]
+       DIB[9] DIB[10] DIB[11] DIB[12] DIB[13] DIB[14] DIB[15] DIB[16] DIB[17]
+       DIB[18] DIB[19] DIB[20] DIB[21] DIB[22] DIB[23] DIB[24] DIB[25] DIB[26]
+       DIB[27] DINB[0] DINB[1] DINB[2] DINB[3] DINB[4] DINB[5] DINB[6] DINB[7]
+       DINB[8] DINB[9] DINB[10] DINB[11] DINB[12] DINB[13] DINB[14] DINB[15]
+       DINB[16] DINB[17] DINB[18] DINB[19] DINB[20] DINB[21] DINB[22] DINB[23]
+       DINB[24] DINB[25] DINB[26] DINB[27] DLYPDB D_AL[0] D_AL[1] D_AL[2]
+       D_AL[3] D_AL[4] D_AL[5] D_AL[6] D_AL[7] D_AL[8] D_AL[9] D_AL[10]
+       D_AL[11] D_AL[12] D_AL[13] D_AL[14] D_AL[15] D_AL[16] D_AL[17] D_AL[18]
+       D_AL[19] D_AL[20] D_AL[21] D_AL[22] D_AL[23] D_AL[24] D_AL[25] D_AL[26]
+       D_AL[27] GSE_DB GSE_DT IV_WB[0] IV_WB[1] IV_WB[2] IV_WB[3] IV_WB[4]
+       IV_WB[5] IV_WB[6] IV_WB[7] IV_WB[8] IV_WB[9] IV_WB[10] IV_WB[11]
+       IV_WB[12] IV_WB[13] IV_WB[14] IV_WB[15] IV_WB[16] IV_WB[17] IV_WB[18]
+       IV_WB[19] IV_WB[20] IV_WB[21] IV_WB[22] IV_WB[23] IV_WB[24] IV_WB[25]
+       IV_WB[26] IV_WB[27] IV_WT[0] IV_WT[1] IV_WT[2] IV_WT[3] IV_WT[4]
+       IV_WT[5] IV_WT[6] IV_WT[7] IV_WT[8] IV_WT[9] IV_WT[10] IV_WT[11]
+       IV_WT[12] IV_WT[13] IV_WT[14] IV_WT[15] IV_WT[16] IV_WT[17] IV_WT[18]
+       IV_WT[19] IV_WT[20] IV_WT[21] IV_WT[22] IV_WT[23] IV_WT[24] IV_WT[25]
+       IV_WT[26] IV_WT[27] LDFTYBUF LDIB[0] LDIB[1] LDIB[2] LDIB[3] LDIB[4]
+       LDIB[5] LDIB[6] LDIB[7] LDIB[8] LDIB[9] LDIB[10] LDIB[11] LDIB[12]
+       LDIB[13] LDIB[14] LDIB[15] LDIB[16] LDIB[17] LDIB[18] LDIB[19] LDIB[20]
+       LDIB[21] LDIB[22] LDIB[23] LDIB[24] LDIB[25] LDIB[26] LDIB[27] LOG0 LOG1
+       LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7] LQB[8] LQB[9]
+       LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16] LQB[17] LQB[18]
+       LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25] LQB[26] LQB[27]
+       LWIB[0] LWIB[1] LWIB[2] LWIB[3] LWIB[4] LWIB[5] LWIB[6] LWIB[7] LWIB[8]
+       LWIB[9] LWIB[10] LWIB[11] LWIB[12] LWIB[13] LWIB[14] LWIB[15] LWIB[16]
+       LWIB[17] LWIB[18] LWIB[19] LWIB[20] LWIB[21] LWIB[22] LWIB[23] LWIB[24]
+       LWIB[25] LWIB[26] LWIB[27] ND_WB[0] ND_WB[1] ND_WB[2] ND_WB[3] ND_WB[4]
+       ND_WB[5] ND_WB[6] ND_WB[7] ND_WB[8] ND_WB[9] ND_WB[10] ND_WB[11]
+       ND_WB[12] ND_WB[13] ND_WB[14] ND_WB[15] ND_WB[16] ND_WB[17] ND_WB[18]
+       ND_WB[19] ND_WB[20] ND_WB[21] ND_WB[22] ND_WB[23] ND_WB[24] ND_WB[25]
+       ND_WB[26] ND_WB[27] ND_WT[0] ND_WT[1] ND_WT[2] ND_WT[3] ND_WT[4]
+       ND_WT[5] ND_WT[6] ND_WT[7] ND_WT[8] ND_WT[9] ND_WT[10] ND_WT[11]
+       ND_WT[12] ND_WT[13] ND_WT[14] ND_WT[15] ND_WT[16] ND_WT[17] ND_WT[18]
+       ND_WT[19] ND_WT[20] ND_WT[21] ND_WT[22] ND_WT[23] ND_WT[24] ND_WT[25]
+       ND_WT[26] ND_WT[27] PWDOR Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] Q[8]
+       Q[9] Q[10] Q[11] Q[12] Q[13] Q[14] Q[15] Q[16] Q[17] Q[18] Q[19] Q[20]
+       Q[21] Q[22] Q[23] Q[24] Q[25] Q[26] Q[27] VBN[0] VBN[1] VBN[2] VBN[3]
+       VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12]
+       VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20] VBN[21]
+       VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28] VBP[0] VBP[1]
+       VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+       VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20]
+       VBP[21] VBP[22] VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VDDA[0]
+       VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9]
+       VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17]
+       VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24] VDDA[25]
+       VDDA[26] VDDA[27] VDDA[28] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+       VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+       VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20]
+       VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28]
+       VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+       VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+       VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21]
+       VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28]
+       VDDPI_DR[0] VDDPI_DR[1] VDDPI_DR[2] VDDPI_DR[3] VDDPI_DR[4] VDDPI_DR[5]
+       VDDPI_DR[6] VDDPI_DR[7] VDDPI_DR[8] VDDPI_DR[9] VDDPI_DR[10]
+       VDDPI_DR[11] VDDPI_DR[12] VDDPI_DR[13] VDDPI_DR[14] VDDPI_DR[15]
+       VDDPI_DR[16] VDDPI_DR[17] VDDPI_DR[18] VDDPI_DR[19] VDDPI_DR[20]
+       VDDPI_DR[21] VDDPI_DR[22] VDDPI_DR[23] VDDPI_DR[24] VDDPI_DR[25]
+       VDDPI_DR[26] VDDPI_DR[27] VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4]
+       VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13]
+       VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22]
+       VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28] WBI[0] WBI[1] WBI[2]
+       WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12]
+       WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21]
+       WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27] WEM[0] WEM[1] WEM[2]
+       WEM[3] WEM[4] WEM[5] WEM[6] WEM[7] WEM[8] WEM[9] WEM[10] WEM[11] WEM[12]
+       WEM[13] WEM[14] WEM[15] WEM[16] WEM[17] WEM[18] WEM[19] WEM[20] WEM[21]
+       WEM[22] WEM[23] WEM[24] WEM[25] WEM[26] WEM[27] WEMB[0] WEMB[1] WEMB[2]
+       WEMB[3] WEMB[4] WEMB[5] WEMB[6] WEMB[7] WEMB[8] WEMB[9] WEMB[10]
+       WEMB[11] WEMB[12] WEMB[13] WEMB[14] WEMB[15] WEMB[16] WEMB[17] WEMB[18]
+       WEMB[19] WEMB[20] WEMB[21] WEMB[22] WEMB[23] WEMB[24] WEMB[25] WEMB[26]
+       WEMB[27] WEM_AL[0] WEM_AL[1] WEM_AL[2] WEM_AL[3] WEM_AL[4] WEM_AL[5]
+       WEM_AL[6] WEM_AL[7] WEM_AL[8] WEM_AL[9] WEM_AL[10] WEM_AL[11] WEM_AL[12]
+       WEM_AL[13] WEM_AL[14] WEM_AL[15] WEM_AL[16] WEM_AL[17] WEM_AL[18]
+       WEM_AL[19] WEM_AL[20] WEM_AL[21] WEM_AL[22] WEM_AL[23] WEM_AL[24]
+       WEM_AL[25] WEM_AL[26] WEM_AL[27] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4]
+       WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13]
+       WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22]
+       WTI[23] WTI[24] WTI[25] WTI[26] WTI[27]
X_gio_rt_seg1 CB[0] CB[1] CB[2] CB[3] CB[4] CB[5] CB[6] CB[7] CB[8] CB[9] CB[10]
+   CB[11] CB[12] CB[13] CB[14] CB[15] CB[16] CB[17] CB[18] CB[19] CB[20] CB[21]
+   CB[22] CB[23] CB[24] CB[25] CB[26] CB[27] CT[0] CT[1] CT[2] CT[3] CT[4]
+   CT[5] CT[6] CT[7] CT[8] CT[9] CT[10] CT[11] CT[12] CT[13] CT[14] CT[15]
+   CT[16] CT[17] CT[18] CT[19] CT[20] CT[21] CT[22] CT[23] CT[24] CT[25] CT[26]
+   CT[27] D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] D[8] D[9] D[10] D[11] D[12]
+   D[13] D[14] D[15] D[16] D[17] D[18] D[19] D[20] D[21] D[22] D[23] D[24]
+   D[25] D[26] D[27] DCLKT DIB[0] DIB[1] DIB[2] DIB[3] DIB[4] DIB[5] DIB[6]
+   DIB[7] DIB[8] DIB[9] DIB[10] DIB[11] DIB[12] DIB[13] DIB[14] DIB[15] DIB[16]
+   DIB[17] DIB[18] DIB[19] DIB[20] DIB[21] DIB[22] DIB[23] DIB[24] DIB[25]
+   DIB[26] DIB[27] DINB[0] DINB[1] DINB[2] DINB[3] DINB[4] DINB[5] DINB[6]
+   DINB[7] DINB[8] DINB[9] DINB[10] DINB[11] DINB[12] DINB[13] DINB[14]
+   DINB[15] DINB[16] DINB[17] DINB[18] DINB[19] DINB[20] DINB[21] DINB[22]
+   DINB[23] DINB[24] DINB[25] DINB[26] DINB[27] DLYPDB D_AL[0] D_AL[1] D_AL[2]
+   D_AL[3] D_AL[4] D_AL[5] D_AL[6] D_AL[7] D_AL[8] D_AL[9] D_AL[10] D_AL[11]
+   D_AL[12] D_AL[13] D_AL[14] D_AL[15] D_AL[16] D_AL[17] D_AL[18] D_AL[19]
+   D_AL[20] D_AL[21] D_AL[22] D_AL[23] D_AL[24] D_AL[25] D_AL[26] D_AL[27]
+   IV_WB[0] IV_WB[1] IV_WB[2] IV_WB[3] IV_WB[4] IV_WB[5] IV_WB[6] IV_WB[7]
+   IV_WB[8] IV_WB[9] IV_WB[10] IV_WB[11] IV_WB[12] IV_WB[13] IV_WB[14]
+   IV_WB[15] IV_WB[16] IV_WB[17] IV_WB[18] IV_WB[19] IV_WB[20] IV_WB[21]
+   IV_WB[22] IV_WB[23] IV_WB[24] IV_WB[25] IV_WB[26] IV_WB[27] IV_WT[0]
+   IV_WT[1] IV_WT[2] IV_WT[3] IV_WT[4] IV_WT[5] IV_WT[6] IV_WT[7] IV_WT[8]
+   IV_WT[9] IV_WT[10] IV_WT[11] IV_WT[12] IV_WT[13] IV_WT[14] IV_WT[15]
+   IV_WT[16] IV_WT[17] IV_WT[18] IV_WT[19] IV_WT[20] IV_WT[21] IV_WT[22]
+   IV_WT[23] IV_WT[24] IV_WT[25] IV_WT[26] IV_WT[27] LDFTYBUF LDIB[0] LDIB[1]
+   LDIB[2] LDIB[3] LDIB[4] LDIB[5] LDIB[6] LDIB[7] LDIB[8] LDIB[9] LDIB[10]
+   LDIB[11] LDIB[12] LDIB[13] LDIB[14] LDIB[15] LDIB[16] LDIB[17] LDIB[18]
+   LDIB[19] LDIB[20] LDIB[21] LDIB[22] LDIB[23] LDIB[24] LDIB[25] LDIB[26]
+   LDIB[27] LOG0 LOG1 LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7]
+   LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16]
+   LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25]
+   LQB[26] LQB[27] LWIB[0] LWIB[1] LWIB[2] LWIB[3] LWIB[4] LWIB[5] LWIB[6]
+   LWIB[7] LWIB[8] LWIB[9] LWIB[10] LWIB[11] LWIB[12] LWIB[13] LWIB[14]
+   LWIB[15] LWIB[16] LWIB[17] LWIB[18] LWIB[19] LWIB[20] LWIB[21] LWIB[22]
+   LWIB[23] LWIB[24] LWIB[25] LWIB[26] LWIB[27] ND_WB[0] ND_WB[1] ND_WB[2]
+   ND_WB[3] ND_WB[4] ND_WB[5] ND_WB[6] ND_WB[7] ND_WB[8] ND_WB[9] ND_WB[10]
+   ND_WB[11] ND_WB[12] ND_WB[13] ND_WB[14] ND_WB[15] ND_WB[16] ND_WB[17]
+   ND_WB[18] ND_WB[19] ND_WB[20] ND_WB[21] ND_WB[22] ND_WB[23] ND_WB[24]
+   ND_WB[25] ND_WB[26] ND_WB[27] ND_WT[0] ND_WT[1] ND_WT[2] ND_WT[3] ND_WT[4]
+   ND_WT[5] ND_WT[6] ND_WT[7] ND_WT[8] ND_WT[9] ND_WT[10] ND_WT[11] ND_WT[12]
+   ND_WT[13] ND_WT[14] ND_WT[15] ND_WT[16] ND_WT[17] ND_WT[18] ND_WT[19]
+   ND_WT[20] ND_WT[21] ND_WT[22] ND_WT[23] ND_WT[24] ND_WT[25] ND_WT[26]
+   ND_WT[27] Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] Q[8] Q[9] Q[10] Q[11]
+   Q[12] Q[13] Q[14] Q[15] Q[16] Q[17] Q[18] Q[19] Q[20] Q[21] Q[22] Q[23]
+   Q[24] Q[25] Q[26] Q[27] GSE_DB GSE_DT VBN[0] VBN[1] VBN[2] VBN[3] VBN[4]
+   VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14]
+   VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23]
+   VBN[24] VBN[25] VBN[26] VBN[27] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5]
+   VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15]
+   VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24]
+   VBP[25] VBP[26] VBP[27] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5]
+   VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+   VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22]
+   VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20]
+   VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI_DR[0] VDDPI_DR[1]
+   VDDPI_DR[2] VDDPI_DR[3] VDDPI_DR[4] VDDPI_DR[5] VDDPI_DR[6] VDDPI_DR[7]
+   VDDPI_DR[8] VDDPI_DR[9] VDDPI_DR[10] VDDPI_DR[11] VDDPI_DR[12] VDDPI_DR[13]
+   VDDPI_DR[14] VDDPI_DR[15] VDDPI_DR[16] VDDPI_DR[17] VDDPI_DR[18]
+   VDDPI_DR[19] VDDPI_DR[20] VDDPI_DR[21] VDDPI_DR[22] VDDPI_DR[23]
+   VDDPI_DR[24] VDDPI_DR[25] VDDPI_DR[26] VDDPI_DR[27] VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21]
+   VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] WBI[0] WBI[1] WBI[2] WBI[3]
+   WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13]
+   WBI[14] WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22]
+   WBI[23] WBI[24] WBI[25] WBI[26] WBI[27] WEM[0] WEM[1] WEM[2] WEM[3] WEM[4]
+   WEM[5] WEM[6] WEM[7] WEM[8] WEM[9] WEM[10] WEM[11] WEM[12] WEM[13] WEM[14]
+   WEM[15] WEM[16] WEM[17] WEM[18] WEM[19] WEM[20] WEM[21] WEM[22] WEM[23]
+   WEM[24] WEM[25] WEM[26] WEM[27] WEMB[0] WEMB[1] WEMB[2] WEMB[3] WEMB[4]
+   WEMB[5] WEMB[6] WEMB[7] WEMB[8] WEMB[9] WEMB[10] WEMB[11] WEMB[12] WEMB[13]
+   WEMB[14] WEMB[15] WEMB[16] WEMB[17] WEMB[18] WEMB[19] WEMB[20] WEMB[21]
+   WEMB[22] WEMB[23] WEMB[24] WEMB[25] WEMB[26] WEMB[27] WEM_AL[0] WEM_AL[1]
+   WEM_AL[2] WEM_AL[3] WEM_AL[4] WEM_AL[5] WEM_AL[6] WEM_AL[7] WEM_AL[8]
+   WEM_AL[9] WEM_AL[10] WEM_AL[11] WEM_AL[12] WEM_AL[13] WEM_AL[14] WEM_AL[15]
+   WEM_AL[16] WEM_AL[17] WEM_AL[18] WEM_AL[19] WEM_AL[20] WEM_AL[21] WEM_AL[22]
+   WEM_AL[23] WEM_AL[24] WEM_AL[25] WEM_AL[26] WEM_AL[27] WTI[0] WTI[1] WTI[2]
+   WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12]
+   WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21]
+   WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27]
+   SNPS_RF_SP_UHS_256x28_gio_rt_seg1
X_mm19a04_u_hs1prf_capgio_cm4 VDDA[28] VDDP[28] VDDPI[28] VSS[28] VBP[28]
+   VBN[28] LOG0 LOG1 PWDOR VEDGE mm19a04_u_hs1prf_capgio
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_gio_row ARYSDR ARYSD_BC1 ARYSD_BC2 BC0 BC1 BC2
+       BKADR CB[0] CB[1] CB[2] CB[3] CB[4] CB[5] CB[6] CB[7] CB[8] CB[9] CB[10]
+       CB[11] CB[12] CB[13] CB[14] CB[15] CB[16] CB[17] CB[18] CB[19] CB[20]
+       CB[21] CB[22] CB[23] CB[24] CB[25] CB[26] CB[27] CENDP CKGATE CLK CLKB
+       CLKDEL CLKFLT CLK_MUXB CLPSEBUF CT[0] CT[1] CT[2] CT[3] CT[4] CT[5]
+       CT[6] CT[7] CT[8] CT[9] CT[10] CT[11] CT[12] CT[13] CT[14] CT[15] CT[16]
+       CT[17] CT[18] CT[19] CT[20] CT[21] CT[22] CT[23] CT[24] CT[25] CT[26]
+       CT[27] D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] D[8] D[9] D[10] D[11]
+       D[12] D[13] D[14] D[15] D[16] D[17] D[18] D[19] D[20] D[21] D[22] D[23]
+       D[24] D[25] D[26] D[27] DEF1 DEF12B_PROG DEF12_PROG DEF1B DEF2 DEF2B
+       DEF_MODE DEF_PROG DFTCLKEN DFTMASK_BCEN DIB[0] DIB[1] DIB[2] DIB[3]
+       DIB[4] DIB[5] DIB[6] DIB[7] DIB[8] DIB[9] DIB[10] DIB[11] DIB[12]
+       DIB[13] DIB[14] DIB[15] DIB[16] DIB[17] DIB[18] DIB[19] DIB[20] DIB[21]
+       DIB[22] DIB[23] DIB[24] DIB[25] DIB[26] DIB[27] DINB[0] DINB[1] DINB[2]
+       DINB[3] DINB[4] DINB[5] DINB[6] DINB[7] DINB[8] DINB[9] DINB[10]
+       DINB[11] DINB[12] DINB[13] DINB[14] DINB[15] DINB[16] DINB[17] DINB[18]
+       DINB[19] DINB[20] DINB[21] DINB[22] DINB[23] DINB[24] DINB[25] DINB[26]
+       DINB[27] DISCHG DLYPDB DLYPW D_AL[0] D_AL[1] D_AL[2] D_AL[3] D_AL[4]
+       D_AL[5] D_AL[6] D_AL[7] D_AL[8] D_AL[9] D_AL[10] D_AL[11] D_AL[12]
+       D_AL[13] D_AL[14] D_AL[15] D_AL[16] D_AL[17] D_AL[18] D_AL[19] D_AL[20]
+       D_AL[21] D_AL[22] D_AL[23] D_AL[24] D_AL[25] D_AL[26] D_AL[27]
+       FAST1_MODE FAST2_MODE FISO FLOAT FLOAT_RET GSE_DB GSE_DT IV_WB[0]
+       IV_WB[1] IV_WB[2] IV_WB[3] IV_WB[4] IV_WB[5] IV_WB[6] IV_WB[7] IV_WB[8]
+       IV_WB[9] IV_WB[10] IV_WB[11] IV_WB[12] IV_WB[13] IV_WB[14] IV_WB[15]
+       IV_WB[16] IV_WB[17] IV_WB[18] IV_WB[19] IV_WB[20] IV_WB[21] IV_WB[22]
+       IV_WB[23] IV_WB[24] IV_WB[25] IV_WB[26] IV_WB[27] IV_WT[0] IV_WT[1]
+       IV_WT[2] IV_WT[3] IV_WT[4] IV_WT[5] IV_WT[6] IV_WT[7] IV_WT[8] IV_WT[9]
+       IV_WT[10] IV_WT[11] IV_WT[12] IV_WT[13] IV_WT[14] IV_WT[15] IV_WT[16]
+       IV_WT[17] IV_WT[18] IV_WT[19] IV_WT[20] IV_WT[21] IV_WT[22] IV_WT[23]
+       IV_WT[24] IV_WT[25] IV_WT[26] IV_WT[27] LBKADR LCLKB LCLKT LDFTX
+       LDFTYBUF LDIB[0] LDIB[1] LDIB[2] LDIB[3] LDIB[4] LDIB[5] LDIB[6] LDIB[7]
+       LDIB[8] LDIB[9] LDIB[10] LDIB[11] LDIB[12] LDIB[13] LDIB[14] LDIB[15]
+       LDIB[16] LDIB[17] LDIB[18] LDIB[19] LDIB[20] LDIB[21] LDIB[22] LDIB[23]
+       LDIB[24] LDIB[25] LDIB[26] LDIB[27] LITESLP LME LOG0 LOG1 LQB[0] LQB[1]
+       LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7] LQB[8] LQB[9] LQB[10] LQB[11]
+       LQB[12] LQB[13] LQB[14] LQB[15] LQB[16] LQB[17] LQB[18] LQB[19] LQB[20]
+       LQB[21] LQB[22] LQB[23] LQB[24] LQB[25] LQB[26] LQB[27] LS LWE LWEIB
+       LWIB[0] LWIB[1] LWIB[2] LWIB[3] LWIB[4] LWIB[5] LWIB[6] LWIB[7] LWIB[8]
+       LWIB[9] LWIB[10] LWIB[11] LWIB[12] LWIB[13] LWIB[14] LWIB[15] LWIB[16]
+       LWIB[17] LWIB[18] LWIB[19] LWIB[20] LWIB[21] LWIB[22] LWIB[23] LWIB[24]
+       LWIB[25] LWIB[26] LWIB[27] LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+       LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] MCLKB MCLKT ME MEB_I MEB_LT
+       MEORDFTCLKEN MEORDFTCLKEN_IN ND_WB[0] ND_WB[1] ND_WB[2] ND_WB[3]
+       ND_WB[4] ND_WB[5] ND_WB[6] ND_WB[7] ND_WB[8] ND_WB[9] ND_WB[10]
+       ND_WB[11] ND_WB[12] ND_WB[13] ND_WB[14] ND_WB[15] ND_WB[16] ND_WB[17]
+       ND_WB[18] ND_WB[19] ND_WB[20] ND_WB[21] ND_WB[22] ND_WB[23] ND_WB[24]
+       ND_WB[25] ND_WB[26] ND_WB[27] ND_WT[0] ND_WT[1] ND_WT[2] ND_WT[3]
+       ND_WT[4] ND_WT[5] ND_WT[6] ND_WT[7] ND_WT[8] ND_WT[9] ND_WT[10]
+       ND_WT[11] ND_WT[12] ND_WT[13] ND_WT[14] ND_WT[15] ND_WT[16] ND_WT[17]
+       ND_WT[18] ND_WT[19] ND_WT[20] ND_WT[21] ND_WT[22] ND_WT[23] ND_WT[24]
+       ND_WT[25] ND_WT[26] ND_WT[27] PLBKADR PROCOM[0] PROCOM[1] PROCOML PWDOR
+       Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] Q[8] Q[9] Q[10] Q[11] Q[12]
+       Q[13] Q[14] Q[15] Q[16] Q[17] Q[18] Q[19] Q[20] Q[21] Q[22] Q[23] Q[24]
+       Q[25] Q[26] Q[27] RA[0] RA[1] RASSIST[0] RASSIST[1] RM[0] RM[1] RM[2]
+       RM3CNT RMDEF1[0] RMDEF1[1] RMDEF1[2] RMDEF1[3] RMDEF1_PROCOM00[0]
+       RMDEF1_PROCOM00[1] RMDEF1_PROCOM00[2] RMDEF1_PROCOM00[3]
+       RMDEF1_PROCOM01[0] RMDEF1_PROCOM01[1] RMDEF1_PROCOM01[2]
+       RMDEF1_PROCOM01[3] RMDEF2[0] RMDEF2[1] RMDEF2[2] RMDEF2[3]
+       RMDEF2_PROCOM00[0] RMDEF2_PROCOM00[1] RMDEF2_PROCOM00[2]
+       RMDEF2_PROCOM00[3] RMDEF2_PROCOM01[0] RMDEF2_PROCOM01[1]
+       RMDEF2_PROCOM01[2] RMDEF2_PROCOM01[3] RME RMENI[0] RMENI[1] RMENI[2]
+       RMSLOW[0] RMSLOW[1] RMSLOW[2] RMSLOW[3] RMT[0] RMT[1] RMT[2] RMT[3]
+       RSCEN RSCIN RSCLK RSCOUT RSCRST RWLCKB SD T1T TEST1 TEST_RNM TEST_RNMB
+       VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+       VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18]
+       VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27]
+       VBN[28] VBN[29] VBN[30] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+       VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15]
+       VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24]
+       VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VDDA[0] VDDA[1] VDDA[2]
+       VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10]
+       VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17] VDDA[18]
+       VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24] VDDA[25] VDDA[26]
+       VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDF VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+       VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11]
+       VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19]
+       VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27]
+       VDDP[28] VDDP[29] VDDP[30] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+       VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+       VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18]
+       VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25]
+       VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30] VDDPI_DR[0]
+       VDDPI_DR[1] VDDPI_DR[2] VDDPI_DR[3] VDDPI_DR[4] VDDPI_DR[5] VDDPI_DR[6]
+       VDDPI_DR[7] VDDPI_DR[8] VDDPI_DR[9] VDDPI_DR[10] VDDPI_DR[11]
+       VDDPI_DR[12] VDDPI_DR[13] VDDPI_DR[14] VDDPI_DR[15] VDDPI_DR[16]
+       VDDPI_DR[17] VDDPI_DR[18] VDDPI_DR[19] VDDPI_DR[20] VDDPI_DR[21]
+       VDDPI_DR[22] VDDPI_DR[23] VDDPI_DR[24] VDDPI_DR[25] VDDPI_DR[26]
+       VDDPI_DR[27] VDDPI_LOG1 VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+       VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14]
+       VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23]
+       VSS[24] VSS[25] VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] WA[0] WA[1]
+       WA[2] WABUF[0] WABUF[1] WABUF[2] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4]
+       WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13]
+       WBI[14] WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22]
+       WBI[23] WBI[24] WBI[25] WBI[26] WBI[27] WE WEM[0] WEM[1] WEM[2] WEM[3]
+       WEM[4] WEM[5] WEM[6] WEM[7] WEM[8] WEM[9] WEM[10] WEM[11] WEM[12]
+       WEM[13] WEM[14] WEM[15] WEM[16] WEM[17] WEM[18] WEM[19] WEM[20] WEM[21]
+       WEM[22] WEM[23] WEM[24] WEM[25] WEM[26] WEM[27] WEMB[0] WEMB[1] WEMB[2]
+       WEMB[3] WEMB[4] WEMB[5] WEMB[6] WEMB[7] WEMB[8] WEMB[9] WEMB[10]
+       WEMB[11] WEMB[12] WEMB[13] WEMB[14] WEMB[15] WEMB[16] WEMB[17] WEMB[18]
+       WEMB[19] WEMB[20] WEMB[21] WEMB[22] WEMB[23] WEMB[24] WEMB[25] WEMB[26]
+       WEMB[27] WEM_AL[0] WEM_AL[1] WEM_AL[2] WEM_AL[3] WEM_AL[4] WEM_AL[5]
+       WEM_AL[6] WEM_AL[7] WEM_AL[8] WEM_AL[9] WEM_AL[10] WEM_AL[11] WEM_AL[12]
+       WEM_AL[13] WEM_AL[14] WEM_AL[15] WEM_AL[16] WEM_AL[17] WEM_AL[18]
+       WEM_AL[19] WEM_AL[20] WEM_AL[21] WEM_AL[22] WEM_AL[23] WEM_AL[24]
+       WEM_AL[25] WEM_AL[26] WEM_AL[27] WFLOAT WMDEF1[0] WMDEF1[1] WMDEF1[2]
+       WMDEF1[3] WMDEF1_PROCOM00[0] WMDEF1_PROCOM00[1] WMDEF1_PROCOM00[2]
+       WMDEF1_PROCOM00[3] WMDEF1_PROCOM01[0] WMDEF1_PROCOM01[1]
+       WMDEF1_PROCOM01[2] WMDEF1_PROCOM01[3] WMDEF2[0] WMDEF2[1] WMDEF2[2]
+       WMDEF2[3] WMDEF2_PROCOM00[0] WMDEF2_PROCOM00[1] WMDEF2_PROCOM00[2]
+       WMDEF2_PROCOM00[3] WMDEF2_PROCOM01[0] WMDEF2_PROCOM01[1]
+       WMDEF2_PROCOM01[2] WMDEF2_PROCOM01[3] WMSLOW[0] WMSLOW[1] WMSLOW[2]
+       WMSLOW[3] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]
+       WPULSE[0] WPULSE[1] WPULSE[2] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+       WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14]
+       WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23]
+       WTI[24] WTI[25] WTI[26] WTI[27] XADR[0] XADR[1] XADR[2] XADR[3] XADR[4]
+       XADR[5] XADR[6] XADR[7] YADR[0] YADR[1]
X_gio_cnt ARYSDR ARYSD_BC1 ARYSD_BC2 BC0 BC1 BC2 BKADR CENDP CKGATE CLK CLKB
+   CLKDEL CLKFLT CLK_MUXB CLPSEBUF DCLKT DEF1 DEF12B_PROG DEF12_PROG DEF1B DEF2
+   DEF2B DEF_MODE DEF_PROG DFTCLKEN DFTMASK_BCEN DISCHG DLYPDB DLYPW FAST1_MODE
+   FAST2_MODE FISO FLOAT FLOAT_RET GSE_DB GSE_DT LBKADR LCLKB LCLKT LDFTX
+   LDFTYBUF LITESLP LME LOG0 LOG1 LS LWE LWEIB LXADR[0] LXADR[1] LXADR[2]
+   LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] MCLKB MCLKT
+   ME MEB_I MEB_LT MEORDFTCLKEN MEORDFTCLKEN_IN PLBKADR PROCOM[0] PROCOM[1]
+   PROCOML RA[0] RA[1] RASSIST[0] RASSIST[1] RM[0] RM[1] RM[2] RM3CNT RMDEF1[0]
+   RMDEF1[1] RMDEF1[2] RMDEF1[3] RMDEF1_PROCOM00[0] RMDEF1_PROCOM00[1]
+   RMDEF1_PROCOM00[2] RMDEF1_PROCOM00[3] RMDEF1_PROCOM01[0] RMDEF1_PROCOM01[1]
+   RMDEF1_PROCOM01[2] RMDEF1_PROCOM01[3] RMDEF2[0] RMDEF2[1] RMDEF2[2]
+   RMDEF2[3] RMDEF2_PROCOM00[0] RMDEF2_PROCOM00[1] RMDEF2_PROCOM00[2]
+   RMDEF2_PROCOM00[3] RMDEF2_PROCOM01[0] RMDEF2_PROCOM01[1] RMDEF2_PROCOM01[2]
+   RMDEF2_PROCOM01[3] RME RMENI[0] RMENI[1] RMENI[2] RMSLOW[0] RMSLOW[1]
+   RMSLOW[2] RMSLOW[3] RMT[0] RMT[1] RMT[2] RMT[3] RSCEN RSCIN RSCLK RSCOUT
+   RSCRST RWLCKB SD T1T TEST1 TEST_RNM TEST_RNMB VBN[0] VBN[1] VBP[0] VBP[1]
+   VDDA[0] VDDA[1] VDDF VDDP[0] VDDP[1] VDDPI[0] VDDPI[1] VDDPI_LOG1 VSS[0]
+   VSS[1] WA[0] WA[1] WA[2] WABUF[0] WABUF[1] WABUF[2] WE WFLOAT WMDEF1[0]
+   WMDEF1[1] WMDEF1[2] WMDEF1[3] WMDEF1_PROCOM00[0] WMDEF1_PROCOM00[1]
+   WMDEF1_PROCOM00[2] WMDEF1_PROCOM00[3] WMDEF1_PROCOM01[0] WMDEF1_PROCOM01[1]
+   WMDEF1_PROCOM01[2] WMDEF1_PROCOM01[3] WMDEF2[0] WMDEF2[1] WMDEF2[2]
+   WMDEF2[3] WMDEF2_PROCOM00[0] WMDEF2_PROCOM00[1] WMDEF2_PROCOM00[2]
+   WMDEF2_PROCOM00[3] WMDEF2_PROCOM01[0] WMDEF2_PROCOM01[1] WMDEF2_PROCOM01[2]
+   WMDEF2_PROCOM01[3] WMSLOW[0] WMSLOW[1] WMSLOW[2] WMSLOW[3] WMT[0] WMT[1]
+   WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WPULSE[0] WPULSE[1] WPULSE[2]
+   XADR[0] XADR[1] XADR[2] XADR[3] XADR[4] XADR[5] XADR[6] XADR[7] YADR[0]
+   YADR[1] SNPS_RF_SP_UHS_256x28_gio_cnt
X_gio_rt CB[0] CB[1] CB[2] CB[3] CB[4] CB[5] CB[6] CB[7] CB[8] CB[9] CB[10]
+   CB[11] CB[12] CB[13] CB[14] CB[15] CB[16] CB[17] CB[18] CB[19] CB[20] CB[21]
+   CB[22] CB[23] CB[24] CB[25] CB[26] CB[27] CT[0] CT[1] CT[2] CT[3] CT[4]
+   CT[5] CT[6] CT[7] CT[8] CT[9] CT[10] CT[11] CT[12] CT[13] CT[14] CT[15]
+   CT[16] CT[17] CT[18] CT[19] CT[20] CT[21] CT[22] CT[23] CT[24] CT[25] CT[26]
+   CT[27] D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] D[8] D[9] D[10] D[11] D[12]
+   D[13] D[14] D[15] D[16] D[17] D[18] D[19] D[20] D[21] D[22] D[23] D[24]
+   D[25] D[26] D[27] DCLKT DIB[0] DIB[1] DIB[2] DIB[3] DIB[4] DIB[5] DIB[6]
+   DIB[7] DIB[8] DIB[9] DIB[10] DIB[11] DIB[12] DIB[13] DIB[14] DIB[15] DIB[16]
+   DIB[17] DIB[18] DIB[19] DIB[20] DIB[21] DIB[22] DIB[23] DIB[24] DIB[25]
+   DIB[26] DIB[27] DINB[0] DINB[1] DINB[2] DINB[3] DINB[4] DINB[5] DINB[6]
+   DINB[7] DINB[8] DINB[9] DINB[10] DINB[11] DINB[12] DINB[13] DINB[14]
+   DINB[15] DINB[16] DINB[17] DINB[18] DINB[19] DINB[20] DINB[21] DINB[22]
+   DINB[23] DINB[24] DINB[25] DINB[26] DINB[27] DLYPDB D_AL[0] D_AL[1] D_AL[2]
+   D_AL[3] D_AL[4] D_AL[5] D_AL[6] D_AL[7] D_AL[8] D_AL[9] D_AL[10] D_AL[11]
+   D_AL[12] D_AL[13] D_AL[14] D_AL[15] D_AL[16] D_AL[17] D_AL[18] D_AL[19]
+   D_AL[20] D_AL[21] D_AL[22] D_AL[23] D_AL[24] D_AL[25] D_AL[26] D_AL[27]
+   GSE_DB GSE_DT IV_WB[0] IV_WB[1] IV_WB[2] IV_WB[3] IV_WB[4] IV_WB[5] IV_WB[6]
+   IV_WB[7] IV_WB[8] IV_WB[9] IV_WB[10] IV_WB[11] IV_WB[12] IV_WB[13] IV_WB[14]
+   IV_WB[15] IV_WB[16] IV_WB[17] IV_WB[18] IV_WB[19] IV_WB[20] IV_WB[21]
+   IV_WB[22] IV_WB[23] IV_WB[24] IV_WB[25] IV_WB[26] IV_WB[27] IV_WT[0]
+   IV_WT[1] IV_WT[2] IV_WT[3] IV_WT[4] IV_WT[5] IV_WT[6] IV_WT[7] IV_WT[8]
+   IV_WT[9] IV_WT[10] IV_WT[11] IV_WT[12] IV_WT[13] IV_WT[14] IV_WT[15]
+   IV_WT[16] IV_WT[17] IV_WT[18] IV_WT[19] IV_WT[20] IV_WT[21] IV_WT[22]
+   IV_WT[23] IV_WT[24] IV_WT[25] IV_WT[26] IV_WT[27] LDFTYBUF LDIB[0] LDIB[1]
+   LDIB[2] LDIB[3] LDIB[4] LDIB[5] LDIB[6] LDIB[7] LDIB[8] LDIB[9] LDIB[10]
+   LDIB[11] LDIB[12] LDIB[13] LDIB[14] LDIB[15] LDIB[16] LDIB[17] LDIB[18]
+   LDIB[19] LDIB[20] LDIB[21] LDIB[22] LDIB[23] LDIB[24] LDIB[25] LDIB[26]
+   LDIB[27] LOG0 LOG1 LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7]
+   LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16]
+   LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25]
+   LQB[26] LQB[27] LWIB[0] LWIB[1] LWIB[2] LWIB[3] LWIB[4] LWIB[5] LWIB[6]
+   LWIB[7] LWIB[8] LWIB[9] LWIB[10] LWIB[11] LWIB[12] LWIB[13] LWIB[14]
+   LWIB[15] LWIB[16] LWIB[17] LWIB[18] LWIB[19] LWIB[20] LWIB[21] LWIB[22]
+   LWIB[23] LWIB[24] LWIB[25] LWIB[26] LWIB[27] ND_WB[0] ND_WB[1] ND_WB[2]
+   ND_WB[3] ND_WB[4] ND_WB[5] ND_WB[6] ND_WB[7] ND_WB[8] ND_WB[9] ND_WB[10]
+   ND_WB[11] ND_WB[12] ND_WB[13] ND_WB[14] ND_WB[15] ND_WB[16] ND_WB[17]
+   ND_WB[18] ND_WB[19] ND_WB[20] ND_WB[21] ND_WB[22] ND_WB[23] ND_WB[24]
+   ND_WB[25] ND_WB[26] ND_WB[27] ND_WT[0] ND_WT[1] ND_WT[2] ND_WT[3] ND_WT[4]
+   ND_WT[5] ND_WT[6] ND_WT[7] ND_WT[8] ND_WT[9] ND_WT[10] ND_WT[11] ND_WT[12]
+   ND_WT[13] ND_WT[14] ND_WT[15] ND_WT[16] ND_WT[17] ND_WT[18] ND_WT[19]
+   ND_WT[20] ND_WT[21] ND_WT[22] ND_WT[23] ND_WT[24] ND_WT[25] ND_WT[26]
+   ND_WT[27] PWDOR Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] Q[8] Q[9] Q[10]
+   Q[11] Q[12] Q[13] Q[14] Q[15] Q[16] Q[17] Q[18] Q[19] Q[20] Q[21] Q[22]
+   Q[23] Q[24] Q[25] Q[26] Q[27] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7]
+   VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+   VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25]
+   VBN[26] VBN[27] VBN[28] VBN[29] VBN[30] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+   VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+   VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+   VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VDDA[2] VDDA[3] VDDA[4] VDDA[5]
+   VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+   VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22]
+   VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5]
+   VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13]
+   VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20]
+   VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27]
+   VDDPI[28] VDDPI[29] VDDPI[30] VDDPI_DR[0] VDDPI_DR[1] VDDPI_DR[2]
+   VDDPI_DR[3] VDDPI_DR[4] VDDPI_DR[5] VDDPI_DR[6] VDDPI_DR[7] VDDPI_DR[8]
+   VDDPI_DR[9] VDDPI_DR[10] VDDPI_DR[11] VDDPI_DR[12] VDDPI_DR[13] VDDPI_DR[14]
+   VDDPI_DR[15] VDDPI_DR[16] VDDPI_DR[17] VDDPI_DR[18] VDDPI_DR[19]
+   VDDPI_DR[20] VDDPI_DR[21] VDDPI_DR[22] VDDPI_DR[23] VDDPI_DR[24]
+   VDDPI_DR[25] VDDPI_DR[26] VDDPI_DR[27] VEDGE VSS[2] VSS[3] VSS[4] VSS[5]
+   VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15]
+   VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24]
+   VSS[25] VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] WBI[0] WBI[1] WBI[2] WBI[3]
+   WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13]
+   WBI[14] WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22]
+   WBI[23] WBI[24] WBI[25] WBI[26] WBI[27] WEM[0] WEM[1] WEM[2] WEM[3] WEM[4]
+   WEM[5] WEM[6] WEM[7] WEM[8] WEM[9] WEM[10] WEM[11] WEM[12] WEM[13] WEM[14]
+   WEM[15] WEM[16] WEM[17] WEM[18] WEM[19] WEM[20] WEM[21] WEM[22] WEM[23]
+   WEM[24] WEM[25] WEM[26] WEM[27] WEMB[0] WEMB[1] WEMB[2] WEMB[3] WEMB[4]
+   WEMB[5] WEMB[6] WEMB[7] WEMB[8] WEMB[9] WEMB[10] WEMB[11] WEMB[12] WEMB[13]
+   WEMB[14] WEMB[15] WEMB[16] WEMB[17] WEMB[18] WEMB[19] WEMB[20] WEMB[21]
+   WEMB[22] WEMB[23] WEMB[24] WEMB[25] WEMB[26] WEMB[27] WEM_AL[0] WEM_AL[1]
+   WEM_AL[2] WEM_AL[3] WEM_AL[4] WEM_AL[5] WEM_AL[6] WEM_AL[7] WEM_AL[8]
+   WEM_AL[9] WEM_AL[10] WEM_AL[11] WEM_AL[12] WEM_AL[13] WEM_AL[14] WEM_AL[15]
+   WEM_AL[16] WEM_AL[17] WEM_AL[18] WEM_AL[19] WEM_AL[20] WEM_AL[21] WEM_AL[22]
+   WEM_AL[23] WEM_AL[24] WEM_AL[25] WEM_AL[26] WEM_AL[27] WTI[0] WTI[1] WTI[2]
+   WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12]
+   WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21]
+   WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27] SNPS_RF_SP_UHS_256x28_gio_rt
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_sac_cnt_wa ARYSDR ARYSD_BC1 ARYSD_BC2 BYP_VLOAD
+       CENDP DEF_MODE DLYPDB DLYPW ENLPGB_R FAST1_MODE FAST2_MODE FLOAT FLOATT
+       FLOAT_RET LBKADR LCGTH LCGTHB LCGTHB_PCHG LDFTX LITESLP LOG0 LOG1 LWEIB
+       LWERD LWEWR LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+       LXADR[6] LXADR[7] LYADR[0] LYADR[1] PM[0] PM[1] PM[2] PM[3] PRCKDLY
+       PROCOML RASSIST[0] RASSIST[1] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1]
+       RMT[2] RMT[3] RWLB SAEB_INT T1T TAP0 TAP1 TAP2 TAP3 TEST_RNMB VBN[0]
+       VBN[1] VBP[0] VBP[1] VDDA VDDF VDDP[0] VDDP[1] VDDPI[0] VDDPI[1] VSS[0]
+       VSS[1] WABUF[0] WABUF[1] WABUF[2] WAPRCLK WAPRCLKBUF WAPRCLKBUFB_RETI
+       WA_R0 WA_R1 WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]

*** Jumper Report ***
* Jumper: PRCKDLY TAP1
* Jumper: VDDA VDDP[0] VDDP[1] VDDPI[0] VDDPI[1]

*X_mm19a04_u_sac_wa_cm4_edge_cd0 mm19a04_u_sac_wa_cm4_edge_cd0
X_mm19a04_u_hs1prf_sactrl_wa VDDA VDDF VDDP[0] VDDPI[0] VSS[0] VBP[0] VBN[0]
+   PM[0] PM[1] PM[2] PM[3] BYP_VLOAD CENDP DEF_MODE DLYPW ENLPGB_R FAST1_MODE
+   FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR LCGTHB LCGTHB_PCHG LCGTHLV LDFTX
+   LITESLP LOG0 LOG1 LWEIB LWERD LWEWR PRCKDLY RBLRD RBLWA RBLWR RM3CNT RMT[0]
+   RMT[1] RMT[2] RMT[3] RWLB RWLBHV RWLBLV T1T TAP0 TAP1 TAP2 TAP3 TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WAPRCLK WAPRCLKBUFB_RETI WMT[0] WMT[1] WMT[2]
+   WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] LXADR[0] LXADR[1] LXADR[2] LXADR[3]
+   LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   mm19a04_u_hs1prf_sactrl_wa
X_mm19a04_u_hs1prf_sacbuf_wa VDDA VDDP[1] VDDPI[1] VSS[1] VBP[1] VBN[1] WA_R0
+   WA_R1 WAPRCLKBUF ARYSDR ARYSD_BC1 ARYSD_BC2 DLYPDB LCGTH PROCOML RASSIST[0]
+   RASSIST[1] SAEB_INT WAPRCLKBUFB_RETI WABUF[0] WABUF[1] WAPRCLK
+   mm19a04_u_hs1prf_sacbuf_wa
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_sac_rt_seg1seg_wa LOG1[0] LOG1[1] LOG1[2] LOG1[3]
+       LOG1[4] LOG1[5] LOG1[6] LOG1[7] LOG1[8] LOG1[9] LOG1[10] LOG1[11]
+       LOG1[12] LOG1[13] LOG1[14] LOG1[15] LOG1[16] LOG1[17] LOG1[18] LOG1[19]
+       LOG1[20] LOG1[21] LOG1[22] LOG1[23] LOG1[24] LOG1[25] LOG1[26] LOG1[27]
+       LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7] LQB[8] LQB[9]
+       LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16] LQB[17] LQB[18]
+       LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25] LQB[26] LQB[27]
+       RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10]
+       RB[11] RB[12] RB[13] RB[14] RB[15] RB[16] RB[17] RB[18] RB[19] RB[20]
+       RB[21] RB[22] RB[23] RB[24] RB[25] RB[26] RB[27] RT[0] RT[1] RT[2] RT[3]
+       RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14]
+       RT[15] RT[16] RT[17] RT[18] RT[19] RT[20] RT[21] RT[22] RT[23] RT[24]
+       RT[25] RT[26] RT[27] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+       VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15]
+       VBN[16] VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24]
+       VBN[25] VBN[26] VBN[27] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+       VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15]
+       VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24]
+       VBP[25] VBP[26] VBP[27] VDDA VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+       VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+       VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20]
+       VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+       VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+       VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+       VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VSS[0] VSS[1] VSS[2]
+       VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+       VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21]
+       VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS_WA[0] VSS_WA[1]
+       VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7] VSS_WA[8]
+       VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12] VSS_WA[13] VSS_WA[14]
+       VSS_WA[15] VSS_WA[16] VSS_WA[17] VSS_WA[18] VSS_WA[19] VSS_WA[20]
+       VSS_WA[21] VSS_WA[22] VSS_WA[23] VSS_WA[24] VSS_WA[25] VSS_WA[26]
+       VSS_WA[27] WA[0] WA[1] WAPRCLKBUF WAPRCLKBUFB_RETI WB[0] WB[1] WB[2]
+       WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13]
+       WB[14] WB[15] WB[16] WB[17] WB[18] WB[19] WB[20] WB[21] WB[22] WB[23]
+       WB[24] WB[25] WB[26] WB[27] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+       WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14]
+       WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23]
+       WBI[24] WBI[25] WBI[26] WBI[27] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5]
+       WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WT[16]
+       WT[17] WT[18] WT[19] WT[20] WT[21] WT[22] WT[23] WT[24] WT[25] WT[26]
+       WT[27] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8]
+       WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16] WTI[17]
+       WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25] WTI[26]
+       WTI[27]

*** Jumper Report ***
* Jumper: VDDP[0] VDDPI[0]
* Jumper: VDDP[1] VDDPI[1]
* Jumper: VDDP[2] VDDPI[2]
* Jumper: VDDP[3] VDDPI[3]
* Jumper: VDDP[4] VDDPI[4]
* Jumper: VDDP[5] VDDPI[5]
* Jumper: VDDP[6] VDDPI[6]
* Jumper: VDDP[7] VDDPI[7]
* Jumper: VDDP[8] VDDPI[8]
* Jumper: VDDP[9] VDDPI[9]
* Jumper: VDDP[10] VDDPI[10]
* Jumper: VDDP[11] VDDPI[11]
* Jumper: VDDP[12] VDDPI[12]
* Jumper: VDDP[13] VDDPI[13]
* Jumper: VDDP[14] VDDPI[14]
* Jumper: VDDP[15] VDDPI[15]
* Jumper: VDDP[16] VDDPI[16]
* Jumper: VDDP[17] VDDPI[17]
* Jumper: VDDP[18] VDDPI[18]
* Jumper: VDDP[19] VDDPI[19]
* Jumper: VDDP[20] VDDPI[20]
* Jumper: VDDP[21] VDDPI[21]
* Jumper: VDDP[22] VDDPI[22]
* Jumper: VDDP[23] VDDPI[23]
* Jumper: VDDP[24] VDDPI[24]
* Jumper: VDDP[25] VDDPI[25]
* Jumper: VDDP[26] VDDPI[26]
* Jumper: VDDP[27] VDDPI[27]

X_mm19a04_u_hs1prf_sacm4x1_wa_128_S0 VDDA VDDP[0] VDDPI[0] VSS[0] VSS_WA[0]
+   VBP[0] VBN[0] LOG1[0] LQB[0] RB[0] RT[0] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RETI WB[0] WBI[0] WT[0] WTI[0] mm19a04_u_hs1prf_sacm4x1_wa_128
X_mm19a04_u_hs1prf_sacm4x1_wa_128_S1 VDDA VDDP[1] VDDPI[1] VSS[1] VSS_WA[1]
+   VBP[1] VBN[1] LOG1[1] LQB[1] RB[1] RT[1] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RETI WB[1] WBI[1] WT[1] WTI[1] mm19a04_u_hs1prf_sacm4x1_wa_128
X_mm19a04_u_hs1prf_sacm4x1_wa_128_S2 VDDA VDDP[2] VDDPI[2] VSS[2] VSS_WA[2]
+   VBP[2] VBN[2] LOG1[2] LQB[2] RB[2] RT[2] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RETI WB[2] WBI[2] WT[2] WTI[2] mm19a04_u_hs1prf_sacm4x1_wa_128
X_mm19a04_u_hs1prf_sacm4x1_wa_128_S3 VDDA VDDP[3] VDDPI[3] VSS[3] VSS_WA[3]
+   VBP[3] VBN[3] LOG1[3] LQB[3] RB[3] RT[3] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RETI WB[3] WBI[3] WT[3] WTI[3] mm19a04_u_hs1prf_sacm4x1_wa_128
X_mm19a04_u_hs1prf_sacm4x1_wa_128_S4 VDDA VDDP[4] VDDPI[4] VSS[4] VSS_WA[4]
+   VBP[4] VBN[4] LOG1[4] LQB[4] RB[4] RT[4] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RETI WB[4] WBI[4] WT[4] WTI[4] mm19a04_u_hs1prf_sacm4x1_wa_128
X_mm19a04_u_hs1prf_sacm4x1_wa_128_S5 VDDA VDDP[5] VDDPI[5] VSS[5] VSS_WA[5]
+   VBP[5] VBN[5] LOG1[5] LQB[5] RB[5] RT[5] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RETI WB[5] WBI[5] WT[5] WTI[5] mm19a04_u_hs1prf_sacm4x1_wa_128
X_mm19a04_u_hs1prf_sacm4x1_wa_128_S6 VDDA VDDP[6] VDDPI[6] VSS[6] VSS_WA[6]
+   VBP[6] VBN[6] LOG1[6] LQB[6] RB[6] RT[6] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RETI WB[6] WBI[6] WT[6] WTI[6] mm19a04_u_hs1prf_sacm4x1_wa_128
X_mm19a04_u_hs1prf_sacm4x1_wa_128_S7 VDDA VDDP[7] VDDPI[7] VSS[7] VSS_WA[7]
+   VBP[7] VBN[7] LOG1[7] LQB[7] RB[7] RT[7] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RETI WB[7] WBI[7] WT[7] WTI[7] mm19a04_u_hs1prf_sacm4x1_wa_128
X_mm19a04_u_hs1prf_sacm4x1_wa_128_S8 VDDA VDDP[8] VDDPI[8] VSS[8] VSS_WA[8]
+   VBP[8] VBN[8] LOG1[8] LQB[8] RB[8] RT[8] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RETI WB[8] WBI[8] WT[8] WTI[8] mm19a04_u_hs1prf_sacm4x1_wa_128
X_mm19a04_u_hs1prf_sacm4x1_wa_128_S9 VDDA VDDP[9] VDDPI[9] VSS[9] VSS_WA[9]
+   VBP[9] VBN[9] LOG1[9] LQB[9] RB[9] RT[9] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RETI WB[9] WBI[9] WT[9] WTI[9] mm19a04_u_hs1prf_sacm4x1_wa_128
X_mm19a04_u_hs1prf_sacm4x1_wa_128_S10 VDDA VDDP[10] VDDPI[10] VSS[10] VSS_WA[10]
+   VBP[10] VBN[10] LOG1[10] LQB[10] RB[10] RT[10] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RETI WB[10] WBI[10] WT[10] WTI[10]
+   mm19a04_u_hs1prf_sacm4x1_wa_128
X_mm19a04_u_hs1prf_sacm4x1_wa_128_S11 VDDA VDDP[11] VDDPI[11] VSS[11] VSS_WA[11]
+   VBP[11] VBN[11] LOG1[11] LQB[11] RB[11] RT[11] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RETI WB[11] WBI[11] WT[11] WTI[11]
+   mm19a04_u_hs1prf_sacm4x1_wa_128
X_mm19a04_u_hs1prf_sacm4x1_wa_128_S12 VDDA VDDP[12] VDDPI[12] VSS[12] VSS_WA[12]
+   VBP[12] VBN[12] LOG1[12] LQB[12] RB[12] RT[12] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RETI WB[12] WBI[12] WT[12] WTI[12]
+   mm19a04_u_hs1prf_sacm4x1_wa_128
X_mm19a04_u_hs1prf_sacm4x1_wa_128_S13 VDDA VDDP[13] VDDPI[13] VSS[13] VSS_WA[13]
+   VBP[13] VBN[13] LOG1[13] LQB[13] RB[13] RT[13] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RETI WB[13] WBI[13] WT[13] WTI[13]
+   mm19a04_u_hs1prf_sacm4x1_wa_128
X_mm19a04_u_hs1prf_sacm4x1_wa_128_F13 VDDA VDDP[14] VDDPI[14] VSS[14] VSS_WA[14]
+   VBP[14] VBN[14] LOG1[14] LQB[14] RB[14] RT[14] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RETI WB[14] WBI[14] WT[14] WTI[14]
+   mm19a04_u_hs1prf_sacm4x1_wa_128
X_mm19a04_u_hs1prf_sacm4x1_wa_128_F12 VDDA VDDP[15] VDDPI[15] VSS[15] VSS_WA[15]
+   VBP[15] VBN[15] LOG1[15] LQB[15] RB[15] RT[15] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RETI WB[15] WBI[15] WT[15] WTI[15]
+   mm19a04_u_hs1prf_sacm4x1_wa_128
X_mm19a04_u_hs1prf_sacm4x1_wa_128_F11 VDDA VDDP[16] VDDPI[16] VSS[16] VSS_WA[16]
+   VBP[16] VBN[16] LOG1[16] LQB[16] RB[16] RT[16] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RETI WB[16] WBI[16] WT[16] WTI[16]
+   mm19a04_u_hs1prf_sacm4x1_wa_128
X_mm19a04_u_hs1prf_sacm4x1_wa_128_F10 VDDA VDDP[17] VDDPI[17] VSS[17] VSS_WA[17]
+   VBP[17] VBN[17] LOG1[17] LQB[17] RB[17] RT[17] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RETI WB[17] WBI[17] WT[17] WTI[17]
+   mm19a04_u_hs1prf_sacm4x1_wa_128
X_mm19a04_u_hs1prf_sacm4x1_wa_128_F9 VDDA VDDP[18] VDDPI[18] VSS[18] VSS_WA[18]
+   VBP[18] VBN[18] LOG1[18] LQB[18] RB[18] RT[18] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RETI WB[18] WBI[18] WT[18] WTI[18]
+   mm19a04_u_hs1prf_sacm4x1_wa_128
X_mm19a04_u_hs1prf_sacm4x1_wa_128_F8 VDDA VDDP[19] VDDPI[19] VSS[19] VSS_WA[19]
+   VBP[19] VBN[19] LOG1[19] LQB[19] RB[19] RT[19] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RETI WB[19] WBI[19] WT[19] WTI[19]
+   mm19a04_u_hs1prf_sacm4x1_wa_128
X_mm19a04_u_hs1prf_sacm4x1_wa_128_F7 VDDA VDDP[20] VDDPI[20] VSS[20] VSS_WA[20]
+   VBP[20] VBN[20] LOG1[20] LQB[20] RB[20] RT[20] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RETI WB[20] WBI[20] WT[20] WTI[20]
+   mm19a04_u_hs1prf_sacm4x1_wa_128
X_mm19a04_u_hs1prf_sacm4x1_wa_128_F6 VDDA VDDP[21] VDDPI[21] VSS[21] VSS_WA[21]
+   VBP[21] VBN[21] LOG1[21] LQB[21] RB[21] RT[21] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RETI WB[21] WBI[21] WT[21] WTI[21]
+   mm19a04_u_hs1prf_sacm4x1_wa_128
X_mm19a04_u_hs1prf_sacm4x1_wa_128_F5 VDDA VDDP[22] VDDPI[22] VSS[22] VSS_WA[22]
+   VBP[22] VBN[22] LOG1[22] LQB[22] RB[22] RT[22] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RETI WB[22] WBI[22] WT[22] WTI[22]
+   mm19a04_u_hs1prf_sacm4x1_wa_128
X_mm19a04_u_hs1prf_sacm4x1_wa_128_F4 VDDA VDDP[23] VDDPI[23] VSS[23] VSS_WA[23]
+   VBP[23] VBN[23] LOG1[23] LQB[23] RB[23] RT[23] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RETI WB[23] WBI[23] WT[23] WTI[23]
+   mm19a04_u_hs1prf_sacm4x1_wa_128
X_mm19a04_u_hs1prf_sacm4x1_wa_128_F3 VDDA VDDP[24] VDDPI[24] VSS[24] VSS_WA[24]
+   VBP[24] VBN[24] LOG1[24] LQB[24] RB[24] RT[24] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RETI WB[24] WBI[24] WT[24] WTI[24]
+   mm19a04_u_hs1prf_sacm4x1_wa_128
X_mm19a04_u_hs1prf_sacm4x1_wa_128_F2 VDDA VDDP[25] VDDPI[25] VSS[25] VSS_WA[25]
+   VBP[25] VBN[25] LOG1[25] LQB[25] RB[25] RT[25] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RETI WB[25] WBI[25] WT[25] WTI[25]
+   mm19a04_u_hs1prf_sacm4x1_wa_128
X_mm19a04_u_hs1prf_sacm4x1_wa_128_F1 VDDA VDDP[26] VDDPI[26] VSS[26] VSS_WA[26]
+   VBP[26] VBN[26] LOG1[26] LQB[26] RB[26] RT[26] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RETI WB[26] WBI[26] WT[26] WTI[26]
+   mm19a04_u_hs1prf_sacm4x1_wa_128
X_mm19a04_u_hs1prf_sacm4x1_wa_128_F0 VDDA VDDP[27] VDDPI[27] VSS[27] VSS_WA[27]
+   VBP[27] VBN[27] LOG1[27] LQB[27] RB[27] RT[27] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RETI WB[27] WBI[27] WT[27] WTI[27]
+   mm19a04_u_hs1prf_sacm4x1_wa_128
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_sac_rt_wa LOG0 LOG1[0] LOG1[1] LOG1[2] LOG1[3]
+       LOG1[4] LOG1[5] LOG1[6] LOG1[7] LOG1[8] LOG1[9] LOG1[10] LOG1[11]
+       LOG1[12] LOG1[13] LOG1[14] LOG1[15] LOG1[16] LOG1[17] LOG1[18] LOG1[19]
+       LOG1[20] LOG1[21] LOG1[22] LOG1[23] LOG1[24] LOG1[25] LOG1[26] LOG1[27]
+       LOG1[28] LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7] LQB[8]
+       LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16] LQB[17]
+       LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25] LQB[26]
+       LQB[27] PWDOR RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8]
+       RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RB[16] RB[17] RB[18]
+       RB[19] RB[20] RB[21] RB[22] RB[23] RB[24] RB[25] RB[26] RB[27] RT[0]
+       RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11]
+       RT[12] RT[13] RT[14] RT[15] RT[16] RT[17] RT[18] RT[19] RT[20] RT[21]
+       RT[22] RT[23] RT[24] RT[25] RT[26] RT[27] VBN[0] VBN[1] VBN[2] VBN[3]
+       VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12]
+       VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20] VBN[21]
+       VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28] VBP[0] VBP[1]
+       VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+       VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20]
+       VBP[21] VBP[22] VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VDDA
+       VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8]
+       VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16]
+       VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24]
+       VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+       VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+       VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17]
+       VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24]
+       VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VEDGE VSS[0] VSS[1] VSS[2]
+       VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+       VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21]
+       VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28] VSS_WA[0]
+       VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7]
+       VSS_WA[8] VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12] VSS_WA[13]
+       VSS_WA[14] VSS_WA[15] VSS_WA[16] VSS_WA[17] VSS_WA[18] VSS_WA[19]
+       VSS_WA[20] VSS_WA[21] VSS_WA[22] VSS_WA[23] VSS_WA[24] VSS_WA[25]
+       VSS_WA[26] VSS_WA[27] WAPRCLKBUF WAPRCLKBUFB_RETI WA_R0 WA_R1 WB[0]
+       WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11]
+       WB[12] WB[13] WB[14] WB[15] WB[16] WB[17] WB[18] WB[19] WB[20] WB[21]
+       WB[22] WB[23] WB[24] WB[25] WB[26] WB[27] WBI[0] WBI[1] WBI[2] WBI[3]
+       WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12]
+       WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21]
+       WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27] WT[0] WT[1] WT[2] WT[3]
+       WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14]
+       WT[15] WT[16] WT[17] WT[18] WT[19] WT[20] WT[21] WT[22] WT[23] WT[24]
+       WT[25] WT[26] WT[27] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+       WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+       WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24]
+       WTI[25] WTI[26] WTI[27]
X_sac_rt_seg1seg_wa LOG1[0] LOG1[1] LOG1[2] LOG1[3] LOG1[4] LOG1[5] LOG1[6]
+   LOG1[7] LOG1[8] LOG1[9] LOG1[10] LOG1[11] LOG1[12] LOG1[13] LOG1[14]
+   LOG1[15] LOG1[16] LOG1[17] LOG1[18] LOG1[19] LOG1[20] LOG1[21] LOG1[22]
+   LOG1[23] LOG1[24] LOG1[25] LOG1[26] LOG1[27] LQB[0] LQB[1] LQB[2] LQB[3]
+   LQB[4] LQB[5] LQB[6] LQB[7] LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13]
+   LQB[14] LQB[15] LQB[16] LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22]
+   LQB[23] LQB[24] LQB[25] LQB[26] LQB[27] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5]
+   RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RB[16]
+   RB[17] RB[18] RB[19] RB[20] RB[21] RB[22] RB[23] RB[24] RB[25] RB[26] RB[27]
+   RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11]
+   RT[12] RT[13] RT[14] RT[15] RT[16] RT[17] RT[18] RT[19] RT[20] RT[21] RT[22]
+   RT[23] RT[24] RT[25] RT[26] RT[27] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5]
+   VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15]
+   VBN[16] VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24]
+   VBN[25] VBN[26] VBN[27] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+   VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+   VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+   VBP[26] VBP[27] VDDA VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6]
+   VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14]
+   VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21] VDDP[22]
+   VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDPI[0] VDDPI[1] VDDPI[2]
+   VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+   VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17]
+   VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24]
+   VDDPI[25] VDDPI[26] VDDPI[27] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+   VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15]
+   VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24]
+   VSS[25] VSS[26] VSS[27] VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4]
+   VSS_WA[5] VSS_WA[6] VSS_WA[7] VSS_WA[8] VSS_WA[9] VSS_WA[10] VSS_WA[11]
+   VSS_WA[12] VSS_WA[13] VSS_WA[14] VSS_WA[15] VSS_WA[16] VSS_WA[17] VSS_WA[18]
+   VSS_WA[19] VSS_WA[20] VSS_WA[21] VSS_WA[22] VSS_WA[23] VSS_WA[24] VSS_WA[25]
+   VSS_WA[26] VSS_WA[27] WA_R0 WA_R1 WAPRCLKBUF WAPRCLKBUFB_RETI WB[0] WB[1]
+   WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13]
+   WB[14] WB[15] WB[16] WB[17] WB[18] WB[19] WB[20] WB[21] WB[22] WB[23] WB[24]
+   WB[25] WB[26] WB[27] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7]
+   WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16]
+   WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25]
+   WBI[26] WBI[27] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9]
+   WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WT[16] WT[17] WT[18] WT[19] WT[20]
+   WT[21] WT[22] WT[23] WT[24] WT[25] WT[26] WT[27] WTI[0] WTI[1] WTI[2] WTI[3]
+   WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13]
+   WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22]
+   WTI[23] WTI[24] WTI[25] WTI[26] WTI[27]
+   SNPS_RF_SP_UHS_256x28_sac_rt_seg1seg_wa
X_mm19a04_u_hs1prf_capsac_wa VDDA VDDP[28] VDDPI[28] VSS[28] VBP[28] VBN[28]
+   LOG0 LOG1[28] PWDOR VEDGE WAPRCLKBUF WAPRCLKBUFB_RETI
+   mm19a04_u_hs1prf_capsac_wa
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_sac_wa_row_t ARYSDR ARYSD_BC1 ARYSD_BC2 BYP_VLOAD
+       CENDP DEF_MODE DLYPDB DLYPW ENLPGB_R FAST1_MODE FAST2_MODE FLOAT FLOATT
+       FLOAT_RET LBKADR LCGTH LCGTHB LCGTHB_PCHG LDFTX LITESLP LOG0[0] LOG0[1]
+       LOG1[0] LOG1[1] LOG1[2] LOG1[3] LOG1[4] LOG1[5] LOG1[6] LOG1[7] LOG1[8]
+       LOG1[9] LOG1[10] LOG1[11] LOG1[12] LOG1[13] LOG1[14] LOG1[15] LOG1[16]
+       LOG1[17] LOG1[18] LOG1[19] LOG1[20] LOG1[21] LOG1[22] LOG1[23] LOG1[24]
+       LOG1[25] LOG1[26] LOG1[27] LOG1[28] LOG1[29] LQB[0] LQB[1] LQB[2] LQB[3]
+       LQB[4] LQB[5] LQB[6] LQB[7] LQB[8] LQB[9] LQB[10] LQB[11] LQB[12]
+       LQB[13] LQB[14] LQB[15] LQB[16] LQB[17] LQB[18] LQB[19] LQB[20] LQB[21]
+       LQB[22] LQB[23] LQB[24] LQB[25] LQB[26] LQB[27] LWEIB LWERD LWEWR
+       LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+       LYADR[0] LYADR[1] PM[0] PM[1] PM[2] PM[3] PRCKDLY PROCOML PWDOR
+       RASSIST[0] RASSIST[1] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7]
+       RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RB[16] RB[17]
+       RB[18] RB[19] RB[20] RB[21] RB[22] RB[23] RB[24] RB[25] RB[26] RB[27]
+       RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RT[0] RT[1] RT[2]
+       RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13]
+       RT[14] RT[15] RT[16] RT[17] RT[18] RT[19] RT[20] RT[21] RT[22] RT[23]
+       RT[24] RT[25] RT[26] RT[27] RWLB SAEB_INT T1T TAP0 TAP1 TAP2 TAP3
+       TEST_RNMB VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+       VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+       VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+       VBN[27] VBN[28] VBN[29] VBN[30] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4]
+       VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+       VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+       VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VDDA
+       VDDF VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7]
+       VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15]
+       VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23]
+       VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+       VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+       VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+       VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+       VDDPI[30] VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+       VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+       VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+       VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS_WA[0] VSS_WA[1] VSS_WA[2]
+       VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7] VSS_WA[8] VSS_WA[9]
+       VSS_WA[10] VSS_WA[11] VSS_WA[12] VSS_WA[13] VSS_WA[14] VSS_WA[15]
+       VSS_WA[16] VSS_WA[17] VSS_WA[18] VSS_WA[19] VSS_WA[20] VSS_WA[21]
+       VSS_WA[22] VSS_WA[23] VSS_WA[24] VSS_WA[25] VSS_WA[26] VSS_WA[27]
+       WABUF[0] WABUF[1] WABUF[2] WAPRCLK WAPRCLKBUF WAPRCLKBUFB_RETI WA_R0
+       WA_R1 WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10]
+       WB[11] WB[12] WB[13] WB[14] WB[15] WB[16] WB[17] WB[18] WB[19] WB[20]
+       WB[21] WB[22] WB[23] WB[24] WB[25] WB[26] WB[27] WBI[0] WBI[1] WBI[2]
+       WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12]
+       WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21]
+       WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27] WMT[0] WMT[1] WMT[2]
+       WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5]
+       WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WT[16]
+       WT[17] WT[18] WT[19] WT[20] WT[21] WT[22] WT[23] WT[24] WT[25] WT[26]
+       WT[27] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8]
+       WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16] WTI[17]
+       WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25] WTI[26]
+       WTI[27]
X_sac_cnt_wa ARYSDR ARYSD_BC1 ARYSD_BC2 BYP_VLOAD CENDP DEF_MODE DLYPDB DLYPW
+   ENLPGB_R FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR LCGTH LCGTHB
+   LCGTHB_PCHG LDFTX LITESLP LOG0[0] LOG1[0] LWEIB LWERD LWEWR LXADR[0]
+   LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+   LYADR[1] PM[0] PM[1] PM[2] PM[3] PRCKDLY PROCOML RASSIST[0] RASSIST[1] RBLRD
+   RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB SAEB_INT T1T TAP0 TAP1
+   TAP2 TAP3 TEST_RNMB VBN[0] VBN[1] VBP[0] VBP[1] VDDA VDDF VDDP[0] VDDP[1]
+   VDDPI[0] VDDPI[1] VSS[0] VSS[1] WABUF[0] WABUF[1] WABUF[2] WAPRCLK
+   WAPRCLKBUF WAPRCLKBUFB_RETI WA_R0 WA_R1 WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0]
+   WPBUF[1] WPBUF[2] SNPS_RF_SP_UHS_256x28_sac_cnt_wa
X_sac_rt_wa LOG0[1] LOG1[1] LOG1[2] LOG1[3] LOG1[4] LOG1[5] LOG1[6] LOG1[7]
+   LOG1[8] LOG1[9] LOG1[10] LOG1[11] LOG1[12] LOG1[13] LOG1[14] LOG1[15]
+   LOG1[16] LOG1[17] LOG1[18] LOG1[19] LOG1[20] LOG1[21] LOG1[22] LOG1[23]
+   LOG1[24] LOG1[25] LOG1[26] LOG1[27] LOG1[28] LOG1[29] LQB[0] LQB[1] LQB[2]
+   LQB[3] LQB[4] LQB[5] LQB[6] LQB[7] LQB[8] LQB[9] LQB[10] LQB[11] LQB[12]
+   LQB[13] LQB[14] LQB[15] LQB[16] LQB[17] LQB[18] LQB[19] LQB[20] LQB[21]
+   LQB[22] LQB[23] LQB[24] LQB[25] LQB[26] LQB[27] PWDOR RB[0] RB[1] RB[2]
+   RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14]
+   RB[15] RB[16] RB[17] RB[18] RB[19] RB[20] RB[21] RB[22] RB[23] RB[24] RB[25]
+   RB[26] RB[27] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9]
+   RT[10] RT[11] RT[12] RT[13] RT[14] RT[15] RT[16] RT[17] RT[18] RT[19] RT[20]
+   RT[21] RT[22] RT[23] RT[24] RT[25] RT[26] RT[27] VBN[2] VBN[3] VBN[4] VBN[5]
+   VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15]
+   VBN[16] VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24]
+   VBN[25] VBN[26] VBN[27] VBN[28] VBN[29] VBN[30] VBP[2] VBP[3] VBP[4] VBP[5]
+   VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15]
+   VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24]
+   VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VDDA VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21]
+   VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDP[29]
+   VDDP[30] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+   VDDPI[30] VEDGE VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9]
+   VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18]
+   VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27]
+   VSS[28] VSS[29] VSS[30] VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4]
+   VSS_WA[5] VSS_WA[6] VSS_WA[7] VSS_WA[8] VSS_WA[9] VSS_WA[10] VSS_WA[11]
+   VSS_WA[12] VSS_WA[13] VSS_WA[14] VSS_WA[15] VSS_WA[16] VSS_WA[17] VSS_WA[18]
+   VSS_WA[19] VSS_WA[20] VSS_WA[21] VSS_WA[22] VSS_WA[23] VSS_WA[24] VSS_WA[25]
+   VSS_WA[26] VSS_WA[27] WAPRCLKBUF WAPRCLKBUFB_RETI WA_R0 WA_R1 WB[0] WB[1]
+   WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13]
+   WB[14] WB[15] WB[16] WB[17] WB[18] WB[19] WB[20] WB[21] WB[22] WB[23] WB[24]
+   WB[25] WB[26] WB[27] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7]
+   WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16]
+   WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25]
+   WBI[26] WBI[27] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9]
+   WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WT[16] WT[17] WT[18] WT[19] WT[20]
+   WT[21] WT[22] WT[23] WT[24] WT[25] WT[26] WT[27] WTI[0] WTI[1] WTI[2] WTI[3]
+   WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13]
+   WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22]
+   WTI[23] WTI[24] WTI[25] WTI[26] WTI[27] SNPS_RF_SP_UHS_256x28_sac_rt_wa
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_sac_wa_row ARYSDR ARYSD_BC1 ARYSD_BC2 BYP_VLOAD
+       CENDP DEF_MODE DLYPDB DLYPW ENLPGB_R FAST1_MODE FAST2_MODE FLOAT FLOATT
+       FLOAT_RET LBKADR LCGTH LCGTHB LCGTHB_PCHG LDFTX LITESLP LOG0 LOG1 LQB[0]
+       LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7] LQB[8] LQB[9] LQB[10]
+       LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16] LQB[17] LQB[18] LQB[19]
+       LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25] LQB[26] LQB[27] LWEIB
+       LWERD LWEWR LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+       LXADR[6] LXADR[7] LYADR[0] LYADR[1] PM[0] PM[1] PM[2] PM[3] PRCKDLY
+       PROCOML PWDOR RASSIST[0] RASSIST[1] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5]
+       RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RB[16]
+       RB[17] RB[18] RB[19] RB[20] RB[21] RB[22] RB[23] RB[24] RB[25] RB[26]
+       RB[27] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RT[0] RT[1]
+       RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12]
+       RT[13] RT[14] RT[15] RT[16] RT[17] RT[18] RT[19] RT[20] RT[21] RT[22]
+       RT[23] RT[24] RT[25] RT[26] RT[27] RWLB SAEB_INT T1T TAP0 TAP1 TAP2 TAP3
+       TEST_RNMB VBN VBP VDDA VDDF VDDP VDDPI VEDGE VSS VSS_WA[0] VSS_WA[1]
+       VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7] VSS_WA[8]
+       VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12] VSS_WA[13] VSS_WA[14]
+       VSS_WA[15] VSS_WA[16] VSS_WA[17] VSS_WA[18] VSS_WA[19] VSS_WA[20]
+       VSS_WA[21] VSS_WA[22] VSS_WA[23] VSS_WA[24] VSS_WA[25] VSS_WA[26]
+       VSS_WA[27] WABUF[0] WABUF[1] WABUF[2] WAPRCLK WAPRCLKBUF
+       WAPRCLKBUFB_RETI WA_R0 WA_R1 WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6]
+       WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WB[16]
+       WB[17] WB[18] WB[19] WB[20] WB[21] WB[22] WB[23] WB[24] WB[25] WB[26]
+       WB[27] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8]
+       WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17]
+       WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26]
+       WBI[27] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT[0]
+       WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11]
+       WT[12] WT[13] WT[14] WT[15] WT[16] WT[17] WT[18] WT[19] WT[20] WT[21]
+       WT[22] WT[23] WT[24] WT[25] WT[26] WT[27] WTI[0] WTI[1] WTI[2] WTI[3]
+       WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12]
+       WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21]
+       WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27]
X_sac_wa_row_t ARYSDR ARYSD_BC1 ARYSD_BC2 BYP_VLOAD CENDP DEF_MODE DLYPDB DLYPW
+   ENLPGB_R FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR LCGTH LCGTHB
+   LCGTHB_PCHG LDFTX LITESLP LOG0 LOG0 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1
+   LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1
+   LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5]
+   LQB[6] LQB[7] LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15]
+   LQB[16] LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24]
+   LQB[25] LQB[26] LQB[27] LWEIB LWERD LWEWR LXADR[0] LXADR[1] LXADR[2]
+   LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PM[0] PM[1]
+   PM[2] PM[3] PRCKDLY PROCOML PWDOR RASSIST[0] RASSIST[1] RB[0] RB[1] RB[2]
+   RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14]
+   RB[15] RB[16] RB[17] RB[18] RB[19] RB[20] RB[21] RB[22] RB[23] RB[24] RB[25]
+   RB[26] RB[27] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RT[0]
+   RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12]
+   RT[13] RT[14] RT[15] RT[16] RT[17] RT[18] RT[19] RT[20] RT[21] RT[22] RT[23]
+   RT[24] RT[25] RT[26] RT[27] RWLB SAEB_INT T1T TAP0 TAP1 TAP2 TAP3 TEST_RNMB
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VDDA VDDF VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VEDGE VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS_WA[0] VSS_WA[1]
+   VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7] VSS_WA[8]
+   VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12] VSS_WA[13] VSS_WA[14] VSS_WA[15]
+   VSS_WA[16] VSS_WA[17] VSS_WA[18] VSS_WA[19] VSS_WA[20] VSS_WA[21] VSS_WA[22]
+   VSS_WA[23] VSS_WA[24] VSS_WA[25] VSS_WA[26] VSS_WA[27] WABUF[0] WABUF[1]
+   WABUF[2] WAPRCLK WAPRCLKBUF WAPRCLKBUFB_RETI WA_R0 WA_R1 WB[0] WB[1] WB[2]
+   WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14]
+   WB[15] WB[16] WB[17] WB[18] WB[19] WB[20] WB[21] WB[22] WB[23] WB[24] WB[25]
+   WB[26] WB[27] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8]
+   WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17]
+   WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26]
+   WBI[27] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT[0] WT[1]
+   WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13]
+   WT[14] WT[15] WT[16] WT[17] WT[18] WT[19] WT[20] WT[21] WT[22] WT[23] WT[24]
+   WT[25] WT[26] WT[27] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16]
+   WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25]
+   WTI[26] WTI[27] SNPS_RF_SP_UHS_256x28_sac_wa_row_t
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_sac_cnt ARYSDR ARYSD_BC1 ARYSD_BC2 BYPASS[1]
+       BYP_VLOAD CENDP CKGATE DEF_MODE DLYPDB DLYPW ENLPGB_R FAST1_MODE
+       FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR LCGTH LCGTHB LCGTHB_PCHG LDFTX
+       LITESLP LOG0 LOG1 LWEIB LWERD LWEWR LXADR[0] LXADR[1] LXADR[2] LXADR[3]
+       LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] LYADRB PLYADR
+       PLYADRB PM[0] PM[1] PM[2] PM[3] PRCLKB PROCOML RASSIST[0] RASSIST[1]
+       RASSISTT_R0 RASSISTT_R1 RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2]
+       RMT[3] RWLB SAEB SAEB_INT SAED SAPR T1T TEST_RNMB VBN[0] VBN[1] VBP[0]
+       VBP[1] VDDA[0] VDDA[1] VDDF VDDP[0] VDDP[1] VDDPI[0] VDDPI[1] VSS[0]
+       VSS[1] WABUF[0] WABUF[1] WABUF[2] WAPRCLKBUFB_RETI WMT[0] WMT[1] WMT[2]
+       WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]

*** Jumper Report ***
* Jumper: CKGATE VSS[0]
* Jumper: DEFAULT_DLY1 DEFAULT_IN DLY_FT1
* Jumper: ENLPGB_R LDFTX LOG0
* Jumper: FLOAT_T1_B FLOAT_T1_B_2
* Jumper: LCGTHB LCGTHB_DR0
* Jumper: LYADR[1] PLYADR
* Jumper: LYADRB PLYADRB
* Jumper: RWLB RWLBHV RWLBLV RWLB_IN RWLB_INT
* Jumper: VDDA[0] VDDP[0] VDDPI[0]
* Jumper: VDDA[1] VDDP[1] VDDPI[1]

*X_mm19a04_u_sac_cm4_edge_cd0 mm19a04_u_sac_cm4_edge_cd0
X_mm19a04_u_hs1prf_sactrl VDDA[0] VDDF VDDP[0] VDDPI[0] VSS[0] VBP[0] VBN[0]
+   LCGTHB LCGTHB LCGTHB_PCHG LCGTHLV LWERD LWEWR LYADRB PM[0] PM[1] PM[2] PM[3]
+   PRCLKB RWLB SAET SAETHV SAPRT BYPASS[0] BYP_VLOAD DEFAULT_DLY1 DEFAULT_DLY2
+   DEFAULT_DLY1 DEF_MODE DEFAULT_DLY1 DLY_FT1_INT FAST1_MODE FAST2_MODE FLOAT
+   FLOAT_RET FLOAT_T1_B FLOAT_T1_B FLOAT_T1_B_3 LBKADR LCGTB LOG0 LOG1 RBLRD
+   RBLWA RBLWR RMT[0] RMT[1] RMT[2] RMT[3] RWLB RWLB RWLB RWLB_OUT T1T
+   TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WAPRCLKBUFB_RETI WMT[0] WMT[1] WMT[2]
+   WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] CENDP CKGATE DLYPW ENLPGB_R FLOATT LDFTX
+   LITESLP LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6]
+   LXADR[7] LYADR[0] LYADR[1] PLYADR PLYADRB RM3CNT RWLB SAED
+   mm19a04_u_hs1prf_sactrl
X_mm19a04_u_hs1prf_sacbuf VDDA[1] VDDP[1] VDDPI[1] VSS[1] VBP[1] VBN[1] LCGTH
+   SAEB SAPR ARYSDR ARYSD_BC1 ARYSD_BC2 BYPASS[1] DLYPDB PROCOML RASSIST[0]
+   RASSIST[1] RASSISTT_R0 RASSISTT_R1 SAEB_INT SAED LCGTHB SAET SAPRT
+   mm19a04_u_hs1prf_sacbuf
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_sac_rt_seg1seg BADB[0] BADB[1] BADB[2] BADB[3]
+       BADB[4] BADB[5] BADB[6] BADB[7] BADB[8] BADB[9] BADB[10] BADB[11]
+       BADB[12] BADB[13] BADB[14] BADB[15] BADB[16] BADB[17] BADB[18] BADB[19]
+       BADB[20] BADB[21] BADB[22] BADB[23] BADB[24] BADB[25] BADB[26] BADB[27]
+       BYPASS LCGTH LOG1[0] LOG1[1] LOG1[2] LOG1[3] LOG1[4] LOG1[5] LOG1[6]
+       LOG1[7] LOG1[8] LOG1[9] LOG1[10] LOG1[11] LOG1[12] LOG1[13] LOG1[14]
+       LOG1[15] LOG1[16] LOG1[17] LOG1[18] LOG1[19] LOG1[20] LOG1[21] LOG1[22]
+       LOG1[23] LOG1[24] LOG1[25] LOG1[26] LOG1[27] LQB[0] LQB[1] LQB[2] LQB[3]
+       LQB[4] LQB[5] LQB[6] LQB[7] LQB[8] LQB[9] LQB[10] LQB[11] LQB[12]
+       LQB[13] LQB[14] LQB[15] LQB[16] LQB[17] LQB[18] LQB[19] LQB[20] LQB[21]
+       LQB[22] LQB[23] LQB[24] LQB[25] LQB[26] LQB[27] RASSISTT[0] RASSISTT[1]
+       RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10]
+       RB[11] RB[12] RB[13] RB[14] RB[15] RB[16] RB[17] RB[18] RB[19] RB[20]
+       RB[21] RB[22] RB[23] RB[24] RB[25] RB[26] RB[27] RT[0] RT[1] RT[2] RT[3]
+       RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14]
+       RT[15] RT[16] RT[17] RT[18] RT[19] RT[20] RT[21] RT[22] RT[23] RT[24]
+       RT[25] RT[26] RT[27] SAEB SAED SAPRB VBN[0] VBN[1] VBN[2] VBN[3] VBN[4]
+       VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13]
+       VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22]
+       VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBP[0] VBP[1] VBP[2] VBP[3]
+       VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+       VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21]
+       VBP[22] VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VDDA VDDP[0] VDDP[1]
+       VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+       VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+       VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+       VDDP[27] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6]
+       VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13]
+       VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20]
+       VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27]
+       VGND[0] VGND[1] VGND[2] VGND[3] VGND[4] VGND[5] VGND[6] VGND[7] VGND[8]
+       VGND[9] VGND[10] VGND[11] VGND[12] VGND[13] VGND[14] VGND[15] VGND[16]
+       VGND[17] VGND[18] VGND[19] VGND[20] VGND[21] VGND[22] VGND[23] VGND[24]
+       VGND[25] VGND[26] VGND[27] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+       VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14]
+       VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23]
+       VSS[24] VSS[25] VSS[26] VSS[27] VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3]
+       VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7] VSS_WA[8] VSS_WA[9] VSS_WA[10]
+       VSS_WA[11] VSS_WA[12] VSS_WA[13] VSS_WA[14] VSS_WA[15] VSS_WA[16]
+       VSS_WA[17] VSS_WA[18] VSS_WA[19] VSS_WA[20] VSS_WA[21] VSS_WA[22]
+       VSS_WA[23] VSS_WA[24] VSS_WA[25] VSS_WA[26] VSS_WA[27] WB[0] WB[1] WB[2]
+       WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13]
+       WB[14] WB[15] WB[16] WB[17] WB[18] WB[19] WB[20] WB[21] WB[22] WB[23]
+       WB[24] WB[25] WB[26] WB[27] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+       WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14]
+       WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23]
+       WBI[24] WBI[25] WBI[26] WBI[27] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5]
+       WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WT[16]
+       WT[17] WT[18] WT[19] WT[20] WT[21] WT[22] WT[23] WT[24] WT[25] WT[26]
+       WT[27] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8]
+       WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16] WTI[17]
+       WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25] WTI[26]
+       WTI[27]

*** Jumper Report ***
* Jumper: VDDP[0] VDDPI[0]
* Jumper: VDDP[1] VDDPI[1]
* Jumper: VDDP[2] VDDPI[2]
* Jumper: VDDP[3] VDDPI[3]
* Jumper: VDDP[4] VDDPI[4]
* Jumper: VDDP[5] VDDPI[5]
* Jumper: VDDP[6] VDDPI[6]
* Jumper: VDDP[7] VDDPI[7]
* Jumper: VDDP[8] VDDPI[8]
* Jumper: VDDP[9] VDDPI[9]
* Jumper: VDDP[10] VDDPI[10]
* Jumper: VDDP[11] VDDPI[11]
* Jumper: VDDP[12] VDDPI[12]
* Jumper: VDDP[13] VDDPI[13]
* Jumper: VDDP[14] VDDPI[14]
* Jumper: VDDP[15] VDDPI[15]
* Jumper: VDDP[16] VDDPI[16]
* Jumper: VDDP[17] VDDPI[17]
* Jumper: VDDP[18] VDDPI[18]
* Jumper: VDDP[19] VDDPI[19]
* Jumper: VDDP[20] VDDPI[20]
* Jumper: VDDP[21] VDDPI[21]
* Jumper: VDDP[22] VDDPI[22]
* Jumper: VDDP[23] VDDPI[23]
* Jumper: VDDP[24] VDDPI[24]
* Jumper: VDDP[25] VDDPI[25]
* Jumper: VDDP[26] VDDPI[26]
* Jumper: VDDP[27] VDDPI[27]
* Jumper: VGND[0] VSS[0]
* Jumper: VGND[1] VSS[1]
* Jumper: VGND[2] VSS[2]
* Jumper: VGND[3] VSS[3]
* Jumper: VGND[4] VSS[4]
* Jumper: VGND[5] VSS[5]
* Jumper: VGND[6] VSS[6]
* Jumper: VGND[7] VSS[7]
* Jumper: VGND[8] VSS[8]
* Jumper: VGND[9] VSS[9]
* Jumper: VGND[10] VSS[10]
* Jumper: VGND[11] VSS[11]
* Jumper: VGND[12] VSS[12]
* Jumper: VGND[13] VSS[13]
* Jumper: VGND[14] VSS[14]
* Jumper: VGND[15] VSS[15]
* Jumper: VGND[16] VSS[16]
* Jumper: VGND[17] VSS[17]
* Jumper: VGND[18] VSS[18]
* Jumper: VGND[19] VSS[19]
* Jumper: VGND[20] VSS[20]
* Jumper: VGND[21] VSS[21]
* Jumper: VGND[22] VSS[22]
* Jumper: VGND[23] VSS[23]
* Jumper: VGND[24] VSS[24]
* Jumper: VGND[25] VSS[25]
* Jumper: VGND[26] VSS[26]
* Jumper: VGND[27] VSS[27]

X_mm19a04_u_hs1prf_sacm4x1_S0 VDDA VDDP[0] VDDPI[0] VSS[0] VSS_WA[0] VBP[0]
+   VBN[0] BYPASS LCGTH LOG1[0] LQB[0] RASSISTT[0] RASSISTT[1] RB[0] RT[0] SAED
+   VGND[0] WB[0] WBI[0] WT[0] WTI[0] BADB[0] SAEB SAPRB
+   mm19a04_u_hs1prf_sacm4x1
X_mm19a04_u_hs1prf_sacm4x1_S1 VDDA VDDP[1] VDDPI[1] VSS[1] VSS_WA[1] VBP[1]
+   VBN[1] BYPASS LCGTH LOG1[1] LQB[1] RASSISTT[0] RASSISTT[1] RB[1] RT[1] SAED
+   VGND[1] WB[1] WBI[1] WT[1] WTI[1] BADB[1] SAEB SAPRB
+   mm19a04_u_hs1prf_sacm4x1
X_mm19a04_u_hs1prf_sacm4x1_S2 VDDA VDDP[2] VDDPI[2] VSS[2] VSS_WA[2] VBP[2]
+   VBN[2] BYPASS LCGTH LOG1[2] LQB[2] RASSISTT[0] RASSISTT[1] RB[2] RT[2] SAED
+   VGND[2] WB[2] WBI[2] WT[2] WTI[2] BADB[2] SAEB SAPRB
+   mm19a04_u_hs1prf_sacm4x1
X_mm19a04_u_hs1prf_sacm4x1_S3 VDDA VDDP[3] VDDPI[3] VSS[3] VSS_WA[3] VBP[3]
+   VBN[3] BYPASS LCGTH LOG1[3] LQB[3] RASSISTT[0] RASSISTT[1] RB[3] RT[3] SAED
+   VGND[3] WB[3] WBI[3] WT[3] WTI[3] BADB[3] SAEB SAPRB
+   mm19a04_u_hs1prf_sacm4x1
X_mm19a04_u_hs1prf_sacm4x1_S4 VDDA VDDP[4] VDDPI[4] VSS[4] VSS_WA[4] VBP[4]
+   VBN[4] BYPASS LCGTH LOG1[4] LQB[4] RASSISTT[0] RASSISTT[1] RB[4] RT[4] SAED
+   VGND[4] WB[4] WBI[4] WT[4] WTI[4] BADB[4] SAEB SAPRB
+   mm19a04_u_hs1prf_sacm4x1
X_mm19a04_u_hs1prf_sacm4x1_S5 VDDA VDDP[5] VDDPI[5] VSS[5] VSS_WA[5] VBP[5]
+   VBN[5] BYPASS LCGTH LOG1[5] LQB[5] RASSISTT[0] RASSISTT[1] RB[5] RT[5] SAED
+   VGND[5] WB[5] WBI[5] WT[5] WTI[5] BADB[5] SAEB SAPRB
+   mm19a04_u_hs1prf_sacm4x1
X_mm19a04_u_hs1prf_sacm4x1_S6 VDDA VDDP[6] VDDPI[6] VSS[6] VSS_WA[6] VBP[6]
+   VBN[6] BYPASS LCGTH LOG1[6] LQB[6] RASSISTT[0] RASSISTT[1] RB[6] RT[6] SAED
+   VGND[6] WB[6] WBI[6] WT[6] WTI[6] BADB[6] SAEB SAPRB
+   mm19a04_u_hs1prf_sacm4x1
X_mm19a04_u_hs1prf_sacm4x1_S7 VDDA VDDP[7] VDDPI[7] VSS[7] VSS_WA[7] VBP[7]
+   VBN[7] BYPASS LCGTH LOG1[7] LQB[7] RASSISTT[0] RASSISTT[1] RB[7] RT[7] SAED
+   VGND[7] WB[7] WBI[7] WT[7] WTI[7] BADB[7] SAEB SAPRB
+   mm19a04_u_hs1prf_sacm4x1
X_mm19a04_u_hs1prf_sacm4x1_S8 VDDA VDDP[8] VDDPI[8] VSS[8] VSS_WA[8] VBP[8]
+   VBN[8] BYPASS LCGTH LOG1[8] LQB[8] RASSISTT[0] RASSISTT[1] RB[8] RT[8] SAED
+   VGND[8] WB[8] WBI[8] WT[8] WTI[8] BADB[8] SAEB SAPRB
+   mm19a04_u_hs1prf_sacm4x1
X_mm19a04_u_hs1prf_sacm4x1_S9 VDDA VDDP[9] VDDPI[9] VSS[9] VSS_WA[9] VBP[9]
+   VBN[9] BYPASS LCGTH LOG1[9] LQB[9] RASSISTT[0] RASSISTT[1] RB[9] RT[9] SAED
+   VGND[9] WB[9] WBI[9] WT[9] WTI[9] BADB[9] SAEB SAPRB
+   mm19a04_u_hs1prf_sacm4x1
X_mm19a04_u_hs1prf_sacm4x1_S10 VDDA VDDP[10] VDDPI[10] VSS[10] VSS_WA[10]
+   VBP[10] VBN[10] BYPASS LCGTH LOG1[10] LQB[10] RASSISTT[0] RASSISTT[1] RB[10]
+   RT[10] SAED VGND[10] WB[10] WBI[10] WT[10] WTI[10] BADB[10] SAEB SAPRB
+   mm19a04_u_hs1prf_sacm4x1
X_mm19a04_u_hs1prf_sacm4x1_S11 VDDA VDDP[11] VDDPI[11] VSS[11] VSS_WA[11]
+   VBP[11] VBN[11] BYPASS LCGTH LOG1[11] LQB[11] RASSISTT[0] RASSISTT[1] RB[11]
+   RT[11] SAED VGND[11] WB[11] WBI[11] WT[11] WTI[11] BADB[11] SAEB SAPRB
+   mm19a04_u_hs1prf_sacm4x1
X_mm19a04_u_hs1prf_sacm4x1_S12 VDDA VDDP[12] VDDPI[12] VSS[12] VSS_WA[12]
+   VBP[12] VBN[12] BYPASS LCGTH LOG1[12] LQB[12] RASSISTT[0] RASSISTT[1] RB[12]
+   RT[12] SAED VGND[12] WB[12] WBI[12] WT[12] WTI[12] BADB[12] SAEB SAPRB
+   mm19a04_u_hs1prf_sacm4x1
X_mm19a04_u_hs1prf_sacm4x1_S13 VDDA VDDP[13] VDDPI[13] VSS[13] VSS_WA[13]
+   VBP[13] VBN[13] BYPASS LCGTH LOG1[13] LQB[13] RASSISTT[0] RASSISTT[1] RB[13]
+   RT[13] SAED VGND[13] WB[13] WBI[13] WT[13] WTI[13] BADB[13] SAEB SAPRB
+   mm19a04_u_hs1prf_sacm4x1
X_mm19a04_u_hs1prf_sacm4x1_F13 VDDA VDDP[14] VDDPI[14] VSS[14] VSS_WA[14]
+   VBP[14] VBN[14] BYPASS LCGTH LOG1[14] LQB[14] RASSISTT[0] RASSISTT[1] RB[14]
+   RT[14] SAED VGND[14] WB[14] WBI[14] WT[14] WTI[14] BADB[14] SAEB SAPRB
+   mm19a04_u_hs1prf_sacm4x1
X_mm19a04_u_hs1prf_sacm4x1_F12 VDDA VDDP[15] VDDPI[15] VSS[15] VSS_WA[15]
+   VBP[15] VBN[15] BYPASS LCGTH LOG1[15] LQB[15] RASSISTT[0] RASSISTT[1] RB[15]
+   RT[15] SAED VGND[15] WB[15] WBI[15] WT[15] WTI[15] BADB[15] SAEB SAPRB
+   mm19a04_u_hs1prf_sacm4x1
X_mm19a04_u_hs1prf_sacm4x1_F11 VDDA VDDP[16] VDDPI[16] VSS[16] VSS_WA[16]
+   VBP[16] VBN[16] BYPASS LCGTH LOG1[16] LQB[16] RASSISTT[0] RASSISTT[1] RB[16]
+   RT[16] SAED VGND[16] WB[16] WBI[16] WT[16] WTI[16] BADB[16] SAEB SAPRB
+   mm19a04_u_hs1prf_sacm4x1
X_mm19a04_u_hs1prf_sacm4x1_F10 VDDA VDDP[17] VDDPI[17] VSS[17] VSS_WA[17]
+   VBP[17] VBN[17] BYPASS LCGTH LOG1[17] LQB[17] RASSISTT[0] RASSISTT[1] RB[17]
+   RT[17] SAED VGND[17] WB[17] WBI[17] WT[17] WTI[17] BADB[17] SAEB SAPRB
+   mm19a04_u_hs1prf_sacm4x1
X_mm19a04_u_hs1prf_sacm4x1_F9 VDDA VDDP[18] VDDPI[18] VSS[18] VSS_WA[18] VBP[18]
+   VBN[18] BYPASS LCGTH LOG1[18] LQB[18] RASSISTT[0] RASSISTT[1] RB[18] RT[18]
+   SAED VGND[18] WB[18] WBI[18] WT[18] WTI[18] BADB[18] SAEB SAPRB
+   mm19a04_u_hs1prf_sacm4x1
X_mm19a04_u_hs1prf_sacm4x1_F8 VDDA VDDP[19] VDDPI[19] VSS[19] VSS_WA[19] VBP[19]
+   VBN[19] BYPASS LCGTH LOG1[19] LQB[19] RASSISTT[0] RASSISTT[1] RB[19] RT[19]
+   SAED VGND[19] WB[19] WBI[19] WT[19] WTI[19] BADB[19] SAEB SAPRB
+   mm19a04_u_hs1prf_sacm4x1
X_mm19a04_u_hs1prf_sacm4x1_F7 VDDA VDDP[20] VDDPI[20] VSS[20] VSS_WA[20] VBP[20]
+   VBN[20] BYPASS LCGTH LOG1[20] LQB[20] RASSISTT[0] RASSISTT[1] RB[20] RT[20]
+   SAED VGND[20] WB[20] WBI[20] WT[20] WTI[20] BADB[20] SAEB SAPRB
+   mm19a04_u_hs1prf_sacm4x1
X_mm19a04_u_hs1prf_sacm4x1_F6 VDDA VDDP[21] VDDPI[21] VSS[21] VSS_WA[21] VBP[21]
+   VBN[21] BYPASS LCGTH LOG1[21] LQB[21] RASSISTT[0] RASSISTT[1] RB[21] RT[21]
+   SAED VGND[21] WB[21] WBI[21] WT[21] WTI[21] BADB[21] SAEB SAPRB
+   mm19a04_u_hs1prf_sacm4x1
X_mm19a04_u_hs1prf_sacm4x1_F5 VDDA VDDP[22] VDDPI[22] VSS[22] VSS_WA[22] VBP[22]
+   VBN[22] BYPASS LCGTH LOG1[22] LQB[22] RASSISTT[0] RASSISTT[1] RB[22] RT[22]
+   SAED VGND[22] WB[22] WBI[22] WT[22] WTI[22] BADB[22] SAEB SAPRB
+   mm19a04_u_hs1prf_sacm4x1
X_mm19a04_u_hs1prf_sacm4x1_F4 VDDA VDDP[23] VDDPI[23] VSS[23] VSS_WA[23] VBP[23]
+   VBN[23] BYPASS LCGTH LOG1[23] LQB[23] RASSISTT[0] RASSISTT[1] RB[23] RT[23]
+   SAED VGND[23] WB[23] WBI[23] WT[23] WTI[23] BADB[23] SAEB SAPRB
+   mm19a04_u_hs1prf_sacm4x1
X_mm19a04_u_hs1prf_sacm4x1_F3 VDDA VDDP[24] VDDPI[24] VSS[24] VSS_WA[24] VBP[24]
+   VBN[24] BYPASS LCGTH LOG1[24] LQB[24] RASSISTT[0] RASSISTT[1] RB[24] RT[24]
+   SAED VGND[24] WB[24] WBI[24] WT[24] WTI[24] BADB[24] SAEB SAPRB
+   mm19a04_u_hs1prf_sacm4x1
X_mm19a04_u_hs1prf_sacm4x1_F2 VDDA VDDP[25] VDDPI[25] VSS[25] VSS_WA[25] VBP[25]
+   VBN[25] BYPASS LCGTH LOG1[25] LQB[25] RASSISTT[0] RASSISTT[1] RB[25] RT[25]
+   SAED VGND[25] WB[25] WBI[25] WT[25] WTI[25] BADB[25] SAEB SAPRB
+   mm19a04_u_hs1prf_sacm4x1
X_mm19a04_u_hs1prf_sacm4x1_F1 VDDA VDDP[26] VDDPI[26] VSS[26] VSS_WA[26] VBP[26]
+   VBN[26] BYPASS LCGTH LOG1[26] LQB[26] RASSISTT[0] RASSISTT[1] RB[26] RT[26]
+   SAED VGND[26] WB[26] WBI[26] WT[26] WTI[26] BADB[26] SAEB SAPRB
+   mm19a04_u_hs1prf_sacm4x1
X_mm19a04_u_hs1prf_sacm4x1_F0 VDDA VDDP[27] VDDPI[27] VSS[27] VSS_WA[27] VBP[27]
+   VBN[27] BYPASS LCGTH LOG1[27] LQB[27] RASSISTT[0] RASSISTT[1] RB[27] RT[27]
+   SAED VGND[27] WB[27] WBI[27] WT[27] WTI[27] BADB[27] SAEB SAPRB
+   mm19a04_u_hs1prf_sacm4x1
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_sac_rt BADB[0] BADB[1] BADB[2] BADB[3] BADB[4]
+       BADB[5] BADB[6] BADB[7] BADB[8] BADB[9] BADB[10] BADB[11] BADB[12]
+       BADB[13] BADB[14] BADB[15] BADB[16] BADB[17] BADB[18] BADB[19] BADB[20]
+       BADB[21] BADB[22] BADB[23] BADB[24] BADB[25] BADB[26] BADB[27] BYPASS
+       LCGTH LOG0 LOG1[0] LOG1[1] LOG1[2] LOG1[3] LOG1[4] LOG1[5] LOG1[6]
+       LOG1[7] LOG1[8] LOG1[9] LOG1[10] LOG1[11] LOG1[12] LOG1[13] LOG1[14]
+       LOG1[15] LOG1[16] LOG1[17] LOG1[18] LOG1[19] LOG1[20] LOG1[21] LOG1[22]
+       LOG1[23] LOG1[24] LOG1[25] LOG1[26] LOG1[27] LOG1[28] LQB[0] LQB[1]
+       LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7] LQB[8] LQB[9] LQB[10] LQB[11]
+       LQB[12] LQB[13] LQB[14] LQB[15] LQB[16] LQB[17] LQB[18] LQB[19] LQB[20]
+       LQB[21] LQB[22] LQB[23] LQB[24] LQB[25] LQB[26] LQB[27] PWDOR
+       RASSISTT[0] RASSISTT[1] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7]
+       RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RB[16] RB[17]
+       RB[18] RB[19] RB[20] RB[21] RB[22] RB[23] RB[24] RB[25] RB[26] RB[27]
+       RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10]
+       RT[11] RT[12] RT[13] RT[14] RT[15] RT[16] RT[17] RT[18] RT[19] RT[20]
+       RT[21] RT[22] RT[23] RT[24] RT[25] RT[26] RT[27] SAEB SAED SAPRB VBN[0]
+       VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10]
+       VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19]
+       VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28]
+       VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9]
+       VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18]
+       VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25] VBP[26] VBP[27]
+       VBP[28] VDDA VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6]
+       VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14]
+       VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21] VDDP[22]
+       VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDPI[0] VDDPI[1]
+       VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9]
+       VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16]
+       VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23]
+       VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VEDGE VGND[0] VGND[1]
+       VGND[2] VGND[3] VGND[4] VGND[5] VGND[6] VGND[7] VGND[8] VGND[9] VGND[10]
+       VGND[11] VGND[12] VGND[13] VGND[14] VGND[15] VGND[16] VGND[17] VGND[18]
+       VGND[19] VGND[20] VGND[21] VGND[22] VGND[23] VGND[24] VGND[25] VGND[26]
+       VGND[27] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+       VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17]
+       VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26]
+       VSS[27] VSS[28] VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4]
+       VSS_WA[5] VSS_WA[6] VSS_WA[7] VSS_WA[8] VSS_WA[9] VSS_WA[10] VSS_WA[11]
+       VSS_WA[12] VSS_WA[13] VSS_WA[14] VSS_WA[15] VSS_WA[16] VSS_WA[17]
+       VSS_WA[18] VSS_WA[19] VSS_WA[20] VSS_WA[21] VSS_WA[22] VSS_WA[23]
+       VSS_WA[24] VSS_WA[25] VSS_WA[26] VSS_WA[27] WB[0] WB[1] WB[2] WB[3]
+       WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14]
+       WB[15] WB[16] WB[17] WB[18] WB[19] WB[20] WB[21] WB[22] WB[23] WB[24]
+       WB[25] WB[26] WB[27] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+       WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+       WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24]
+       WBI[25] WBI[26] WBI[27] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7]
+       WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WT[16] WT[17]
+       WT[18] WT[19] WT[20] WT[21] WT[22] WT[23] WT[24] WT[25] WT[26] WT[27]
+       WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9]
+       WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18]
+       WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27]

*** Jumper Report ***
* Jumper: VDDP[28] VDDPI[28]

X_sac_rt_seg1seg BADB[0] BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7]
+   BADB[8] BADB[9] BADB[10] BADB[11] BADB[12] BADB[13] BADB[14] BADB[15]
+   BADB[16] BADB[17] BADB[18] BADB[19] BADB[20] BADB[21] BADB[22] BADB[23]
+   BADB[24] BADB[25] BADB[26] BADB[27] BYPASS LCGTH LOG1[0] LOG1[1] LOG1[2]
+   LOG1[3] LOG1[4] LOG1[5] LOG1[6] LOG1[7] LOG1[8] LOG1[9] LOG1[10] LOG1[11]
+   LOG1[12] LOG1[13] LOG1[14] LOG1[15] LOG1[16] LOG1[17] LOG1[18] LOG1[19]
+   LOG1[20] LOG1[21] LOG1[22] LOG1[23] LOG1[24] LOG1[25] LOG1[26] LOG1[27]
+   LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7] LQB[8] LQB[9]
+   LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16] LQB[17] LQB[18]
+   LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25] LQB[26] LQB[27]
+   RASSISTT[0] RASSISTT[1] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7]
+   RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RB[16] RB[17] RB[18]
+   RB[19] RB[20] RB[21] RB[22] RB[23] RB[24] RB[25] RB[26] RB[27] RT[0] RT[1]
+   RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13]
+   RT[14] RT[15] RT[16] RT[17] RT[18] RT[19] RT[20] RT[21] RT[22] RT[23] RT[24]
+   RT[25] RT[26] RT[27] SAEB SAED SAPRB VBN[0] VBN[1] VBN[2] VBN[3] VBN[4]
+   VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14]
+   VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23]
+   VBN[24] VBN[25] VBN[26] VBN[27] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5]
+   VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15]
+   VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24]
+   VBP[25] VBP[26] VBP[27] VDDA VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5]
+   VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14]
+   VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21] VDDP[22]
+   VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDPI[0] VDDPI[1] VDDPI[2]
+   VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+   VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17]
+   VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24]
+   VDDPI[25] VDDPI[26] VDDPI[27] VGND[0] VGND[1] VGND[2] VGND[3] VGND[4]
+   VGND[5] VGND[6] VGND[7] VGND[8] VGND[9] VGND[10] VGND[11] VGND[12] VGND[13]
+   VGND[14] VGND[15] VGND[16] VGND[17] VGND[18] VGND[19] VGND[20] VGND[21]
+   VGND[22] VGND[23] VGND[24] VGND[25] VGND[26] VGND[27] VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21]
+   VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS_WA[0] VSS_WA[1]
+   VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7] VSS_WA[8]
+   VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12] VSS_WA[13] VSS_WA[14] VSS_WA[15]
+   VSS_WA[16] VSS_WA[17] VSS_WA[18] VSS_WA[19] VSS_WA[20] VSS_WA[21] VSS_WA[22]
+   VSS_WA[23] VSS_WA[24] VSS_WA[25] VSS_WA[26] VSS_WA[27] WB[0] WB[1] WB[2]
+   WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14]
+   WB[15] WB[16] WB[17] WB[18] WB[19] WB[20] WB[21] WB[22] WB[23] WB[24] WB[25]
+   WB[26] WB[27] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8]
+   WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17]
+   WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26]
+   WBI[27] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10]
+   WT[11] WT[12] WT[13] WT[14] WT[15] WT[16] WT[17] WT[18] WT[19] WT[20] WT[21]
+   WT[22] WT[23] WT[24] WT[25] WT[26] WT[27] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4]
+   WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14]
+   WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23]
+   WTI[24] WTI[25] WTI[26] WTI[27] SNPS_RF_SP_UHS_256x28_sac_rt_seg1seg
X_mm19a04_u_hs1prf_capsac VDDA VDDP[28] VDDPI[28] VSS[28] VBP[28] VBN[28] SAED
+   BYPASS LOG0 LOG1[28] PWDOR VEDGE SAEB mm19a04_u_hs1prf_capsac
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_sac_row_t ARYSDR ARYSD_BC1 ARYSD_BC2 BADB[0]
+       BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7] BADB[8] BADB[9]
+       BADB[10] BADB[11] BADB[12] BADB[13] BADB[14] BADB[15] BADB[16] BADB[17]
+       BADB[18] BADB[19] BADB[20] BADB[21] BADB[22] BADB[23] BADB[24] BADB[25]
+       BADB[26] BADB[27] BYP_VLOAD CENDP CKGATE DEF_MODE DLYPDB DLYPW ENLPGB_R
+       FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR LCGTH LCGTHB
+       LCGTHB_PCHG LDFTX LITESLP LOG0[0] LOG0[1] LOG1[0] LOG1[1] LOG1[2]
+       LOG1[3] LOG1[4] LOG1[5] LOG1[6] LOG1[7] LOG1[8] LOG1[9] LOG1[10]
+       LOG1[11] LOG1[12] LOG1[13] LOG1[14] LOG1[15] LOG1[16] LOG1[17] LOG1[18]
+       LOG1[19] LOG1[20] LOG1[21] LOG1[22] LOG1[23] LOG1[24] LOG1[25] LOG1[26]
+       LOG1[27] LOG1[28] LOG1[29] LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5]
+       LQB[6] LQB[7] LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14]
+       LQB[15] LQB[16] LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23]
+       LQB[24] LQB[25] LQB[26] LQB[27] LWEIB LWERD LWEWR LXADR[0] LXADR[1]
+       LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+       LYADRB PLYADR PLYADRB PM[0] PM[1] PM[2] PM[3] PRCLKB PROCOML PWDOR
+       RASSIST[0] RASSIST[1] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7]
+       RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RB[16] RB[17]
+       RB[18] RB[19] RB[20] RB[21] RB[22] RB[23] RB[24] RB[25] RB[26] RB[27]
+       RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RT[0] RT[1] RT[2]
+       RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13]
+       RT[14] RT[15] RT[16] RT[17] RT[18] RT[19] RT[20] RT[21] RT[22] RT[23]
+       RT[24] RT[25] RT[26] RT[27] RWLB T1T TEST_RNMB VBN[0] VBN[1] VBN[2]
+       VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12]
+       VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20] VBN[21]
+       VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28] VBN[29] VBN[30]
+       VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9]
+       VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18]
+       VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25] VBP[26] VBP[27]
+       VBP[28] VBP[29] VBP[30] VDDA[0] VDDA[1] VDDA[2] VDDF VDDP[0] VDDP[1]
+       VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+       VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+       VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+       VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+       VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+       VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17]
+       VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24]
+       VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30] VEDGE
+       VGND[0] VGND[1] VGND[2] VGND[3] VGND[4] VGND[5] VGND[6] VGND[7] VGND[8]
+       VGND[9] VGND[10] VGND[11] VGND[12] VGND[13] VGND[14] VGND[15] VGND[16]
+       VGND[17] VGND[18] VGND[19] VGND[20] VGND[21] VGND[22] VGND[23] VGND[24]
+       VGND[25] VGND[26] VGND[27] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+       VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14]
+       VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23]
+       VSS[24] VSS[25] VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS_WA[0]
+       VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7]
+       VSS_WA[8] VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12] VSS_WA[13]
+       VSS_WA[14] VSS_WA[15] VSS_WA[16] VSS_WA[17] VSS_WA[18] VSS_WA[19]
+       VSS_WA[20] VSS_WA[21] VSS_WA[22] VSS_WA[23] VSS_WA[24] VSS_WA[25]
+       VSS_WA[26] VSS_WA[27] WABUF[0] WABUF[1] WABUF[2] WAPRCLKBUFB_RETI WB[0]
+       WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11]
+       WB[12] WB[13] WB[14] WB[15] WB[16] WB[17] WB[18] WB[19] WB[20] WB[21]
+       WB[22] WB[23] WB[24] WB[25] WB[26] WB[27] WBI[0] WBI[1] WBI[2] WBI[3]
+       WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12]
+       WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21]
+       WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27] WMT[0] WMT[1] WMT[2]
+       WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5]
+       WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WT[16]
+       WT[17] WT[18] WT[19] WT[20] WT[21] WT[22] WT[23] WT[24] WT[25] WT[26]
+       WT[27] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8]
+       WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16] WTI[17]
+       WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25] WTI[26]
+       WTI[27]
X_sac_cnt ARYSDR ARYSD_BC1 ARYSD_BC2 BYPASS BYP_VLOAD CENDP CKGATE DEF_MODE
+   DLYPDB DLYPW ENLPGB_R FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR
+   LCGTH LCGTHB LCGTHB_PCHG LDFTX LITESLP LOG0[0] LOG1[0] LWEIB LWERD LWEWR
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] LYADRB PLYADR PLYADRB PM[0] PM[1] PM[2] PM[3] PRCLKB
+   PROCOML RASSIST[0] RASSIST[1] RASSISTT_R0 RASSISTT_R1 RBLRD RBLWA RBLWR
+   RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB SAEB SAEB_INT SAED SAPR T1T
+   TEST_RNMB VBN[0] VBN[1] VBP[0] VBP[1] VDDA[0] VDDA[1] VDDF VDDP[0] VDDP[1]
+   VDDPI[0] VDDPI[1] VSS[0] VSS[1] WABUF[0] WABUF[1] WABUF[2] WAPRCLKBUFB_RETI
+   WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]
+   SNPS_RF_SP_UHS_256x28_sac_cnt
X_sac_rt BADB[0] BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7] BADB[8]
+   BADB[9] BADB[10] BADB[11] BADB[12] BADB[13] BADB[14] BADB[15] BADB[16]
+   BADB[17] BADB[18] BADB[19] BADB[20] BADB[21] BADB[22] BADB[23] BADB[24]
+   BADB[25] BADB[26] BADB[27] BYPASS LCGTH LOG0[1] LOG1[1] LOG1[2] LOG1[3]
+   LOG1[4] LOG1[5] LOG1[6] LOG1[7] LOG1[8] LOG1[9] LOG1[10] LOG1[11] LOG1[12]
+   LOG1[13] LOG1[14] LOG1[15] LOG1[16] LOG1[17] LOG1[18] LOG1[19] LOG1[20]
+   LOG1[21] LOG1[22] LOG1[23] LOG1[24] LOG1[25] LOG1[26] LOG1[27] LOG1[28]
+   LOG1[29] LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7] LQB[8]
+   LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16] LQB[17]
+   LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25] LQB[26]
+   LQB[27] PWDOR RASSISTT_R0 RASSISTT_R1 RB[0] RB[1] RB[2] RB[3] RB[4] RB[5]
+   RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RB[16]
+   RB[17] RB[18] RB[19] RB[20] RB[21] RB[22] RB[23] RB[24] RB[25] RB[26] RB[27]
+   RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11]
+   RT[12] RT[13] RT[14] RT[15] RT[16] RT[17] RT[18] RT[19] RT[20] RT[21] RT[22]
+   RT[23] RT[24] RT[25] RT[26] RT[27] SAEB SAED SAPR VBN[2] VBN[3] VBN[4]
+   VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14]
+   VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23]
+   VBN[24] VBN[25] VBN[26] VBN[27] VBN[28] VBN[29] VBN[30] VBP[2] VBP[3] VBP[4]
+   VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14]
+   VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23]
+   VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VDDA[2] VDDP[2]
+   VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11]
+   VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19]
+   VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27]
+   VDDP[28] VDDP[29] VDDP[30] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6]
+   VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+   VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21]
+   VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28]
+   VDDPI[29] VDDPI[30] VEDGE VGND[0] VGND[1] VGND[2] VGND[3] VGND[4] VGND[5]
+   VGND[6] VGND[7] VGND[8] VGND[9] VGND[10] VGND[11] VGND[12] VGND[13] VGND[14]
+   VGND[15] VGND[16] VGND[17] VGND[18] VGND[19] VGND[20] VGND[21] VGND[22]
+   VGND[23] VGND[24] VGND[25] VGND[26] VGND[27] VSS[2] VSS[3] VSS[4] VSS[5]
+   VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15]
+   VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24]
+   VSS[25] VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS_WA[0] VSS_WA[1]
+   VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7] VSS_WA[8]
+   VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12] VSS_WA[13] VSS_WA[14] VSS_WA[15]
+   VSS_WA[16] VSS_WA[17] VSS_WA[18] VSS_WA[19] VSS_WA[20] VSS_WA[21] VSS_WA[22]
+   VSS_WA[23] VSS_WA[24] VSS_WA[25] VSS_WA[26] VSS_WA[27] WB[0] WB[1] WB[2]
+   WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14]
+   WB[15] WB[16] WB[17] WB[18] WB[19] WB[20] WB[21] WB[22] WB[23] WB[24] WB[25]
+   WB[26] WB[27] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8]
+   WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17]
+   WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26]
+   WBI[27] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10]
+   WT[11] WT[12] WT[13] WT[14] WT[15] WT[16] WT[17] WT[18] WT[19] WT[20] WT[21]
+   WT[22] WT[23] WT[24] WT[25] WT[26] WT[27] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4]
+   WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14]
+   WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23]
+   WTI[24] WTI[25] WTI[26] WTI[27] SNPS_RF_SP_UHS_256x28_sac_rt
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_sac_row ARYSDR ARYSD_BC1 ARYSD_BC2 BADB[0] BADB[1]
+       BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7] BADB[8] BADB[9] BADB[10]
+       BADB[11] BADB[12] BADB[13] BADB[14] BADB[15] BADB[16] BADB[17] BADB[18]
+       BADB[19] BADB[20] BADB[21] BADB[22] BADB[23] BADB[24] BADB[25] BADB[26]
+       BADB[27] BYP_VLOAD CENDP CKGATE DEF_MODE DLYPDB DLYPW ENLPGB_R
+       FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR LCGTH LCGTHB
+       LCGTHB_PCHG LDFTX LITESLP LOG0 LOG1 LQB[0] LQB[1] LQB[2] LQB[3] LQB[4]
+       LQB[5] LQB[6] LQB[7] LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13]
+       LQB[14] LQB[15] LQB[16] LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22]
+       LQB[23] LQB[24] LQB[25] LQB[26] LQB[27] LWEIB LWERD LWEWR LXADR[0]
+       LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+       LYADR[1] LYADRB PLYADR PLYADRB PM[0] PM[1] PM[2] PM[3] PRCLKB PROCOML
+       PWDOR RASSIST[0] RASSIST[1] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6]
+       RB[7] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RB[16]
+       RB[17] RB[18] RB[19] RB[20] RB[21] RB[22] RB[23] RB[24] RB[25] RB[26]
+       RB[27] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RT[0] RT[1]
+       RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12]
+       RT[13] RT[14] RT[15] RT[16] RT[17] RT[18] RT[19] RT[20] RT[21] RT[22]
+       RT[23] RT[24] RT[25] RT[26] RT[27] RWLB T1T TEST_RNMB VBN VBP VDDA VDDF
+       VDDP VDDPI VEDGE VGND[0] VGND[1] VGND[2] VGND[3] VGND[4] VGND[5] VGND[6]
+       VGND[7] VGND[8] VGND[9] VGND[10] VGND[11] VGND[12] VGND[13] VGND[14]
+       VGND[15] VGND[16] VGND[17] VGND[18] VGND[19] VGND[20] VGND[21] VGND[22]
+       VGND[23] VGND[24] VGND[25] VGND[26] VGND[27] VSS VSS_WA[0] VSS_WA[1]
+       VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7] VSS_WA[8]
+       VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12] VSS_WA[13] VSS_WA[14]
+       VSS_WA[15] VSS_WA[16] VSS_WA[17] VSS_WA[18] VSS_WA[19] VSS_WA[20]
+       VSS_WA[21] VSS_WA[22] VSS_WA[23] VSS_WA[24] VSS_WA[25] VSS_WA[26]
+       VSS_WA[27] WABUF[0] WABUF[1] WABUF[2] WAPRCLKBUFB_RETI WB[0] WB[1] WB[2]
+       WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13]
+       WB[14] WB[15] WB[16] WB[17] WB[18] WB[19] WB[20] WB[21] WB[22] WB[23]
+       WB[24] WB[25] WB[26] WB[27] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+       WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14]
+       WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23]
+       WBI[24] WBI[25] WBI[26] WBI[27] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0]
+       WPBUF[1] WPBUF[2] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8]
+       WT[9] WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WT[16] WT[17] WT[18]
+       WT[19] WT[20] WT[21] WT[22] WT[23] WT[24] WT[25] WT[26] WT[27] WTI[0]
+       WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10]
+       WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19]
+       WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27]
X_sac_row_t ARYSDR ARYSD_BC1 ARYSD_BC2 BADB[0] BADB[1] BADB[2] BADB[3] BADB[4]
+   BADB[5] BADB[6] BADB[7] BADB[8] BADB[9] BADB[10] BADB[11] BADB[12] BADB[13]
+   BADB[14] BADB[15] BADB[16] BADB[17] BADB[18] BADB[19] BADB[20] BADB[21]
+   BADB[22] BADB[23] BADB[24] BADB[25] BADB[26] BADB[27] BYP_VLOAD CENDP CKGATE
+   DEF_MODE DLYPDB DLYPW ENLPGB_R FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET
+   LBKADR LCGTH LCGTHB LCGTHB_PCHG LDFTX LITESLP LOG0 LOG0 LOG1 LOG1 LOG1 LOG1
+   LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1
+   LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LQB[0] LQB[1] LQB[2]
+   LQB[3] LQB[4] LQB[5] LQB[6] LQB[7] LQB[8] LQB[9] LQB[10] LQB[11] LQB[12]
+   LQB[13] LQB[14] LQB[15] LQB[16] LQB[17] LQB[18] LQB[19] LQB[20] LQB[21]
+   LQB[22] LQB[23] LQB[24] LQB[25] LQB[26] LQB[27] LWEIB LWERD LWEWR LXADR[0]
+   LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+   LYADR[1] LYADRB PLYADR PLYADRB PM[0] PM[1] PM[2] PM[3] PRCLKB PROCOML PWDOR
+   RASSIST[0] RASSIST[1] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8]
+   RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RB[16] RB[17] RB[18] RB[19]
+   RB[20] RB[21] RB[22] RB[23] RB[24] RB[25] RB[26] RB[27] RBLRD RBLWA RBLWR
+   RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6]
+   RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15] RT[16] RT[17]
+   RT[18] RT[19] RT[20] RT[21] RT[22] RT[23] RT[24] RT[25] RT[26] RT[27] RWLB
+   T1T TEST_RNMB VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VDDA VDDA VDDA VDDF VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VEDGE VGND[0] VGND[1] VGND[2] VGND[3] VGND[4]
+   VGND[5] VGND[6] VGND[7] VGND[8] VGND[9] VGND[10] VGND[11] VGND[12] VGND[13]
+   VGND[14] VGND[15] VGND[16] VGND[17] VGND[18] VGND[19] VGND[20] VGND[21]
+   VGND[22] VGND[23] VGND[24] VGND[25] VGND[26] VGND[27] VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3]
+   VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7] VSS_WA[8] VSS_WA[9] VSS_WA[10]
+   VSS_WA[11] VSS_WA[12] VSS_WA[13] VSS_WA[14] VSS_WA[15] VSS_WA[16] VSS_WA[17]
+   VSS_WA[18] VSS_WA[19] VSS_WA[20] VSS_WA[21] VSS_WA[22] VSS_WA[23] VSS_WA[24]
+   VSS_WA[25] VSS_WA[26] VSS_WA[27] WABUF[0] WABUF[1] WABUF[2] WAPRCLKBUFB_RETI
+   WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11]
+   WB[12] WB[13] WB[14] WB[15] WB[16] WB[17] WB[18] WB[19] WB[20] WB[21] WB[22]
+   WB[23] WB[24] WB[25] WB[26] WB[27] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24]
+   WBI[25] WBI[26] WBI[27] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10]
+   WT[11] WT[12] WT[13] WT[14] WT[15] WT[16] WT[17] WT[18] WT[19] WT[20] WT[21]
+   WT[22] WT[23] WT[24] WT[25] WT[26] WT[27] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4]
+   WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14]
+   WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23]
+   WTI[24] WTI[25] WTI[26] WTI[27] SNPS_RF_SP_UHS_256x28_sac_row_t
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_mux_cnt ARYSDR ARYSD_BC1 ARYSD_BC2 BYP_VLOAD CENDP
+       CKGATE CKPRCHBR DEF_MODE DLYPDB DRAIN_RIGHT2 FAST1_MODE FAST2_MODE FLOAT
+       FLOATT FLOAT_RET GATE_RIGHT1 GATE_RIGHT2 LBKADR LBKADRB LBKADR_TOP LCGTH
+       LCGTHB_PCHG LDFTX LITESLP LOG0 LOG1 LWEIB LWERD LWEWR LXADR[0] LXADR[1]
+       LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LXADR_TOP[0]
+       LXADR_TOP[1] LXADR_TOP[2] LXADR_TOP[3] LXADR_TOP[4] LXADR_TOP[5]
+       LXADR_TOP[6] LXADR_TOP[7] LYADR[0] LYADR[1] LYADR_TOP[0] LYADR_TOP[1]
+       PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1]
+       PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] PLBKADRB PM[0] PM[1] PM[2]
+       PM[3] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+       PRCHWRB[2] PRCHWRB[3] PROCOML RASSIST[0] RASSIST[1] RASSISTB[0]
+       RASSISTB[1] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB
+       T1T TEST_RNMB VBA VBN[0] VBN[1] VBP[0] VBP[1] VDDA[0] VDDA[1] VDDF
+       VDDP[0] VDDP[1] VDDPI[0] VDDPI[1] VDDWL VDDWL_PCOM VSS VSSWLL VSSWLR
+       WABUF[0] WABUF[1] WABUF[2] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] WMT[0]
+       WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]

*** Jumper Report ***
* Jumper: FLOAT FLOATH
* Jumper: LOG0 PLBKADRB
* Jumper: PRCHWR[0] PRCHWRH[0]
* Jumper: PRCHWR[1] PRCHWRH[1]
* Jumper: PRCHWR[2] PRCHWRH[2]
* Jumper: PRCHWR[3] PRCHWRH[3]
* Jumper: VDDA[0] VDDP[0] VDDPI[0]
* Jumper: VDDA[1] VDDP[1] VDDPI[1]
* Jumper: XPRBH[0] XPRBL[0]
* Jumper: XPRBH[1] XPRBL[1]
* Jumper: XPRBH[2] XPRBL[2]
* Jumper: XPRBH[3] XPRBL[3]

*X_mm19a04_u_lcen_edge_cd0 mm19a04_u_lcen_edge_cd0
X_mm19a04_u_hs1prf_lcen VDDA[0] VDDF VDDP[0] VDDPI[0] VSS VSSWLL VSSWLR VBP[0]
+   VBN[0] CKPRCH PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0]
+   PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] PRCHRD[0] PRCHRD[1]
+   PRCHRD[2] PRCHRD[3] PRCHWR[0] PRCHWR[1] PRCHWR[2] PRCHWR[3] PRCHWR[0]
+   PRCHWR[1] PRCHWR[2] PRCHWR[3] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] BYP_VLOAD
+   CENDP CKGATE DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOAT FLOATT FLOAT_RET
+   LBKADRB LBKADR_TOP LCGTHB LDFTX LITESLP LOG0 LOG1 LWEIB LWERD LWEWR
+   LXADR_TOP[0] LXADR_TOP[1] LXADR_TOP[2] LXADR_TOP[3] LXADR_TOP[4]
+   LXADR_TOP[5] LXADR_TOP[6] LXADR_TOP[7] LYADR_TOP[0] LYADR_TOP[1] RBLRD RBLWA
+   RBLWR RM3CNT RWLB WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3]
+   WPBUF[0] WPBUF[1] WPBUF[2] XPRBH[0] XPRBH[1] XPRBH[2] XPRBH[3] XPRBH[0]
+   XPRBH[1] XPRBH[2] XPRBH[3] LBKADR LCGTHB_PCHG LXADR[0] LXADR[1] LXADR[2]
+   LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PLBKADRB
+   PM[0] PM[1] PM[2] PM[3] RMT[0] RMT[1] RMT[2] RMT[3] T1T TEST_RNMB
+   mm19a04_u_hs1prf_lcen
X_mm19a04_u_hs1prf_lcenbuf VDDA[1] VDDP[1] VDDPI[1] VDDWL VDDWL_PCOM VSS VBP[1]
+   VBN[1] CKPRCHBR PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0]
+   PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] RASSISTB[0] RASSISTB[1] ARYSDR ARYSD_BC1
+   ARYSD_BC2 DLYPDB DRAIN_RIGHT2 GATE_RIGHT1 GATE_RIGHT2 LCGTHB VBA CKPRCH
+   LCGTH LOG0 LOG1 PRCHRD[0] PRCHRD[1] PRCHRD[2] PRCHRD[3] PRCHWR[0] PRCHWR[1]
+   PRCHWR[2] PRCHWR[3] PROCOML RASSIST[0] RASSIST[1] mm19a04_u_hs1prf_lcenbuf
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_cmux BB[0] BB[1] BB[2] BB[3] BT[0] BT[1] BT[2]
+       BT[3] CKPRCHB DRAIN_LEFT1 DRAIN_LEFT2 DRAIN_RIGHT1 DRAIN_RIGHT2
+       GATE_LEFT1 GATE_LEFT2 GATE_RIGHT1 GATE_RIGHT2 LOG0 LOG1[0] LQB
+       PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+       PRCHWRB[2] PRCHWRB[3] RB RT SEL VBA VBN VBP VDDA VDDAI VDDP VDDPI VSS WB
+       WBI WT WTI

*** Jumper Report ***
* Jumper: VDDA VDDP VDDPI

X_mm19a04_u_hs1prf_cmux4x1 VDDA VDDAI VDDP VDDPI VSS VBP VBN BB[0] BB[1] BB[2]
+   BB[3] BT[0] BT[1] BT[2] BT[3] DRAIN_LEFT1 DRAIN_LEFT2 DRAIN_RIGHT1
+   DRAIN_RIGHT2 GATE_LEFT1 GATE_LEFT2 GATE_RIGHT1 GATE_RIGHT2 LOG0 LOG1[0] LQB
+   RB RT VBA WB WBI WT WTI LOG1[1] CKPRCHB PRCHRDB[0] PRCHRDB[1] PRCHRDB[2]
+   PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] SEL
+   mm19a04_u_hs1prf_cmux4x1
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_mux_rt_seg1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5]
+       BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+       BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+       BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+       BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BB[64] BB[65] BB[66]
+       BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75] BB[76]
+       BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83] BB[84] BB[85] BB[86]
+       BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95] BB[96]
+       BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103] BB[104] BB[105]
+       BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BT[0] BT[1] BT[2] BT[3]
+       BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14]
+       BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+       BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34]
+       BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44]
+       BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54]
+       BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64]
+       BT[65] BT[66] BT[67] BT[68] BT[69] BT[70] BT[71] BT[72] BT[73] BT[74]
+       BT[75] BT[76] BT[77] BT[78] BT[79] BT[80] BT[81] BT[82] BT[83] BT[84]
+       BT[85] BT[86] BT[87] BT[88] BT[89] BT[90] BT[91] BT[92] BT[93] BT[94]
+       BT[95] BT[96] BT[97] BT[98] BT[99] BT[100] BT[101] BT[102] BT[103]
+       BT[104] BT[105] BT[106] BT[107] BT[108] BT[109] BT[110] BT[111] CKPRCHB
+       DRAIN_LEFT1[0] DRAIN_LEFT2[0] DRAIN_RIGHT1[27] DRAIN_RIGHT2[27]
+       GATE_LEFT1[0] GATE_LEFT2[0] GATE_RIGHT1[27] GATE_RIGHT2[27] LOG0 LOG1
+       LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7] LQB[8] LQB[9]
+       LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16] LQB[17] LQB[18]
+       LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25] LQB[26] LQB[27]
+       PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+       PRCHWRB[2] PRCHWRB[3] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7]
+       RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RB[16] RB[17]
+       RB[18] RB[19] RB[20] RB[21] RB[22] RB[23] RB[24] RB[25] RB[26] RB[27]
+       RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10]
+       RT[11] RT[12] RT[13] RT[14] RT[15] RT[16] RT[17] RT[18] RT[19] RT[20]
+       RT[21] RT[22] RT[23] RT[24] RT[25] RT[26] RT[27] SEL[0] SEL[1] SEL[2]
+       SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+       SEL[13] SEL[14] SEL[15] SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21]
+       SEL[22] SEL[23] SEL[24] SEL[25] SEL[26] SEL[27] VBA[0] VBA[1] VBA[2]
+       VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12]
+       VBA[13] VBA[14] VBA[15] VBA[16] VBA[17] VBA[18] VBA[19] VBA[20] VBA[21]
+       VBA[22] VBA[23] VBA[24] VBA[25] VBA[26] VBA[27] VBN[0] VBN[1] VBN[2]
+       VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12]
+       VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20] VBN[21]
+       VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBP[0] VBP[1] VBP[2]
+       VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+       VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21]
+       VBP[22] VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VDDA[0] VDDA[1] VDDA[2]
+       VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10]
+       VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17] VDDA[18]
+       VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24] VDDA[25] VDDA[26]
+       VDDA[27] VDDAI[0] VDDAI[1] VDDAI[2] VDDAI[3] VDDAI[4] VDDAI[5] VDDAI[6]
+       VDDAI[7] VDDAI[8] VDDAI[9] VDDAI[10] VDDAI[11] VDDAI[12] VDDAI[13]
+       VDDAI[14] VDDAI[15] VDDAI[16] VDDAI[17] VDDAI[18] VDDAI[19] VDDAI[20]
+       VDDAI[21] VDDAI[22] VDDAI[23] VDDAI[24] VDDAI[25] VDDAI[26] VDDAI[27]
+       VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8]
+       VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16]
+       VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24]
+       VDDP[25] VDDP[26] VDDP[27] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+       VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+       VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18]
+       VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25]
+       VDDPI[26] VDDPI[27] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6]
+       VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15]
+       VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24]
+       VSS[25] VSS[26] VSS[27] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7]
+       WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WB[16] WB[17]
+       WB[18] WB[19] WB[20] WB[21] WB[22] WB[23] WB[24] WB[25] WB[26] WB[27]
+       WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9]
+       WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18]
+       WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27]
+       WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10]
+       WT[11] WT[12] WT[13] WT[14] WT[15] WT[16] WT[17] WT[18] WT[19] WT[20]
+       WT[21] WT[22] WT[23] WT[24] WT[25] WT[26] WT[27] WTI[0] WTI[1] WTI[2]
+       WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12]
+       WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21]
+       WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27]
X_cmux_S0 BB[0] BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3] CKPRCHB DRAIN_LEFT1[0]
+   DRAIN_LEFT2[0] DRAIN_RIGHT1[0] DRAIN_RIGHT2[0] GATE_LEFT1[0] GATE_LEFT2[0]
+   GATE_RIGHT1[0] GATE_RIGHT2[0] LOG0 LOG1 LQB[0] PRCHRDB[0] PRCHRDB[1]
+   PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] RB[0]
+   RT[0] SEL[0] VBA[0] VBN[0] VBP[0] VDDA[0] VDDAI[0] VDDP[0] VDDPI[0] VSS[0]
+   WB[0] WBI[0] WT[0] WTI[0] SNPS_RF_SP_UHS_256x28_cmux
X_cmux_S1 BB[4] BB[5] BB[6] BB[7] BT[4] BT[5] BT[6] BT[7] CKPRCHB DRAIN_LEFT1[1]
+   DRAIN_LEFT2[1] DRAIN_RIGHT1[1] DRAIN_RIGHT2[1] GATE_LEFT1[1] GATE_LEFT2[1]
+   GATE_RIGHT1[1] GATE_RIGHT2[1] LOG0 LOG1 LQB[1] PRCHRDB[0] PRCHRDB[1]
+   PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] RB[1]
+   RT[1] SEL[1] VBA[1] VBN[1] VBP[1] VDDA[1] VDDAI[1] VDDP[1] VDDPI[1] VSS[1]
+   WB[1] WBI[1] WT[1] WTI[1] SNPS_RF_SP_UHS_256x28_cmux
X_cmux_S2 BB[8] BB[9] BB[10] BB[11] BT[8] BT[9] BT[10] BT[11] CKPRCHB
+   DRAIN_LEFT1[2] DRAIN_LEFT2[2] DRAIN_RIGHT1[2] DRAIN_RIGHT2[2] GATE_LEFT1[2]
+   GATE_LEFT2[2] GATE_RIGHT1[2] GATE_RIGHT2[2] LOG0 LOG1 LQB[2] PRCHRDB[0]
+   PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3]
+   RB[2] RT[2] SEL[2] VBA[2] VBN[2] VBP[2] VDDA[2] VDDAI[2] VDDP[2] VDDPI[2]
+   VSS[2] WB[2] WBI[2] WT[2] WTI[2] SNPS_RF_SP_UHS_256x28_cmux
X_cmux_S3 BB[12] BB[13] BB[14] BB[15] BT[12] BT[13] BT[14] BT[15] CKPRCHB
+   DRAIN_LEFT1[3] DRAIN_LEFT2[3] DRAIN_RIGHT1[3] DRAIN_RIGHT2[3] GATE_LEFT1[3]
+   GATE_LEFT2[3] GATE_RIGHT1[3] GATE_RIGHT2[3] LOG0 LOG1 LQB[3] PRCHRDB[0]
+   PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3]
+   RB[3] RT[3] SEL[3] VBA[3] VBN[3] VBP[3] VDDA[3] VDDAI[3] VDDP[3] VDDPI[3]
+   VSS[3] WB[3] WBI[3] WT[3] WTI[3] SNPS_RF_SP_UHS_256x28_cmux
X_cmux_S4 BB[16] BB[17] BB[18] BB[19] BT[16] BT[17] BT[18] BT[19] CKPRCHB
+   DRAIN_LEFT1[4] DRAIN_LEFT2[4] DRAIN_RIGHT1[4] DRAIN_RIGHT2[4] GATE_LEFT1[4]
+   GATE_LEFT2[4] GATE_RIGHT1[4] GATE_RIGHT2[4] LOG0 LOG1 LQB[4] PRCHRDB[0]
+   PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3]
+   RB[4] RT[4] SEL[4] VBA[4] VBN[4] VBP[4] VDDA[4] VDDAI[4] VDDP[4] VDDPI[4]
+   VSS[4] WB[4] WBI[4] WT[4] WTI[4] SNPS_RF_SP_UHS_256x28_cmux
X_cmux_S5 BB[20] BB[21] BB[22] BB[23] BT[20] BT[21] BT[22] BT[23] CKPRCHB
+   DRAIN_LEFT1[5] DRAIN_LEFT2[5] DRAIN_RIGHT1[5] DRAIN_RIGHT2[5] GATE_LEFT1[5]
+   GATE_LEFT2[5] GATE_RIGHT1[5] GATE_RIGHT2[5] LOG0 LOG1 LQB[5] PRCHRDB[0]
+   PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3]
+   RB[5] RT[5] SEL[5] VBA[5] VBN[5] VBP[5] VDDA[5] VDDAI[5] VDDP[5] VDDPI[5]
+   VSS[5] WB[5] WBI[5] WT[5] WTI[5] SNPS_RF_SP_UHS_256x28_cmux
X_cmux_S6 BB[24] BB[25] BB[26] BB[27] BT[24] BT[25] BT[26] BT[27] CKPRCHB
+   DRAIN_LEFT1[6] DRAIN_LEFT2[6] DRAIN_RIGHT1[6] DRAIN_RIGHT2[6] GATE_LEFT1[6]
+   GATE_LEFT2[6] GATE_RIGHT1[6] GATE_RIGHT2[6] LOG0 LOG1 LQB[6] PRCHRDB[0]
+   PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3]
+   RB[6] RT[6] SEL[6] VBA[6] VBN[6] VBP[6] VDDA[6] VDDAI[6] VDDP[6] VDDPI[6]
+   VSS[6] WB[6] WBI[6] WT[6] WTI[6] SNPS_RF_SP_UHS_256x28_cmux
X_cmux_S7 BB[28] BB[29] BB[30] BB[31] BT[28] BT[29] BT[30] BT[31] CKPRCHB
+   DRAIN_LEFT1[7] DRAIN_LEFT2[7] DRAIN_RIGHT1[7] DRAIN_RIGHT2[7] GATE_LEFT1[7]
+   GATE_LEFT2[7] GATE_RIGHT1[7] GATE_RIGHT2[7] LOG0 LOG1 LQB[7] PRCHRDB[0]
+   PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3]
+   RB[7] RT[7] SEL[7] VBA[7] VBN[7] VBP[7] VDDA[7] VDDAI[7] VDDP[7] VDDPI[7]
+   VSS[7] WB[7] WBI[7] WT[7] WTI[7] SNPS_RF_SP_UHS_256x28_cmux
X_cmux_S8 BB[32] BB[33] BB[34] BB[35] BT[32] BT[33] BT[34] BT[35] CKPRCHB
+   DRAIN_LEFT1[8] DRAIN_LEFT2[8] DRAIN_RIGHT1[8] DRAIN_RIGHT2[8] GATE_LEFT1[8]
+   GATE_LEFT2[8] GATE_RIGHT1[8] GATE_RIGHT2[8] LOG0 LOG1 LQB[8] PRCHRDB[0]
+   PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3]
+   RB[8] RT[8] SEL[8] VBA[8] VBN[8] VBP[8] VDDA[8] VDDAI[8] VDDP[8] VDDPI[8]
+   VSS[8] WB[8] WBI[8] WT[8] WTI[8] SNPS_RF_SP_UHS_256x28_cmux
X_cmux_S9 BB[36] BB[37] BB[38] BB[39] BT[36] BT[37] BT[38] BT[39] CKPRCHB
+   DRAIN_LEFT1[9] DRAIN_LEFT2[9] DRAIN_RIGHT1[9] DRAIN_RIGHT2[9] GATE_LEFT1[9]
+   GATE_LEFT2[9] GATE_RIGHT1[9] GATE_RIGHT2[9] LOG0 LOG1 LQB[9] PRCHRDB[0]
+   PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3]
+   RB[9] RT[9] SEL[9] VBA[9] VBN[9] VBP[9] VDDA[9] VDDAI[9] VDDP[9] VDDPI[9]
+   VSS[9] WB[9] WBI[9] WT[9] WTI[9] SNPS_RF_SP_UHS_256x28_cmux
X_cmux_S10 BB[40] BB[41] BB[42] BB[43] BT[40] BT[41] BT[42] BT[43] CKPRCHB
+   DRAIN_LEFT1[10] DRAIN_LEFT2[10] DRAIN_RIGHT1[10] DRAIN_RIGHT2[10]
+   GATE_LEFT1[10] GATE_LEFT2[10] GATE_RIGHT1[10] GATE_RIGHT2[10] LOG0 LOG1
+   LQB[10] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+   PRCHWRB[2] PRCHWRB[3] RB[10] RT[10] SEL[10] VBA[10] VBN[10] VBP[10] VDDA[10]
+   VDDAI[10] VDDP[10] VDDPI[10] VSS[10] WB[10] WBI[10] WT[10] WTI[10]
+   SNPS_RF_SP_UHS_256x28_cmux
X_cmux_S11 BB[44] BB[45] BB[46] BB[47] BT[44] BT[45] BT[46] BT[47] CKPRCHB
+   DRAIN_LEFT1[11] DRAIN_LEFT2[11] DRAIN_RIGHT1[11] DRAIN_RIGHT2[11]
+   GATE_LEFT1[11] GATE_LEFT2[11] GATE_RIGHT1[11] GATE_RIGHT2[11] LOG0 LOG1
+   LQB[11] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+   PRCHWRB[2] PRCHWRB[3] RB[11] RT[11] SEL[11] VBA[11] VBN[11] VBP[11] VDDA[11]
+   VDDAI[11] VDDP[11] VDDPI[11] VSS[11] WB[11] WBI[11] WT[11] WTI[11]
+   SNPS_RF_SP_UHS_256x28_cmux
X_cmux_S12 BB[48] BB[49] BB[50] BB[51] BT[48] BT[49] BT[50] BT[51] CKPRCHB
+   DRAIN_LEFT1[12] DRAIN_LEFT2[12] DRAIN_RIGHT1[12] DRAIN_RIGHT2[12]
+   GATE_LEFT1[12] GATE_LEFT2[12] GATE_RIGHT1[12] GATE_RIGHT2[12] LOG0 LOG1
+   LQB[12] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+   PRCHWRB[2] PRCHWRB[3] RB[12] RT[12] SEL[12] VBA[12] VBN[12] VBP[12] VDDA[12]
+   VDDAI[12] VDDP[12] VDDPI[12] VSS[12] WB[12] WBI[12] WT[12] WTI[12]
+   SNPS_RF_SP_UHS_256x28_cmux
X_cmux_S13 BB[52] BB[53] BB[54] BB[55] BT[52] BT[53] BT[54] BT[55] CKPRCHB
+   DRAIN_LEFT1[13] DRAIN_LEFT2[13] DRAIN_RIGHT1[13] DRAIN_RIGHT2[13]
+   GATE_LEFT1[13] GATE_LEFT2[13] GATE_RIGHT1[13] GATE_RIGHT2[13] LOG0 LOG1
+   LQB[13] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+   PRCHWRB[2] PRCHWRB[3] RB[13] RT[13] SEL[13] VBA[13] VBN[13] VBP[13] VDDA[13]
+   VDDAI[13] VDDP[13] VDDPI[13] VSS[13] WB[13] WBI[13] WT[13] WTI[13]
+   SNPS_RF_SP_UHS_256x28_cmux
X_cmux_F13 BB[56] BB[57] BB[58] BB[59] BT[56] BT[57] BT[58] BT[59] CKPRCHB
+   DRAIN_LEFT1[14] DRAIN_LEFT2[14] DRAIN_RIGHT1[14] DRAIN_RIGHT2[14]
+   GATE_LEFT1[14] GATE_LEFT2[14] GATE_RIGHT1[14] GATE_RIGHT2[14] LOG0 LOG1
+   LQB[14] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+   PRCHWRB[2] PRCHWRB[3] RB[14] RT[14] SEL[14] VBA[14] VBN[14] VBP[14] VDDA[14]
+   VDDAI[14] VDDP[14] VDDPI[14] VSS[14] WB[14] WBI[14] WT[14] WTI[14]
+   SNPS_RF_SP_UHS_256x28_cmux
X_cmux_F12 BB[60] BB[61] BB[62] BB[63] BT[60] BT[61] BT[62] BT[63] CKPRCHB
+   DRAIN_LEFT1[15] DRAIN_LEFT2[15] DRAIN_RIGHT1[15] DRAIN_RIGHT2[15]
+   GATE_LEFT1[15] GATE_LEFT2[15] GATE_RIGHT1[15] GATE_RIGHT2[15] LOG0 LOG1
+   LQB[15] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+   PRCHWRB[2] PRCHWRB[3] RB[15] RT[15] SEL[15] VBA[15] VBN[15] VBP[15] VDDA[15]
+   VDDAI[15] VDDP[15] VDDPI[15] VSS[15] WB[15] WBI[15] WT[15] WTI[15]
+   SNPS_RF_SP_UHS_256x28_cmux
X_cmux_F11 BB[64] BB[65] BB[66] BB[67] BT[64] BT[65] BT[66] BT[67] CKPRCHB
+   DRAIN_LEFT1[16] DRAIN_LEFT2[16] DRAIN_RIGHT1[16] DRAIN_RIGHT2[16]
+   GATE_LEFT1[16] GATE_LEFT2[16] GATE_RIGHT1[16] GATE_RIGHT2[16] LOG0 LOG1
+   LQB[16] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+   PRCHWRB[2] PRCHWRB[3] RB[16] RT[16] SEL[16] VBA[16] VBN[16] VBP[16] VDDA[16]
+   VDDAI[16] VDDP[16] VDDPI[16] VSS[16] WB[16] WBI[16] WT[16] WTI[16]
+   SNPS_RF_SP_UHS_256x28_cmux
X_cmux_F10 BB[68] BB[69] BB[70] BB[71] BT[68] BT[69] BT[70] BT[71] CKPRCHB
+   DRAIN_LEFT1[17] DRAIN_LEFT2[17] DRAIN_RIGHT1[17] DRAIN_RIGHT2[17]
+   GATE_LEFT1[17] GATE_LEFT2[17] GATE_RIGHT1[17] GATE_RIGHT2[17] LOG0 LOG1
+   LQB[17] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+   PRCHWRB[2] PRCHWRB[3] RB[17] RT[17] SEL[17] VBA[17] VBN[17] VBP[17] VDDA[17]
+   VDDAI[17] VDDP[17] VDDPI[17] VSS[17] WB[17] WBI[17] WT[17] WTI[17]
+   SNPS_RF_SP_UHS_256x28_cmux
X_cmux_F9 BB[72] BB[73] BB[74] BB[75] BT[72] BT[73] BT[74] BT[75] CKPRCHB
+   DRAIN_LEFT1[18] DRAIN_LEFT2[18] DRAIN_RIGHT1[18] DRAIN_RIGHT2[18]
+   GATE_LEFT1[18] GATE_LEFT2[18] GATE_RIGHT1[18] GATE_RIGHT2[18] LOG0 LOG1
+   LQB[18] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+   PRCHWRB[2] PRCHWRB[3] RB[18] RT[18] SEL[18] VBA[18] VBN[18] VBP[18] VDDA[18]
+   VDDAI[18] VDDP[18] VDDPI[18] VSS[18] WB[18] WBI[18] WT[18] WTI[18]
+   SNPS_RF_SP_UHS_256x28_cmux
X_cmux_F8 BB[76] BB[77] BB[78] BB[79] BT[76] BT[77] BT[78] BT[79] CKPRCHB
+   DRAIN_LEFT1[19] DRAIN_LEFT2[19] DRAIN_RIGHT1[19] DRAIN_RIGHT2[19]
+   GATE_LEFT1[19] GATE_LEFT2[19] GATE_RIGHT1[19] GATE_RIGHT2[19] LOG0 LOG1
+   LQB[19] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+   PRCHWRB[2] PRCHWRB[3] RB[19] RT[19] SEL[19] VBA[19] VBN[19] VBP[19] VDDA[19]
+   VDDAI[19] VDDP[19] VDDPI[19] VSS[19] WB[19] WBI[19] WT[19] WTI[19]
+   SNPS_RF_SP_UHS_256x28_cmux
X_cmux_F7 BB[80] BB[81] BB[82] BB[83] BT[80] BT[81] BT[82] BT[83] CKPRCHB
+   DRAIN_LEFT1[20] DRAIN_LEFT2[20] DRAIN_RIGHT1[20] DRAIN_RIGHT2[20]
+   GATE_LEFT1[20] GATE_LEFT2[20] GATE_RIGHT1[20] GATE_RIGHT2[20] LOG0 LOG1
+   LQB[20] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+   PRCHWRB[2] PRCHWRB[3] RB[20] RT[20] SEL[20] VBA[20] VBN[20] VBP[20] VDDA[20]
+   VDDAI[20] VDDP[20] VDDPI[20] VSS[20] WB[20] WBI[20] WT[20] WTI[20]
+   SNPS_RF_SP_UHS_256x28_cmux
X_cmux_F6 BB[84] BB[85] BB[86] BB[87] BT[84] BT[85] BT[86] BT[87] CKPRCHB
+   DRAIN_LEFT1[21] DRAIN_LEFT2[21] DRAIN_RIGHT1[21] DRAIN_RIGHT2[21]
+   GATE_LEFT1[21] GATE_LEFT2[21] GATE_RIGHT1[21] GATE_RIGHT2[21] LOG0 LOG1
+   LQB[21] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+   PRCHWRB[2] PRCHWRB[3] RB[21] RT[21] SEL[21] VBA[21] VBN[21] VBP[21] VDDA[21]
+   VDDAI[21] VDDP[21] VDDPI[21] VSS[21] WB[21] WBI[21] WT[21] WTI[21]
+   SNPS_RF_SP_UHS_256x28_cmux
X_cmux_F5 BB[88] BB[89] BB[90] BB[91] BT[88] BT[89] BT[90] BT[91] CKPRCHB
+   DRAIN_LEFT1[22] DRAIN_LEFT2[22] DRAIN_RIGHT1[22] DRAIN_RIGHT2[22]
+   GATE_LEFT1[22] GATE_LEFT2[22] GATE_RIGHT1[22] GATE_RIGHT2[22] LOG0 LOG1
+   LQB[22] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+   PRCHWRB[2] PRCHWRB[3] RB[22] RT[22] SEL[22] VBA[22] VBN[22] VBP[22] VDDA[22]
+   VDDAI[22] VDDP[22] VDDPI[22] VSS[22] WB[22] WBI[22] WT[22] WTI[22]
+   SNPS_RF_SP_UHS_256x28_cmux
X_cmux_F4 BB[92] BB[93] BB[94] BB[95] BT[92] BT[93] BT[94] BT[95] CKPRCHB
+   DRAIN_LEFT1[23] DRAIN_LEFT2[23] DRAIN_RIGHT1[23] DRAIN_RIGHT2[23]
+   GATE_LEFT1[23] GATE_LEFT2[23] GATE_RIGHT1[23] GATE_RIGHT2[23] LOG0 LOG1
+   LQB[23] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+   PRCHWRB[2] PRCHWRB[3] RB[23] RT[23] SEL[23] VBA[23] VBN[23] VBP[23] VDDA[23]
+   VDDAI[23] VDDP[23] VDDPI[23] VSS[23] WB[23] WBI[23] WT[23] WTI[23]
+   SNPS_RF_SP_UHS_256x28_cmux
X_cmux_F3 BB[96] BB[97] BB[98] BB[99] BT[96] BT[97] BT[98] BT[99] CKPRCHB
+   DRAIN_LEFT1[24] DRAIN_LEFT2[24] DRAIN_RIGHT1[24] DRAIN_RIGHT2[24]
+   GATE_LEFT1[24] GATE_LEFT2[24] GATE_RIGHT1[24] GATE_RIGHT2[24] LOG0 LOG1
+   LQB[24] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+   PRCHWRB[2] PRCHWRB[3] RB[24] RT[24] SEL[24] VBA[24] VBN[24] VBP[24] VDDA[24]
+   VDDAI[24] VDDP[24] VDDPI[24] VSS[24] WB[24] WBI[24] WT[24] WTI[24]
+   SNPS_RF_SP_UHS_256x28_cmux
X_cmux_F2 BB[100] BB[101] BB[102] BB[103] BT[100] BT[101] BT[102] BT[103]
+   CKPRCHB DRAIN_LEFT1[25] DRAIN_LEFT2[25] DRAIN_RIGHT1[25] DRAIN_RIGHT2[25]
+   GATE_LEFT1[25] GATE_LEFT2[25] GATE_RIGHT1[25] GATE_RIGHT2[25] LOG0 LOG1
+   LQB[25] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+   PRCHWRB[2] PRCHWRB[3] RB[25] RT[25] SEL[25] VBA[25] VBN[25] VBP[25] VDDA[25]
+   VDDAI[25] VDDP[25] VDDPI[25] VSS[25] WB[25] WBI[25] WT[25] WTI[25]
+   SNPS_RF_SP_UHS_256x28_cmux
X_cmux_F1 BB[104] BB[105] BB[106] BB[107] BT[104] BT[105] BT[106] BT[107]
+   CKPRCHB DRAIN_LEFT1[26] DRAIN_LEFT2[26] DRAIN_RIGHT1[26] DRAIN_RIGHT2[26]
+   GATE_LEFT1[26] GATE_LEFT2[26] GATE_RIGHT1[26] GATE_RIGHT2[26] LOG0 LOG1
+   LQB[26] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+   PRCHWRB[2] PRCHWRB[3] RB[26] RT[26] SEL[26] VBA[26] VBN[26] VBP[26] VDDA[26]
+   VDDAI[26] VDDP[26] VDDPI[26] VSS[26] WB[26] WBI[26] WT[26] WTI[26]
+   SNPS_RF_SP_UHS_256x28_cmux
X_cmux_F0 BB[108] BB[109] BB[110] BB[111] BT[108] BT[109] BT[110] BT[111]
+   CKPRCHB DRAIN_LEFT1[27] DRAIN_LEFT2[27] DRAIN_RIGHT1[27] DRAIN_RIGHT2[27]
+   GATE_LEFT1[27] GATE_LEFT2[27] GATE_RIGHT1[27] GATE_RIGHT2[27] LOG0 LOG1
+   LQB[27] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+   PRCHWRB[2] PRCHWRB[3] RB[27] RT[27] SEL[27] VBA[27] VBN[27] VBP[27] VDDA[27]
+   VDDAI[27] VDDP[27] VDDPI[27] VSS[27] WB[27] WBI[27] WT[27] WTI[27]
+   SNPS_RF_SP_UHS_256x28_cmux
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_mux_rt BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+       BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+       BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+       BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BB[64] BB[65] BB[66]
+       BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75] BB[76]
+       BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83] BB[84] BB[85] BB[86]
+       BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95] BB[96]
+       BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103] BB[104] BB[105]
+       BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BT[0] BT[1] BT[2] BT[3]
+       BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14]
+       BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+       BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34]
+       BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44]
+       BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54]
+       BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64]
+       BT[65] BT[66] BT[67] BT[68] BT[69] BT[70] BT[71] BT[72] BT[73] BT[74]
+       BT[75] BT[76] BT[77] BT[78] BT[79] BT[80] BT[81] BT[82] BT[83] BT[84]
+       BT[85] BT[86] BT[87] BT[88] BT[89] BT[90] BT[91] BT[92] BT[93] BT[94]
+       BT[95] BT[96] BT[97] BT[98] BT[99] BT[100] BT[101] BT[102] BT[103]
+       BT[104] BT[105] BT[106] BT[107] BT[108] BT[109] BT[110] BT[111] CKPRCHBR
+       DRAIN_LEFT1 DRAIN_LEFT2[0] GATE_LEFT1[0] GATE_LEFT2[0] LOG0 LOG1 LQB[0]
+       LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7] LQB[8] LQB[9] LQB[10]
+       LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16] LQB[17] LQB[18] LQB[19]
+       LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25] LQB[26] LQB[27] PGIOIR
+       PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+       PRCHWRB[2] PRCHWRB[3] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7]
+       RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RB[16] RB[17]
+       RB[18] RB[19] RB[20] RB[21] RB[22] RB[23] RB[24] RB[25] RB[26] RB[27]
+       RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10]
+       RT[11] RT[12] RT[13] RT[14] RT[15] RT[16] RT[17] RT[18] RT[19] RT[20]
+       RT[21] RT[22] RT[23] RT[24] RT[25] RT[26] RT[27] SEL[0] SEL[1] SEL[2]
+       SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+       SEL[13] SEL[14] SEL[15] SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21]
+       SEL[22] SEL[23] SEL[24] SEL[25] SEL[26] SEL[27] VBA[0] VBA[1] VBA[2]
+       VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12]
+       VBA[13] VBA[14] VBA[15] VBA[16] VBA[17] VBA[18] VBA[19] VBA[20] VBA[21]
+       VBA[22] VBA[23] VBA[24] VBA[25] VBA[26] VBA[27] VBA[28] VBN[0] VBN[1]
+       VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11]
+       VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20]
+       VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28] VBP[0]
+       VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10]
+       VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19]
+       VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28]
+       VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8]
+       VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16]
+       VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24]
+       VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDAI_H_T1[0] VDDAI_H_T1[1]
+       VDDAI_H_T1[2] VDDAI_H_T1[3] VDDAI_H_T1[4] VDDAI_H_T1[5] VDDAI_H_T1[6]
+       VDDAI_H_T1[7] VDDAI_H_T1[8] VDDAI_H_T1[9] VDDAI_H_T1[10] VDDAI_H_T1[11]
+       VDDAI_H_T1[12] VDDAI_H_T1[13] VDDAI_H_T1[14] VDDAI_H_T1[15]
+       VDDAI_H_T1[16] VDDAI_H_T1[17] VDDAI_H_T1[18] VDDAI_H_T1[19]
+       VDDAI_H_T1[20] VDDAI_H_T1[21] VDDAI_H_T1[22] VDDAI_H_T1[23]
+       VDDAI_H_T1[24] VDDAI_H_T1[25] VDDAI_H_T1[26] VDDAI_H_T1[27]
+       VDDAI_H_T1[28] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6]
+       VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14]
+       VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21] VDDP[22]
+       VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDPI[0] VDDPI[1]
+       VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9]
+       VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16]
+       VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23]
+       VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VEDGE_O VSS[0] VSS[1]
+       VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11]
+       VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] VSS[20]
+       VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28] WB[0]
+       WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11]
+       WB[12] WB[13] WB[14] WB[15] WB[16] WB[17] WB[18] WB[19] WB[20] WB[21]
+       WB[22] WB[23] WB[24] WB[25] WB[26] WB[27] WBI[0] WBI[1] WBI[2] WBI[3]
+       WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12]
+       WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21]
+       WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27] WT[0] WT[1] WT[2] WT[3]
+       WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14]
+       WT[15] WT[16] WT[17] WT[18] WT[19] WT[20] WT[21] WT[22] WT[23] WT[24]
+       WT[25] WT[26] WT[27] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+       WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+       WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24]
+       WTI[25] WTI[26] WTI[27]

*** Jumper Report ***
* Jumper: VBA[28] VSS[28]
* Jumper: VDDP[28] VDDPI[28]

X_mux_rt_seg1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BB[64] BB[65]
+   BB[66] BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75] BB[76]
+   BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83] BB[84] BB[85] BB[86] BB[87]
+   BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95] BB[96] BB[97] BB[98]
+   BB[99] BB[100] BB[101] BB[102] BB[103] BB[104] BB[105] BB[106] BB[107]
+   BB[108] BB[109] BB[110] BB[111] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6]
+   BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16] BT[17]
+   BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28]
+   BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35] BT[36] BT[37] BT[38] BT[39]
+   BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47] BT[48] BT[49] BT[50]
+   BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61]
+   BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68] BT[69] BT[70] BT[71] BT[72]
+   BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79] BT[80] BT[81] BT[82] BT[83]
+   BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90] BT[91] BT[92] BT[93] BT[94]
+   BT[95] BT[96] BT[97] BT[98] BT[99] BT[100] BT[101] BT[102] BT[103] BT[104]
+   BT[105] BT[106] BT[107] BT[108] BT[109] BT[110] BT[111] CKPRCHBR DRAIN_LEFT1
+   DRAIN_LEFT2[0] DRAIN_RIGHT1 DRAIN_RIGHT2 GATE_LEFT1[0] GATE_LEFT2[0]
+   GATE_RIGHT1 GATE_RIGHT2 LOG0 LOG1 LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5]
+   LQB[6] LQB[7] LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15]
+   LQB[16] LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24]
+   LQB[25] LQB[26] LQB[27] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3]
+   PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] RB[0] RB[1] RB[2] RB[3] RB[4]
+   RB[5] RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15]
+   RB[16] RB[17] RB[18] RB[19] RB[20] RB[21] RB[22] RB[23] RB[24] RB[25] RB[26]
+   RB[27] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10]
+   RT[11] RT[12] RT[13] RT[14] RT[15] RT[16] RT[17] RT[18] RT[19] RT[20] RT[21]
+   RT[22] RT[23] RT[24] RT[25] RT[26] RT[27] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14]
+   SEL[15] SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21] SEL[22] SEL[23]
+   SEL[24] SEL[25] SEL[26] SEL[27] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23] VBA[24]
+   VBA[25] VBA[26] VBA[27] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+   VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+   VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25]
+   VBN[26] VBN[27] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7]
+   VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+   VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+   VBP[26] VBP[27] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6]
+   VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+   VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22]
+   VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDAI_H_T1[0] VDDAI_H_T1[1]
+   VDDAI_H_T1[2] VDDAI_H_T1[3] VDDAI_H_T1[4] VDDAI_H_T1[5] VDDAI_H_T1[6]
+   VDDAI_H_T1[7] VDDAI_H_T1[8] VDDAI_H_T1[9] VDDAI_H_T1[10] VDDAI_H_T1[11]
+   VDDAI_H_T1[12] VDDAI_H_T1[13] VDDAI_H_T1[14] VDDAI_H_T1[15] VDDAI_H_T1[16]
+   VDDAI_H_T1[17] VDDAI_H_T1[18] VDDAI_H_T1[19] VDDAI_H_T1[20] VDDAI_H_T1[21]
+   VDDAI_H_T1[22] VDDAI_H_T1[23] VDDAI_H_T1[24] VDDAI_H_T1[25] VDDAI_H_T1[26]
+   VDDAI_H_T1[27] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6]
+   VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14]
+   VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21] VDDP[22]
+   VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDPI[0] VDDPI[1] VDDPI[2]
+   VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+   VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17]
+   VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24]
+   VDDPI[25] VDDPI[26] VDDPI[27] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+   VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15]
+   VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24]
+   VSS[25] VSS[26] VSS[27] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7]
+   WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WB[16] WB[17] WB[18]
+   WB[19] WB[20] WB[21] WB[22] WB[23] WB[24] WB[25] WB[26] WB[27] WBI[0] WBI[1]
+   WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11]
+   WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20]
+   WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27] WT[0] WT[1] WT[2]
+   WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14]
+   WT[15] WT[16] WT[17] WT[18] WT[19] WT[20] WT[21] WT[22] WT[23] WT[24] WT[25]
+   WT[26] WT[27] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8]
+   WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16] WTI[17]
+   WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25] WTI[26]
+   WTI[27] SNPS_RF_SP_UHS_256x28_mux_rt_seg1
X_mm19a04_u_hs1prf_capmux VDDA[28] VDDAI_H_T1[28] VDDP[28] VDDPI[28] VSS[28]
+   VBP[28] VBN[28] DRAIN_LEFT2[1] GATE_LEFT1[1] GATE_LEFT2[1] LOG0 LOG1 PGIOIR
+   VBA[28] VEDGE_O mm19a04_u_hs1prf_capmux
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_mux_row_t ARYSDR ARYSD_BC1 ARYSD_BC2 BB[0] BB[1]
+       BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12]
+       BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21] BB[22]
+       BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+       BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42]
+       BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52]
+       BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62]
+       BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71] BB[72]
+       BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82]
+       BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92]
+       BB[93] BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102]
+       BB[103] BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111]
+       BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10]
+       BT[11] BT[12] BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20]
+       BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30]
+       BT[31] BT[32] BT[33] BT[34] BT[35] BT[36] BT[37] BT[38] BT[39] BT[40]
+       BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47] BT[48] BT[49] BT[50]
+       BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57] BT[58] BT[59] BT[60]
+       BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68] BT[69] BT[70]
+       BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79] BT[80]
+       BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90]
+       BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100]
+       BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109]
+       BT[110] BT[111] BYP_VLOAD CENDP CKGATE DEF_MODE DLYPDB FAST1_MODE
+       FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR LBKADRB LBKADR_TOP LCGTH
+       LCGTHB_PCHG LDFTX LITESLP LOG0 LOG1 LQB[0] LQB[1] LQB[2] LQB[3] LQB[4]
+       LQB[5] LQB[6] LQB[7] LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13]
+       LQB[14] LQB[15] LQB[16] LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22]
+       LQB[23] LQB[24] LQB[25] LQB[26] LQB[27] LWEIB LWERD LWEWR LXADR[0]
+       LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+       LXADR_TOP[0] LXADR_TOP[1] LXADR_TOP[2] LXADR_TOP[3] LXADR_TOP[4]
+       LXADR_TOP[5] LXADR_TOP[6] LXADR_TOP[7] LYADR[0] LYADR[1] LYADR_TOP[0]
+       LYADR_TOP[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+       PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] PGIOIR PLBKADRB
+       PM[0] PM[1] PM[2] PM[3] PROCOML RASSIST[0] RASSIST[1] RASSISTB[0]
+       RASSISTB[1] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9]
+       RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RB[16] RB[17] RB[18] RB[19]
+       RB[20] RB[21] RB[22] RB[23] RB[24] RB[25] RB[26] RB[27] RBLRD RBLWA
+       RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RT[0] RT[1] RT[2] RT[3] RT[4]
+       RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15]
+       RT[16] RT[17] RT[18] RT[19] RT[20] RT[21] RT[22] RT[23] RT[24] RT[25]
+       RT[26] RT[27] RWLB SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+       SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15]
+       SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21] SEL[22] SEL[23] SEL[24]
+       SEL[25] SEL[26] SEL[27] T1T TEST_RNMB VBA[0] VBA[1] VBA[2] VBA[3] VBA[4]
+       VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13]
+       VBA[14] VBA[15] VBA[16] VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22]
+       VBA[23] VBA[24] VBA[25] VBA[26] VBA[27] VBA[28] VBA[29] VBN[0] VBN[1]
+       VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11]
+       VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20]
+       VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28] VBN[29]
+       VBN[30] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8]
+       VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VBP[17]
+       VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25] VBP[26]
+       VBP[27] VBP[28] VBP[29] VBP[30] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4]
+       VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+       VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20]
+       VDDA[21] VDDA[22] VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28]
+       VDDA[29] VDDA[30] VDDAI_H_T1[0] VDDAI_H_T1[1] VDDAI_H_T1[2]
+       VDDAI_H_T1[3] VDDAI_H_T1[4] VDDAI_H_T1[5] VDDAI_H_T1[6] VDDAI_H_T1[7]
+       VDDAI_H_T1[8] VDDAI_H_T1[9] VDDAI_H_T1[10] VDDAI_H_T1[11] VDDAI_H_T1[12]
+       VDDAI_H_T1[13] VDDAI_H_T1[14] VDDAI_H_T1[15] VDDAI_H_T1[16]
+       VDDAI_H_T1[17] VDDAI_H_T1[18] VDDAI_H_T1[19] VDDAI_H_T1[20]
+       VDDAI_H_T1[21] VDDAI_H_T1[22] VDDAI_H_T1[23] VDDAI_H_T1[24]
+       VDDAI_H_T1[25] VDDAI_H_T1[26] VDDAI_H_T1[27] VDDAI_H_T1[28] VDDF VDDP[0]
+       VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9]
+       VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17]
+       VDDP[18] VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25]
+       VDDP[26] VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDPI[0] VDDPI[1] VDDPI[2]
+       VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+       VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17]
+       VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24]
+       VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30] VDDWL
+       VDDWL_PCOM VEDGE_O VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6]
+       VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15]
+       VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24]
+       VSS[25] VSS[26] VSS[27] VSS[28] VSS[29] VSSWLL VSSWLR WABUF[0] WABUF[1]
+       WABUF[2] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9]
+       WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WB[16] WB[17] WB[18] WB[19]
+       WB[20] WB[21] WB[22] WB[23] WB[24] WB[25] WB[26] WB[27] WBI[0] WBI[1]
+       WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11]
+       WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20]
+       WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27] WCLKB[0]
+       WCLKB[1] WCLKB[2] WCLKB[3] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+       WPBUF[2] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9]
+       WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WT[16] WT[17] WT[18] WT[19]
+       WT[20] WT[21] WT[22] WT[23] WT[24] WT[25] WT[26] WT[27] WTI[0] WTI[1]
+       WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11]
+       WTI[12] WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20]
+       WTI[21] WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27]
X_mux_cnt ARYSDR ARYSD_BC1 ARYSD_BC2 BYP_VLOAD CENDP CKGATE CKPRCHBR DEF_MODE
+   DLYPDB DRAIN_RIGHT2 FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET GATE_RIGHT1
+   GATE_RIGHT2 LBKADR LBKADRB LBKADR_TOP LCGTH LCGTHB_PCHG LDFTX LITESLP LOG0
+   LOG1 LWEIB LWERD LWEWR LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+   LXADR[6] LXADR[7] LXADR_TOP[0] LXADR_TOP[1] LXADR_TOP[2] LXADR_TOP[3]
+   LXADR_TOP[4] LXADR_TOP[5] LXADR_TOP[6] LXADR_TOP[7] LYADR[0] LYADR[1]
+   LYADR_TOP[0] LYADR_TOP[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6]
+   PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] PLBKADRB
+   PM[0] PM[1] PM[2] PM[3] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3]
+   PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] PROCOML RASSIST[0] RASSIST[1]
+   RASSISTB[0] RASSISTB[1] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3]
+   RWLB T1T TEST_RNMB VBA[0] VBN[0] VBN[1] VBP[0] VBP[1] VDDA[0] VDDA[1] VDDF
+   VDDP[0] VDDP[1] VDDPI[0] VDDPI[1] VDDWL VDDWL_PCOM VSS[0] VSSWLL VSSWLR
+   WABUF[0] WABUF[1] WABUF[2] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] WMT[0] WMT[1]
+   WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] SNPS_RF_SP_UHS_256x28_mux_cnt
X_mux_rt BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BB[64] BB[65]
+   BB[66] BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75] BB[76]
+   BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83] BB[84] BB[85] BB[86] BB[87]
+   BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95] BB[96] BB[97] BB[98]
+   BB[99] BB[100] BB[101] BB[102] BB[103] BB[104] BB[105] BB[106] BB[107]
+   BB[108] BB[109] BB[110] BB[111] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6]
+   BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16] BT[17]
+   BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28]
+   BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35] BT[36] BT[37] BT[38] BT[39]
+   BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47] BT[48] BT[49] BT[50]
+   BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61]
+   BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68] BT[69] BT[70] BT[71] BT[72]
+   BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79] BT[80] BT[81] BT[82] BT[83]
+   BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90] BT[91] BT[92] BT[93] BT[94]
+   BT[95] BT[96] BT[97] BT[98] BT[99] BT[100] BT[101] BT[102] BT[103] BT[104]
+   BT[105] BT[106] BT[107] BT[108] BT[109] BT[110] BT[111] CKPRCHBR DRAIN_LEFT1
+   DRAIN_LEFT2 GATE_LEFT1 GATE_LEFT2 LOG0 LOG1 LQB[0] LQB[1] LQB[2] LQB[3]
+   LQB[4] LQB[5] LQB[6] LQB[7] LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13]
+   LQB[14] LQB[15] LQB[16] LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22]
+   LQB[23] LQB[24] LQB[25] LQB[26] LQB[27] PGIOIR PRCHRDB[0] PRCHRDB[1]
+   PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] RB[0]
+   RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12]
+   RB[13] RB[14] RB[15] RB[16] RB[17] RB[18] RB[19] RB[20] RB[21] RB[22] RB[23]
+   RB[24] RB[25] RB[26] RB[27] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7]
+   RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15] RT[16] RT[17] RT[18]
+   RT[19] RT[20] RT[21] RT[22] RT[23] RT[24] RT[25] RT[26] RT[27] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] SEL[16] SEL[17] SEL[18] SEL[19] SEL[20]
+   SEL[21] SEL[22] SEL[23] SEL[24] SEL[25] SEL[26] SEL[27] VBA[1] VBA[2] VBA[3]
+   VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13]
+   VBA[14] VBA[15] VBA[16] VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22]
+   VBA[23] VBA[24] VBA[25] VBA[26] VBA[27] VBA[28] VBA[29] VBN[2] VBN[3] VBN[4]
+   VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14]
+   VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23]
+   VBN[24] VBN[25] VBN[26] VBN[27] VBN[28] VBN[29] VBN[30] VBP[2] VBP[3] VBP[4]
+   VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14]
+   VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23]
+   VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20]
+   VDDA[21] VDDA[22] VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28]
+   VDDA[29] VDDA[30] VDDAI_H_T1[0] VDDAI_H_T1[1] VDDAI_H_T1[2] VDDAI_H_T1[3]
+   VDDAI_H_T1[4] VDDAI_H_T1[5] VDDAI_H_T1[6] VDDAI_H_T1[7] VDDAI_H_T1[8]
+   VDDAI_H_T1[9] VDDAI_H_T1[10] VDDAI_H_T1[11] VDDAI_H_T1[12] VDDAI_H_T1[13]
+   VDDAI_H_T1[14] VDDAI_H_T1[15] VDDAI_H_T1[16] VDDAI_H_T1[17] VDDAI_H_T1[18]
+   VDDAI_H_T1[19] VDDAI_H_T1[20] VDDAI_H_T1[21] VDDAI_H_T1[22] VDDAI_H_T1[23]
+   VDDAI_H_T1[24] VDDAI_H_T1[25] VDDAI_H_T1[26] VDDAI_H_T1[27] VDDAI_H_T1[28]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5]
+   VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13]
+   VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20]
+   VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27]
+   VDDPI[28] VDDPI[29] VDDPI[30] VEDGE_O VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+   VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15]
+   VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24]
+   VSS[25] VSS[26] VSS[27] VSS[28] VSS[29] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5]
+   WB[6] WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WB[16]
+   WB[17] WB[18] WB[19] WB[20] WB[21] WB[22] WB[23] WB[24] WB[25] WB[26] WB[27]
+   WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9]
+   WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18]
+   WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27]
+   WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11]
+   WT[12] WT[13] WT[14] WT[15] WT[16] WT[17] WT[18] WT[19] WT[20] WT[21] WT[22]
+   WT[23] WT[24] WT[25] WT[26] WT[27] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24]
+   WTI[25] WTI[26] WTI[27] SNPS_RF_SP_UHS_256x28_mux_rt
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_mux_row ARYSDR ARYSD_BC1 ARYSD_BC2 BB[0] BB[1]
+       BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12]
+       BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21] BB[22]
+       BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+       BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42]
+       BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52]
+       BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62]
+       BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71] BB[72]
+       BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82]
+       BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92]
+       BB[93] BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102]
+       BB[103] BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111]
+       BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10]
+       BT[11] BT[12] BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20]
+       BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30]
+       BT[31] BT[32] BT[33] BT[34] BT[35] BT[36] BT[37] BT[38] BT[39] BT[40]
+       BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47] BT[48] BT[49] BT[50]
+       BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57] BT[58] BT[59] BT[60]
+       BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68] BT[69] BT[70]
+       BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79] BT[80]
+       BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90]
+       BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100]
+       BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109]
+       BT[110] BT[111] BYP_VLOAD CENDP CKGATE DEF_MODE DLYPDB FAST1_MODE
+       FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR LBKADRB LBKADR_TOP LCGTH
+       LCGTHB_PCHG LDFTX LITESLP LOG0 LOG1 LQB[0] LQB[1] LQB[2] LQB[3] LQB[4]
+       LQB[5] LQB[6] LQB[7] LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13]
+       LQB[14] LQB[15] LQB[16] LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22]
+       LQB[23] LQB[24] LQB[25] LQB[26] LQB[27] LWEIB LWERD LWEWR LXADR[0]
+       LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+       LXADR_TOP[0] LXADR_TOP[1] LXADR_TOP[2] LXADR_TOP[3] LXADR_TOP[4]
+       LXADR_TOP[5] LXADR_TOP[6] LXADR_TOP[7] LYADR[0] LYADR[1] LYADR_TOP[0]
+       LYADR_TOP[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+       PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] PGIOIR PLBKADRB
+       PM[0] PM[1] PM[2] PM[3] PROCOML RASSIST[0] RASSIST[1] RASSISTB[0]
+       RASSISTB[1] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9]
+       RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RB[16] RB[17] RB[18] RB[19]
+       RB[20] RB[21] RB[22] RB[23] RB[24] RB[25] RB[26] RB[27] RBLRD RBLWA
+       RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RT[0] RT[1] RT[2] RT[3] RT[4]
+       RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15]
+       RT[16] RT[17] RT[18] RT[19] RT[20] RT[21] RT[22] RT[23] RT[24] RT[25]
+       RT[26] RT[27] RWLB SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+       SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15]
+       SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21] SEL[22] SEL[23] SEL[24]
+       SEL[25] SEL[26] SEL[27] T1T TEST_RNMB VBA VBN VBP VDDA VDDAI_H_T1 VDDF
+       VDDP VDDPI VDDWL VDDWL_PCOM VEDGE_O VSS VSSWLL VSSWLR WABUF[0] WABUF[1]
+       WABUF[2] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9]
+       WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WB[16] WB[17] WB[18] WB[19]
+       WB[20] WB[21] WB[22] WB[23] WB[24] WB[25] WB[26] WB[27] WBI[0] WBI[1]
+       WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11]
+       WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20]
+       WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27] WCLKB[0]
+       WCLKB[1] WCLKB[2] WCLKB[3] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+       WPBUF[2] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9]
+       WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WT[16] WT[17] WT[18] WT[19]
+       WT[20] WT[21] WT[22] WT[23] WT[24] WT[25] WT[26] WT[27] WTI[0] WTI[1]
+       WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11]
+       WTI[12] WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20]
+       WTI[21] WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27]
X_mux_row_t ARYSDR ARYSD_BC1 ARYSD_BC2 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+   BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17]
+   BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28]
+   BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39]
+   BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50]
+   BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61]
+   BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71] BB[72]
+   BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83]
+   BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94]
+   BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103] BB[104]
+   BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BT[0] BT[1] BT[2]
+   BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14]
+   BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25]
+   BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35] BT[36]
+   BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47]
+   BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57] BT[58]
+   BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68] BT[69]
+   BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79] BT[80]
+   BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90] BT[91]
+   BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100] BT[101]
+   BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109] BT[110]
+   BT[111] BYP_VLOAD CENDP CKGATE DEF_MODE DLYPDB FAST1_MODE FAST2_MODE FLOAT
+   FLOATT FLOAT_RET LBKADR LBKADRB LBKADR_TOP LCGTH LCGTHB_PCHG LDFTX LITESLP
+   LOG0 LOG1 LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7] LQB[8]
+   LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16] LQB[17]
+   LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25] LQB[26]
+   LQB[27] LWEIB LWERD LWEWR LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+   LXADR[5] LXADR[6] LXADR[7] LXADR_TOP[0] LXADR_TOP[1] LXADR_TOP[2]
+   LXADR_TOP[3] LXADR_TOP[4] LXADR_TOP[5] LXADR_TOP[6] LXADR_TOP[7] LYADR[0]
+   LYADR[1] LYADR_TOP[0] LYADR_TOP[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5]
+   PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] PGIOIR
+   PLBKADRB PM[0] PM[1] PM[2] PM[3] PROCOML RASSIST[0] RASSIST[1] RASSISTB[0]
+   RASSISTB[1] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9]
+   RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RB[16] RB[17] RB[18] RB[19] RB[20]
+   RB[21] RB[22] RB[23] RB[24] RB[25] RB[26] RB[27] RBLRD RBLWA RBLWR RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7]
+   RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15] RT[16] RT[17] RT[18]
+   RT[19] RT[20] RT[21] RT[22] RT[23] RT[24] RT[25] RT[26] RT[27] RWLB SEL[0]
+   SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10]
+   SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] SEL[16] SEL[17] SEL[18] SEL[19]
+   SEL[20] SEL[21] SEL[22] SEL[23] SEL[24] SEL[25] SEL[26] SEL[27] T1T
+   TEST_RNMB VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA
+   VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1
+   VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1
+   VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1
+   VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1
+   VDDAI_H_T1 VDDAI_H_T1 VDDF VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDWL VDDWL_PCOM VEDGE_O VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSSWLL
+   VSSWLR WABUF[0] WABUF[1] WABUF[2] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6]
+   WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WB[16] WB[17]
+   WB[18] WB[19] WB[20] WB[21] WB[22] WB[23] WB[24] WB[25] WB[26] WB[27] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10]
+   WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18] WBI[19]
+   WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27] WCLKB[0]
+   WCLKB[1] WCLKB[2] WCLKB[3] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10]
+   WT[11] WT[12] WT[13] WT[14] WT[15] WT[16] WT[17] WT[18] WT[19] WT[20] WT[21]
+   WT[22] WT[23] WT[24] WT[25] WT[26] WT[27] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4]
+   WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14]
+   WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23]
+   WTI[24] WTI[25] WTI[26] WTI[27] SNPS_RF_SP_UHS_256x28_mux_row_t
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_ary_xdec B[0] BYP_VLOAD C[0] CENDP CKGATE
+       DEC_HV[0] DEC_HV[1] DEC_HV[2] DEC_HV[3] DEC_HV[4] DEC_HV[5] DEC_HV[6]
+       DEC_HV[7] DEC_HV[8] DEC_HV[9] DEC_HV[10] DEC_HV[11] DEC_HV[12]
+       DEC_HV[13] DEC_HV[14] DEC_HV[15] DEC_LV[0] DEC_LV[1] DEC_LV[2] DEC_LV[3]
+       DEC_LV[4] DEC_LV[5] DEC_LV[6] DEC_LV[7] DEC_LV[8] DEC_LV[9] DEC_LV[10]
+       DEC_LV[11] DEC_LV[12] DEC_LV[13] DEC_LV[14] DEC_LV[15] DEF_MODE
+       FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR LDFTX LITESLP LOG0
+       LOG1 LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+       LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4]
+       PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6]
+       PCB[7] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB T1T
+       TEST_RNMB VBN VBP VDDA VDDF VDDP VDDPI VDDWL[0] VDDWL[1] VDDWL[2]
+       VDDWL[3] VDDWL[4] VDDWL[5] VDDWL[6] VDDWL[7] VDDWL[8] VDDWL[9] VDDWL[10]
+       VDDWL[11] VDDWL[12] VDDWL[13] VDDWL[14] VDDWL[15] VSS VSSWLL VSSWLR
+       WABUF[0] WABUF[1] WABUF[2] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] WLBH[0]
+       WLBH[1] WLBH[2] WLBH[3] WLBH[4] WLBH[5] WLBH[6] WLBH[7] WLBH[8] WLBH[9]
+       WLBH[10] WLBH[11] WLBH[12] WLBH[13] WLBH[14] WLBH[15] WLBH[16] WLBH[17]
+       WLBH[18] WLBH[19] WLBH[20] WLBH[21] WLBH[22] WLBH[23] WLBH[24] WLBH[25]
+       WLBH[26] WLBH[27] WLBH[28] WLBH[29] WLBH[30] WLBH[31] WLBH[32] WLBH[33]
+       WLBH[34] WLBH[35] WLBH[36] WLBH[37] WLBH[38] WLBH[39] WLBH[40] WLBH[41]
+       WLBH[42] WLBH[43] WLBH[44] WLBH[45] WLBH[46] WLBH[47] WLBH[48] WLBH[49]
+       WLBH[50] WLBH[51] WLBH[52] WLBH[53] WLBH[54] WLBH[55] WLBH[56] WLBH[57]
+       WLBH[58] WLBH[59] WLBH[60] WLBH[61] WLBH[62] WLBH[63] WLBL[0] WLBL[1]
+       WLBL[2] WLBL[3] WLBL[4] WLBL[5] WLBL[6] WLBL[7] WLBL[8] WLBL[9] WLBL[10]
+       WLBL[11] WLBL[12] WLBL[13] WLBL[14] WLBL[15] WLBL[16] WLBL[17] WLBL[18]
+       WLBL[19] WLBL[20] WLBL[21] WLBL[22] WLBL[23] WLBL[24] WLBL[25] WLBL[26]
+       WLBL[27] WLBL[28] WLBL[29] WLBL[30] WLBL[31] WLBL[32] WLBL[33] WLBL[34]
+       WLBL[35] WLBL[36] WLBL[37] WLBL[38] WLBL[39] WLBL[40] WLBL[41] WLBL[42]
+       WLBL[43] WLBL[44] WLBL[45] WLBL[46] WLBL[47] WLBL[48] WLBL[49] WLBL[50]
+       WLBL[51] WLBL[52] WLBL[53] WLBL[54] WLBL[55] WLBL[56] WLBL[57] WLBL[58]
+       WLBL[59] WLBL[60] WLBL[61] WLBL[62] WLBL[63] WMT[0] WMT[1] WMT[2] WMT[3]
+       WPBUF[0] WPBUF[1] WPBUF[2]

*** Jumper Report ***
* Jumper: B[0] PBB[0] B[8]
* Jumper: C[0] PCB[0] C[1] C[2] C[3] C[4] C[5] C[6] C[7]
* Jumper: DEC_HV[0] DEC_LV[0]
* Jumper: DEC_HV[1] DEC_LV[1]
* Jumper: DEC_HV[2] DEC_LV[2]
* Jumper: DEC_HV[3] DEC_LV[3]
* Jumper: DEC_HV[4] DEC_LV[4]
* Jumper: DEC_HV[5] DEC_LV[5]
* Jumper: DEC_HV[6] DEC_LV[6]
* Jumper: DEC_HV[7] DEC_LV[7]
* Jumper: DEC_HV[8] DEC_LV[8]
* Jumper: DEC_HV[9] DEC_LV[9]
* Jumper: DEC_HV[10] DEC_LV[10]
* Jumper: DEC_HV[11] DEC_LV[11]
* Jumper: DEC_HV[12] DEC_LV[12]
* Jumper: DEC_HV[13] DEC_LV[13]
* Jumper: DEC_HV[14] DEC_LV[14]
* Jumper: DEC_HV[15] DEC_LV[15]
* Jumper: PBB[1] B[1] B[9]
* Jumper: PBB[2] B[2] B[10]
* Jumper: PBB[3] B[3] B[11]
* Jumper: PBB[4] B[4] B[12]
* Jumper: PBB[5] B[5] B[13]
* Jumper: PBB[6] B[6] B[14]
* Jumper: PBB[7] B[7] B[15]
* Jumper: PCB[1] C[8] C[9] C[10] C[11] C[12] C[13] C[14] C[15]
* Jumper: VDDA VDDP VDDPI

X_mm19a04_u_hs1prf_x4dec_S0 VDDA VDDF VDDP VDDPI VDDWL[0] VSS VSSWLL VSSWLR VBP
+   VBN DEC_LV[0] WLBH[0] WLBH[1] WLBH[2] WLBH[3] WLBL[0] WLBL[1] WLBL[2]
+   WLBL[3] BYP_VLOAD CKGATE DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3]
+   RWLB T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3]
+   WPBUF[0] WPBUF[1] WPBUF[2] B[0] C[0] CENDP DEC_HV[0] FLOAT LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm19a04_u_hs1prf_x4dec
X_mm19a04_u_hs1prf_x4dec_wl_S0 VDDA VDDF VDDP VDDPI VDDWL[1] VSS VSSWLL VSSWLR
+   VBP VBN DEC_LV[1] WLBH[4] WLBH[5] WLBH[6] WLBH[7] WLBL[4] WLBL[5] WLBL[6]
+   WLBL[7] BYP_VLOAD CKGATE DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3]
+   RWLB T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3]
+   WPBUF[0] WPBUF[1] WPBUF[2] PBB[1] C[0] CENDP DEC_HV[1] FLOAT LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm19a04_u_hs1prf_x4dec
X_mm19a04_u_hs1prf_x4dec_S1 VDDA VDDF VDDP VDDPI VDDWL[2] VSS VSSWLL VSSWLR VBP
+   VBN DEC_LV[2] WLBH[8] WLBH[9] WLBH[10] WLBH[11] WLBL[8] WLBL[9] WLBL[10]
+   WLBL[11] BYP_VLOAD CKGATE DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3]
+   RWLB T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3]
+   WPBUF[0] WPBUF[1] WPBUF[2] PBB[2] C[0] CENDP DEC_HV[2] FLOAT LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm19a04_u_hs1prf_x4dec
X_mm19a04_u_hs1prf_x4dec_wl_S1 VDDA VDDF VDDP VDDPI VDDWL[3] VSS VSSWLL VSSWLR
+   VBP VBN DEC_LV[3] WLBH[12] WLBH[13] WLBH[14] WLBH[15] WLBL[12] WLBL[13]
+   WLBL[14] WLBL[15] BYP_VLOAD CKGATE DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1]
+   RMT[2] RMT[3] RWLB T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1]
+   WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[3] C[0] CENDP DEC_HV[3] FLOAT
+   LBKADR LITESLP LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+   LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4]
+   PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7]
+   WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] mm19a04_u_hs1prf_x4dec
X_mm19a04_u_hs1prf_x4dec_S2 VDDA VDDF VDDP VDDPI VDDWL[4] VSS VSSWLL VSSWLR VBP
+   VBN DEC_LV[4] WLBH[16] WLBH[17] WLBH[18] WLBH[19] WLBL[16] WLBL[17] WLBL[18]
+   WLBL[19] BYP_VLOAD CKGATE DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3]
+   RWLB T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3]
+   WPBUF[0] WPBUF[1] WPBUF[2] PBB[4] C[0] CENDP DEC_HV[4] FLOAT LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm19a04_u_hs1prf_x4dec
X_mm19a04_u_hs1prf_x4dec_wl_S2 VDDA VDDF VDDP VDDPI VDDWL[5] VSS VSSWLL VSSWLR
+   VBP VBN DEC_LV[5] WLBH[20] WLBH[21] WLBH[22] WLBH[23] WLBL[20] WLBL[21]
+   WLBL[22] WLBL[23] BYP_VLOAD CKGATE DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1]
+   RMT[2] RMT[3] RWLB T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1]
+   WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[5] C[0] CENDP DEC_HV[5] FLOAT
+   LBKADR LITESLP LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+   LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4]
+   PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7]
+   WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] mm19a04_u_hs1prf_x4dec
X_mm19a04_u_hs1prf_x4dec_S3 VDDA VDDF VDDP VDDPI VDDWL[6] VSS VSSWLL VSSWLR VBP
+   VBN DEC_LV[6] WLBH[24] WLBH[25] WLBH[26] WLBH[27] WLBL[24] WLBL[25] WLBL[26]
+   WLBL[27] BYP_VLOAD CKGATE DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3]
+   RWLB T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3]
+   WPBUF[0] WPBUF[1] WPBUF[2] PBB[6] C[0] CENDP DEC_HV[6] FLOAT LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm19a04_u_hs1prf_x4dec
X_mm19a04_u_hs1prf_x4dec_wl_S3 VDDA VDDF VDDP VDDPI VDDWL[7] VSS VSSWLL VSSWLR
+   VBP VBN DEC_LV[7] WLBH[28] WLBH[29] WLBH[30] WLBH[31] WLBL[28] WLBL[29]
+   WLBL[30] WLBL[31] BYP_VLOAD CKGATE DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1]
+   RMT[2] RMT[3] RWLB T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1]
+   WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[7] C[0] CENDP DEC_HV[7] FLOAT
+   LBKADR LITESLP LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+   LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4]
+   PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7]
+   WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] mm19a04_u_hs1prf_x4dec
X_mm19a04_u_hs1prf_x4dec_F3 VDDA VDDF VDDP VDDPI VDDWL[8] VSS VSSWLL VSSWLR VBP
+   VBN DEC_LV[8] WLBH[32] WLBH[33] WLBH[34] WLBH[35] WLBL[32] WLBL[33] WLBL[34]
+   WLBL[35] BYP_VLOAD CKGATE DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3]
+   RWLB T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3]
+   WPBUF[0] WPBUF[1] WPBUF[2] B[0] PCB[1] CENDP DEC_HV[8] FLOAT LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm19a04_u_hs1prf_x4dec
X_mm19a04_u_hs1prf_x4dec_wl_F3 VDDA VDDF VDDP VDDPI VDDWL[9] VSS VSSWLL VSSWLR
+   VBP VBN DEC_LV[9] WLBH[36] WLBH[37] WLBH[38] WLBH[39] WLBL[36] WLBL[37]
+   WLBL[38] WLBL[39] BYP_VLOAD CKGATE DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1]
+   RMT[2] RMT[3] RWLB T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1]
+   WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[1] PCB[1] CENDP DEC_HV[9] FLOAT
+   LBKADR LITESLP LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+   LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4]
+   PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7]
+   WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] mm19a04_u_hs1prf_x4dec
X_mm19a04_u_hs1prf_x4dec_F2 VDDA VDDF VDDP VDDPI VDDWL[10] VSS VSSWLL VSSWLR VBP
+   VBN DEC_LV[10] WLBH[40] WLBH[41] WLBH[42] WLBH[43] WLBL[40] WLBL[41]
+   WLBL[42] WLBL[43] BYP_VLOAD CKGATE DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1]
+   RMT[2] RMT[3] RWLB T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1]
+   WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[2] PCB[1] CENDP DEC_HV[10]
+   FLOAT LBKADR LITESLP LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+   LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4]
+   PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7]
+   WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] mm19a04_u_hs1prf_x4dec
X_mm19a04_u_hs1prf_x4dec_wl_F2 VDDA VDDF VDDP VDDPI VDDWL[11] VSS VSSWLL VSSWLR
+   VBP VBN DEC_LV[11] WLBH[44] WLBH[45] WLBH[46] WLBH[47] WLBL[44] WLBL[45]
+   WLBL[46] WLBL[47] BYP_VLOAD CKGATE DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1]
+   RMT[2] RMT[3] RWLB T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1]
+   WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[3] PCB[1] CENDP DEC_HV[11]
+   FLOAT LBKADR LITESLP LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+   LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4]
+   PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7]
+   WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] mm19a04_u_hs1prf_x4dec
X_mm19a04_u_hs1prf_x4dec_F1 VDDA VDDF VDDP VDDPI VDDWL[12] VSS VSSWLL VSSWLR VBP
+   VBN DEC_LV[12] WLBH[48] WLBH[49] WLBH[50] WLBH[51] WLBL[48] WLBL[49]
+   WLBL[50] WLBL[51] BYP_VLOAD CKGATE DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1]
+   RMT[2] RMT[3] RWLB T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1]
+   WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[4] PCB[1] CENDP DEC_HV[12]
+   FLOAT LBKADR LITESLP LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+   LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4]
+   PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7]
+   WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] mm19a04_u_hs1prf_x4dec
X_mm19a04_u_hs1prf_x4dec_wl_F1 VDDA VDDF VDDP VDDPI VDDWL[13] VSS VSSWLL VSSWLR
+   VBP VBN DEC_LV[13] WLBH[52] WLBH[53] WLBH[54] WLBH[55] WLBL[52] WLBL[53]
+   WLBL[54] WLBL[55] BYP_VLOAD CKGATE DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1]
+   RMT[2] RMT[3] RWLB T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1]
+   WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[5] PCB[1] CENDP DEC_HV[13]
+   FLOAT LBKADR LITESLP LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+   LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4]
+   PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7]
+   WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] mm19a04_u_hs1prf_x4dec
X_mm19a04_u_hs1prf_x4dec_F0 VDDA VDDF VDDP VDDPI VDDWL[14] VSS VSSWLL VSSWLR VBP
+   VBN DEC_LV[14] WLBH[56] WLBH[57] WLBH[58] WLBH[59] WLBL[56] WLBL[57]
+   WLBL[58] WLBL[59] BYP_VLOAD CKGATE DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1]
+   RMT[2] RMT[3] RWLB T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1]
+   WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[6] PCB[1] CENDP DEC_HV[14]
+   FLOAT LBKADR LITESLP LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+   LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4]
+   PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7]
+   WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] mm19a04_u_hs1prf_x4dec
X_mm19a04_u_hs1prf_x4dec_wl_F0 VDDA VDDF VDDP VDDPI VDDWL[15] VSS VSSWLL VSSWLR
+   VBP VBN DEC_LV[15] WLBH[60] WLBH[61] WLBH[62] WLBH[63] WLBL[60] WLBL[61]
+   WLBL[62] WLBL[63] BYP_VLOAD CKGATE DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1]
+   RMT[2] RMT[3] RWLB T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1]
+   WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[7] PCB[1] CENDP DEC_HV[15]
+   FLOAT LBKADR LITESLP LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+   LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4]
+   PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7]
+   WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] mm19a04_u_hs1prf_x4dec
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_ary_buf ARYSD ARYSD_BC1 ARYSD_BC2 DLYPDB EDGEB[0]
+       EDGET[15] LCGTH LOG0 LOG1 PROCOML RASSIST[0] RASSIST[1] RASSISTB[0]
+       RASSISTB[1] VBA VBN VBP VDDA VDDP VDDPI VDDWL VSS WL[0] WL[1] WL[2]
+       WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13]
+       WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23]
+       WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33]
+       WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42] WL[43]
+       WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53]
+       WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63]
+       WLB[0] WLB[1] WLB[2] WLB[3] WLB[4] WLB[5] WLB[6] WLB[7] WLB[8] WLB[9]
+       WLB[10] WLB[11] WLB[12] WLB[13] WLB[14] WLB[15] WLB[16] WLB[17] WLB[18]
+       WLB[19] WLB[20] WLB[21] WLB[22] WLB[23] WLB[24] WLB[25] WLB[26] WLB[27]
+       WLB[28] WLB[29] WLB[30] WLB[31] WLB[32] WLB[33] WLB[34] WLB[35] WLB[36]
+       WLB[37] WLB[38] WLB[39] WLB[40] WLB[41] WLB[42] WLB[43] WLB[44] WLB[45]
+       WLB[46] WLB[47] WLB[48] WLB[49] WLB[50] WLB[51] WLB[52] WLB[53] WLB[54]
+       WLB[55] WLB[56] WLB[57] WLB[58] WLB[59] WLB[60] WLB[61] WLB[62] WLB[63]
X_mm19a04_u_hs1prf_x4buf_S0 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[0] WL[1] WL[2]
+   WL[3] ARYSD ARYSD_BC1 ARYSD_BC2 DLYPDB EDGEB[0] EDGET[0] LCGTH LOG0 LOG1
+   PROCOML RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[0] WLB[1]
+   WLB[2] WLB[3] mm19a04_u_hs1prf_x4buf
X_mm19a04_u_hs1prf_x4buf_wl_S0 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[4] WL[5]
+   WL[6] WL[7] ARYSD ARYSD_BC1 ARYSD_BC2 DLYPDB EDGEB[1] EDGET[1] LCGTH LOG0
+   LOG1 PROCOML RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[4] WLB[5]
+   WLB[6] WLB[7] mm19a04_u_hs1prf_x4buf
X_mm19a04_u_hs1prf_x4buf_S1 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[8] WL[9] WL[10]
+   WL[11] ARYSD ARYSD_BC1 ARYSD_BC2 DLYPDB EDGEB[2] EDGET[2] LCGTH LOG0 LOG1
+   PROCOML RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[8] WLB[9]
+   WLB[10] WLB[11] mm19a04_u_hs1prf_x4buf
X_mm19a04_u_hs1prf_x4buf_wl_S1 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[12] WL[13]
+   WL[14] WL[15] ARYSD ARYSD_BC1 ARYSD_BC2 DLYPDB EDGEB[3] EDGET[3] LCGTH LOG0
+   LOG1 PROCOML RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[12]
+   WLB[13] WLB[14] WLB[15] mm19a04_u_hs1prf_x4buf
X_mm19a04_u_hs1prf_x4buf_S2 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[16] WL[17]
+   WL[18] WL[19] ARYSD ARYSD_BC1 ARYSD_BC2 DLYPDB EDGEB[4] EDGET[4] LCGTH LOG0
+   LOG1 PROCOML RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[16]
+   WLB[17] WLB[18] WLB[19] mm19a04_u_hs1prf_x4buf
X_mm19a04_u_hs1prf_x4buf_wl_S2 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[20] WL[21]
+   WL[22] WL[23] ARYSD ARYSD_BC1 ARYSD_BC2 DLYPDB EDGEB[5] EDGET[5] LCGTH LOG0
+   LOG1 PROCOML RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[20]
+   WLB[21] WLB[22] WLB[23] mm19a04_u_hs1prf_x4buf
X_mm19a04_u_hs1prf_x4buf_S3 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[24] WL[25]
+   WL[26] WL[27] ARYSD ARYSD_BC1 ARYSD_BC2 DLYPDB EDGEB[6] EDGET[6] LCGTH LOG0
+   LOG1 PROCOML RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[24]
+   WLB[25] WLB[26] WLB[27] mm19a04_u_hs1prf_x4buf
X_mm19a04_u_hs1prf_x4buf_wl_S3 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[28] WL[29]
+   WL[30] WL[31] ARYSD ARYSD_BC1 ARYSD_BC2 DLYPDB EDGEB[7] EDGET[7] LCGTH LOG0
+   LOG1 PROCOML RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[28]
+   WLB[29] WLB[30] WLB[31] mm19a04_u_hs1prf_x4buf
X_mm19a04_u_hs1prf_x4buf_F3 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[32] WL[33]
+   WL[34] WL[35] ARYSD ARYSD_BC1 ARYSD_BC2 DLYPDB EDGEB[8] EDGET[8] LCGTH LOG0
+   LOG1 PROCOML RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[32]
+   WLB[33] WLB[34] WLB[35] mm19a04_u_hs1prf_x4buf
X_mm19a04_u_hs1prf_x4buf_wl_F3 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[36] WL[37]
+   WL[38] WL[39] ARYSD ARYSD_BC1 ARYSD_BC2 DLYPDB EDGEB[9] EDGET[9] LCGTH LOG0
+   LOG1 PROCOML RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[36]
+   WLB[37] WLB[38] WLB[39] mm19a04_u_hs1prf_x4buf
X_mm19a04_u_hs1prf_x4buf_F2 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[40] WL[41]
+   WL[42] WL[43] ARYSD ARYSD_BC1 ARYSD_BC2 DLYPDB EDGEB[10] EDGET[10] LCGTH
+   LOG0 LOG1 PROCOML RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[40]
+   WLB[41] WLB[42] WLB[43] mm19a04_u_hs1prf_x4buf
X_mm19a04_u_hs1prf_x4buf_wl_F2 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[44] WL[45]
+   WL[46] WL[47] ARYSD ARYSD_BC1 ARYSD_BC2 DLYPDB EDGEB[11] EDGET[11] LCGTH
+   LOG0 LOG1 PROCOML RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[44]
+   WLB[45] WLB[46] WLB[47] mm19a04_u_hs1prf_x4buf
X_mm19a04_u_hs1prf_x4buf_F1 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[48] WL[49]
+   WL[50] WL[51] ARYSD ARYSD_BC1 ARYSD_BC2 DLYPDB EDGEB[12] EDGET[12] LCGTH
+   LOG0 LOG1 PROCOML RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[48]
+   WLB[49] WLB[50] WLB[51] mm19a04_u_hs1prf_x4buf
X_mm19a04_u_hs1prf_x4buf_wl_F1 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[52] WL[53]
+   WL[54] WL[55] ARYSD ARYSD_BC1 ARYSD_BC2 DLYPDB EDGEB[13] EDGET[13] LCGTH
+   LOG0 LOG1 PROCOML RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[52]
+   WLB[53] WLB[54] WLB[55] mm19a04_u_hs1prf_x4buf
X_mm19a04_u_hs1prf_x4buf_F0 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[56] WL[57]
+   WL[58] WL[59] ARYSD ARYSD_BC1 ARYSD_BC2 DLYPDB EDGEB[14] EDGET[14] LCGTH
+   LOG0 LOG1 PROCOML RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[56]
+   WLB[57] WLB[58] WLB[59] mm19a04_u_hs1prf_x4buf
X_mm19a04_u_hs1prf_x4buf_wl_F0 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[60] WL[61]
+   WL[62] WL[63] ARYSD ARYSD_BC1 ARYSD_BC2 DLYPDB EDGEB[15] EDGET[15] LCGTH
+   LOG0 LOG1 PROCOML RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[60]
+   WLB[61] WLB[62] WLB[63] mm19a04_u_hs1prf_x4buf
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_ary_cnt ARYSDR ARYSD_BC1 ARYSD_BC2 B BYP_VLOAD C
+       CENDP CKGATE DEF_MODE DLYPDB EDGEB EDGET FAST1_MODE FAST2_MODE FLOAT
+       FLOATT FLOAT_RET LBKADR LCGTH LDFTX LITESLP LOG0[0] LOG0[1] LOG1[0]
+       LOG1[1] LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+       LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4]
+       PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6]
+       PCB[7] PROCOML RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] RBLRD RBLWA
+       RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB T1T TEST_RNMB VBA VBN[0]
+       VBN[1] VBP[0] VBP[1] VDDA[0] VDDA[1] VDDF VDDP[0] VDDP[1] VDDPI[0]
+       VDDPI[1] VDDWL VSS[0] VSS[1] VSSWLL VSSWLR WABUF[0] WABUF[1] WABUF[2]
+       WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] WL[0] WL[1] WL[2] WL[3] WL[4] WL[5]
+       WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13] WL[14] WL[15] WL[16]
+       WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23] WL[24] WL[25] WL[26]
+       WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33] WL[34] WL[35] WL[36]
+       WL[37] WL[38] WL[39] WL[40] WL[41] WL[42] WL[43] WL[44] WL[45] WL[46]
+       WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53] WL[54] WL[55] WL[56]
+       WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63] WMT[0] WMT[1] WMT[2]
+       WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]
*X_ary_cd0 SNPS_RF_SP_UHS_256x28_ary_cd0
X_ary_xdec B BYP_VLOAD C CENDP CKGATE DEC_HV[0] DEC_HV[1] DEC_HV[2] DEC_HV[3]
+   DEC_HV[4] DEC_HV[5] DEC_HV[6] DEC_HV[7] DEC_HV[8] DEC_HV[9] DEC_HV[10]
+   DEC_HV[11] DEC_HV[12] DEC_HV[13] DEC_HV[14] DEC_HV[15] DEC_HV[0] DEC_HV[1]
+   DEC_HV[2] DEC_HV[3] DEC_HV[4] DEC_HV[5] DEC_HV[6] DEC_HV[7] DEC_HV[8]
+   DEC_HV[9] DEC_HV[10] DEC_HV[11] DEC_HV[12] DEC_HV[13] DEC_HV[14] DEC_HV[15]
+   DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR LDFTX LITESLP
+   LOG0[0] LOG1[0] LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+   LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4]
+   PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7]
+   RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB T1T TEST_RNMB
+   VBN[0] VBP[0] VDDA[0] VDDF VDDP[0] VDDPI[0] VDDWL VDDWL VDDWL VDDWL VDDWL
+   VDDWL VDDWL VDDWL VDDWL VDDWL VDDWL VDDWL VDDWL VDDWL VDDWL VDDWL VSS[0]
+   VSSWLL VSSWLR WABUF[0] WABUF[1] WABUF[2] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   WLBH[0] WLBH[1] WLBH[2] WLBH[3] WLBH[4] WLBH[5] WLBH[6] WLBH[7] WLBH[8]
+   WLBH[9] WLBH[10] WLBH[11] WLBH[12] WLBH[13] WLBH[14] WLBH[15] WLBH[16]
+   WLBH[17] WLBH[18] WLBH[19] WLBH[20] WLBH[21] WLBH[22] WLBH[23] WLBH[24]
+   WLBH[25] WLBH[26] WLBH[27] WLBH[28] WLBH[29] WLBH[30] WLBH[31] WLBH[32]
+   WLBH[33] WLBH[34] WLBH[35] WLBH[36] WLBH[37] WLBH[38] WLBH[39] WLBH[40]
+   WLBH[41] WLBH[42] WLBH[43] WLBH[44] WLBH[45] WLBH[46] WLBH[47] WLBH[48]
+   WLBH[49] WLBH[50] WLBH[51] WLBH[52] WLBH[53] WLBH[54] WLBH[55] WLBH[56]
+   WLBH[57] WLBH[58] WLBH[59] WLBH[60] WLBH[61] WLBH[62] WLBH[63] WLBL[0]
+   WLBL[1] WLBL[2] WLBL[3] WLBL[4] WLBL[5] WLBL[6] WLBL[7] WLBL[8] WLBL[9]
+   WLBL[10] WLBL[11] WLBL[12] WLBL[13] WLBL[14] WLBL[15] WLBL[16] WLBL[17]
+   WLBL[18] WLBL[19] WLBL[20] WLBL[21] WLBL[22] WLBL[23] WLBL[24] WLBL[25]
+   WLBL[26] WLBL[27] WLBL[28] WLBL[29] WLBL[30] WLBL[31] WLBL[32] WLBL[33]
+   WLBL[34] WLBL[35] WLBL[36] WLBL[37] WLBL[38] WLBL[39] WLBL[40] WLBL[41]
+   WLBL[42] WLBL[43] WLBL[44] WLBL[45] WLBL[46] WLBL[47] WLBL[48] WLBL[49]
+   WLBL[50] WLBL[51] WLBL[52] WLBL[53] WLBL[54] WLBL[55] WLBL[56] WLBL[57]
+   WLBL[58] WLBL[59] WLBL[60] WLBL[61] WLBL[62] WLBL[63] WMT[0] WMT[1] WMT[2]
+   WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] SNPS_RF_SP_UHS_256x28_ary_xdec
X_ary_buf ARYSDR ARYSD_BC1 ARYSD_BC2 DLYPDB EDGEB EDGET LCGTH LOG0[1] LOG1[1]
+   PROCOML RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA VBN[1] VBP[1]
+   VDDA[1] VDDP[1] VDDPI[1] VDDWL VSS[1] WL[0] WL[1] WL[2] WL[3] WL[4] WL[5]
+   WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13] WL[14] WL[15] WL[16]
+   WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23] WL[24] WL[25] WL[26] WL[27]
+   WL[28] WL[29] WL[30] WL[31] WL[32] WL[33] WL[34] WL[35] WL[36] WL[37] WL[38]
+   WL[39] WL[40] WL[41] WL[42] WL[43] WL[44] WL[45] WL[46] WL[47] WL[48] WL[49]
+   WL[50] WL[51] WL[52] WL[53] WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60]
+   WL[61] WL[62] WL[63] WLBH[0] WLBH[1] WLBH[2] WLBH[3] WLBH[4] WLBH[5] WLBH[6]
+   WLBH[7] WLBH[8] WLBH[9] WLBH[10] WLBH[11] WLBH[12] WLBH[13] WLBH[14]
+   WLBH[15] WLBH[16] WLBH[17] WLBH[18] WLBH[19] WLBH[20] WLBH[21] WLBH[22]
+   WLBH[23] WLBH[24] WLBH[25] WLBH[26] WLBH[27] WLBH[28] WLBH[29] WLBH[30]
+   WLBH[31] WLBH[32] WLBH[33] WLBH[34] WLBH[35] WLBH[36] WLBH[37] WLBH[38]
+   WLBH[39] WLBH[40] WLBH[41] WLBH[42] WLBH[43] WLBH[44] WLBH[45] WLBH[46]
+   WLBH[47] WLBH[48] WLBH[49] WLBH[50] WLBH[51] WLBH[52] WLBH[53] WLBH[54]
+   WLBH[55] WLBH[56] WLBH[57] WLBH[58] WLBH[59] WLBH[60] WLBH[61] WLBH[62]
+   WLBH[63] SNPS_RF_SP_UHS_256x28_ary_buf
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_ary_rt_seg1 BADB[0] BADB[1] BADB[2] BADB[3]
+       BADB[4] BADB[5] BADB[6] BADB[7] BADB[8] BADB[9] BADB[10] BADB[11]
+       BADB[12] BADB[13] BADB[14] BADB[15] BADB[16] BADB[17] BADB[18] BADB[19]
+       BADB[20] BADB[21] BADB[22] BADB[23] BADB[24] BADB[25] BADB[26] BADB[27]
+       BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+       BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20]
+       BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30]
+       BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40]
+       BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50]
+       BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60]
+       BB[61] BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70]
+       BB[71] BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80]
+       BB[81] BB[82] BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90]
+       BB[91] BB[92] BB[93] BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100]
+       BB[101] BB[102] BB[103] BB[104] BB[105] BB[106] BB[107] BB[108] BB[109]
+       BB[110] BB[111] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8]
+       BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16] BT[17] BT[18]
+       BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28]
+       BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35] BT[36] BT[37] BT[38]
+       BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47] BT[48]
+       BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57] BT[58]
+       BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68]
+       BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78]
+       BT[79] BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88]
+       BT[89] BT[90] BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98]
+       BT[99] BT[100] BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107]
+       BT[108] BT[109] BT[110] BT[111] LQB[0] LQB[1] LQB[2] LQB[3] LQB[4]
+       LQB[5] LQB[6] LQB[7] LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13]
+       LQB[14] LQB[15] LQB[16] LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22]
+       LQB[23] LQB[24] LQB[25] LQB[26] LQB[27] VBA[0] VBA[1] VBA[2] VBA[3]
+       VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12]
+       VBA[13] VBA[14] VBA[15] VBA[16] VBA[17] VBA[18] VBA[19] VBA[20] VBA[21]
+       VBA[22] VBA[23] VBA[24] VBA[25] VBA[26] VBA[27] VBN[0] VBN[1] VBN[2]
+       VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12]
+       VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20] VBN[21]
+       VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBP[0] VBP[1] VBP[2]
+       VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+       VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21]
+       VBP[22] VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VDDA[0] VDDA[1] VDDA[2]
+       VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10]
+       VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17] VDDA[18]
+       VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24] VDDA[25] VDDA[26]
+       VDDA[27] VDDAI[0] VDDAI[1] VDDAI[2] VDDAI[3] VDDAI[4] VDDAI[5] VDDAI[6]
+       VDDAI[7] VDDAI[8] VDDAI[9] VDDAI[10] VDDAI[11] VDDAI[12] VDDAI[13]
+       VDDAI[14] VDDAI[15] VDDAI[16] VDDAI[17] VDDAI[18] VDDAI[19] VDDAI[20]
+       VDDAI[21] VDDAI[22] VDDAI[23] VDDAI[24] VDDAI[25] VDDAI[26] VDDAI[27]
+       VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8]
+       VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16]
+       VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24]
+       VDDP[25] VDDP[26] VDDP[27] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+       VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+       VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18]
+       VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25]
+       VDDPI[26] VDDPI[27] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6]
+       VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15]
+       VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24]
+       VSS[25] VSS[26] VSS[27] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+       WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+       WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24]
+       WBI[25] WBI[26] WBI[27] WL[0] WL[1] WL[2] WL[3] WTI[0] WTI[1] WTI[2]
+       WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12]
+       WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21]
+       WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27]
X_mm19a04_u_hs1prf_ar4x4m4_S0 VDDA[0] VDDAI[0] VDDP[0] VDDPI[0] VSS[0] VBP[0]
+   VBN[0] BADB[0] BB[0] BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3] LQB[0] VBA[0]
+   WBI[0] WTI[0] WL[0] WL[1] WL[2] WL[3] mm19a04_u_hs1prf_ar4x4m4
X_mm19a04_u_hs1prf_ar4x4m4_S1 VDDA[1] VDDAI[1] VDDP[1] VDDPI[1] VSS[1] VBP[1]
+   VBN[1] BADB[1] BB[4] BB[5] BB[6] BB[7] BT[4] BT[5] BT[6] BT[7] LQB[1] VBA[1]
+   WBI[1] WTI[1] WL[0] WL[1] WL[2] WL[3] mm19a04_u_hs1prf_ar4x4m4
X_mm19a04_u_hs1prf_ar4x4m4_S2 VDDA[2] VDDAI[2] VDDP[2] VDDPI[2] VSS[2] VBP[2]
+   VBN[2] BADB[2] BB[8] BB[9] BB[10] BB[11] BT[8] BT[9] BT[10] BT[11] LQB[2]
+   VBA[2] WBI[2] WTI[2] WL[0] WL[1] WL[2] WL[3] mm19a04_u_hs1prf_ar4x4m4
X_mm19a04_u_hs1prf_ar4x4m4_S3 VDDA[3] VDDAI[3] VDDP[3] VDDPI[3] VSS[3] VBP[3]
+   VBN[3] BADB[3] BB[12] BB[13] BB[14] BB[15] BT[12] BT[13] BT[14] BT[15]
+   LQB[3] VBA[3] WBI[3] WTI[3] WL[0] WL[1] WL[2] WL[3] mm19a04_u_hs1prf_ar4x4m4
X_mm19a04_u_hs1prf_ar4x4m4_S4 VDDA[4] VDDAI[4] VDDP[4] VDDPI[4] VSS[4] VBP[4]
+   VBN[4] BADB[4] BB[16] BB[17] BB[18] BB[19] BT[16] BT[17] BT[18] BT[19]
+   LQB[4] VBA[4] WBI[4] WTI[4] WL[0] WL[1] WL[2] WL[3] mm19a04_u_hs1prf_ar4x4m4
X_mm19a04_u_hs1prf_ar4x4m4_S5 VDDA[5] VDDAI[5] VDDP[5] VDDPI[5] VSS[5] VBP[5]
+   VBN[5] BADB[5] BB[20] BB[21] BB[22] BB[23] BT[20] BT[21] BT[22] BT[23]
+   LQB[5] VBA[5] WBI[5] WTI[5] WL[0] WL[1] WL[2] WL[3] mm19a04_u_hs1prf_ar4x4m4
X_mm19a04_u_hs1prf_ar4x4m4_S6 VDDA[6] VDDAI[6] VDDP[6] VDDPI[6] VSS[6] VBP[6]
+   VBN[6] BADB[6] BB[24] BB[25] BB[26] BB[27] BT[24] BT[25] BT[26] BT[27]
+   LQB[6] VBA[6] WBI[6] WTI[6] WL[0] WL[1] WL[2] WL[3] mm19a04_u_hs1prf_ar4x4m4
X_mm19a04_u_hs1prf_ar4x4m4_S7 VDDA[7] VDDAI[7] VDDP[7] VDDPI[7] VSS[7] VBP[7]
+   VBN[7] BADB[7] BB[28] BB[29] BB[30] BB[31] BT[28] BT[29] BT[30] BT[31]
+   LQB[7] VBA[7] WBI[7] WTI[7] WL[0] WL[1] WL[2] WL[3] mm19a04_u_hs1prf_ar4x4m4
X_mm19a04_u_hs1prf_ar4x4m4_S8 VDDA[8] VDDAI[8] VDDP[8] VDDPI[8] VSS[8] VBP[8]
+   VBN[8] BADB[8] BB[32] BB[33] BB[34] BB[35] BT[32] BT[33] BT[34] BT[35]
+   LQB[8] VBA[8] WBI[8] WTI[8] WL[0] WL[1] WL[2] WL[3] mm19a04_u_hs1prf_ar4x4m4
X_mm19a04_u_hs1prf_ar4x4m4_S9 VDDA[9] VDDAI[9] VDDP[9] VDDPI[9] VSS[9] VBP[9]
+   VBN[9] BADB[9] BB[36] BB[37] BB[38] BB[39] BT[36] BT[37] BT[38] BT[39]
+   LQB[9] VBA[9] WBI[9] WTI[9] WL[0] WL[1] WL[2] WL[3] mm19a04_u_hs1prf_ar4x4m4
X_mm19a04_u_hs1prf_ar4x4m4_S10 VDDA[10] VDDAI[10] VDDP[10] VDDPI[10] VSS[10]
+   VBP[10] VBN[10] BADB[10] BB[40] BB[41] BB[42] BB[43] BT[40] BT[41] BT[42]
+   BT[43] LQB[10] VBA[10] WBI[10] WTI[10] WL[0] WL[1] WL[2] WL[3]
+   mm19a04_u_hs1prf_ar4x4m4
X_mm19a04_u_hs1prf_ar4x4m4_S11 VDDA[11] VDDAI[11] VDDP[11] VDDPI[11] VSS[11]
+   VBP[11] VBN[11] BADB[11] BB[44] BB[45] BB[46] BB[47] BT[44] BT[45] BT[46]
+   BT[47] LQB[11] VBA[11] WBI[11] WTI[11] WL[0] WL[1] WL[2] WL[3]
+   mm19a04_u_hs1prf_ar4x4m4
X_mm19a04_u_hs1prf_ar4x4m4_S12 VDDA[12] VDDAI[12] VDDP[12] VDDPI[12] VSS[12]
+   VBP[12] VBN[12] BADB[12] BB[48] BB[49] BB[50] BB[51] BT[48] BT[49] BT[50]
+   BT[51] LQB[12] VBA[12] WBI[12] WTI[12] WL[0] WL[1] WL[2] WL[3]
+   mm19a04_u_hs1prf_ar4x4m4
X_mm19a04_u_hs1prf_ar4x4m4_S13 VDDA[13] VDDAI[13] VDDP[13] VDDPI[13] VSS[13]
+   VBP[13] VBN[13] BADB[13] BB[52] BB[53] BB[54] BB[55] BT[52] BT[53] BT[54]
+   BT[55] LQB[13] VBA[13] WBI[13] WTI[13] WL[0] WL[1] WL[2] WL[3]
+   mm19a04_u_hs1prf_ar4x4m4
X_mm19a04_u_hs1prf_ar4x4m4_F13 VDDA[14] VDDAI[14] VDDP[14] VDDPI[14] VSS[14]
+   VBP[14] VBN[14] BADB[14] BB[56] BB[57] BB[58] BB[59] BT[56] BT[57] BT[58]
+   BT[59] LQB[14] VBA[14] WBI[14] WTI[14] WL[0] WL[1] WL[2] WL[3]
+   mm19a04_u_hs1prf_ar4x4m4
X_mm19a04_u_hs1prf_ar4x4m4_F12 VDDA[15] VDDAI[15] VDDP[15] VDDPI[15] VSS[15]
+   VBP[15] VBN[15] BADB[15] BB[60] BB[61] BB[62] BB[63] BT[60] BT[61] BT[62]
+   BT[63] LQB[15] VBA[15] WBI[15] WTI[15] WL[0] WL[1] WL[2] WL[3]
+   mm19a04_u_hs1prf_ar4x4m4
X_mm19a04_u_hs1prf_ar4x4m4_F11 VDDA[16] VDDAI[16] VDDP[16] VDDPI[16] VSS[16]
+   VBP[16] VBN[16] BADB[16] BB[64] BB[65] BB[66] BB[67] BT[64] BT[65] BT[66]
+   BT[67] LQB[16] VBA[16] WBI[16] WTI[16] WL[0] WL[1] WL[2] WL[3]
+   mm19a04_u_hs1prf_ar4x4m4
X_mm19a04_u_hs1prf_ar4x4m4_F10 VDDA[17] VDDAI[17] VDDP[17] VDDPI[17] VSS[17]
+   VBP[17] VBN[17] BADB[17] BB[68] BB[69] BB[70] BB[71] BT[68] BT[69] BT[70]
+   BT[71] LQB[17] VBA[17] WBI[17] WTI[17] WL[0] WL[1] WL[2] WL[3]
+   mm19a04_u_hs1prf_ar4x4m4
X_mm19a04_u_hs1prf_ar4x4m4_F9 VDDA[18] VDDAI[18] VDDP[18] VDDPI[18] VSS[18]
+   VBP[18] VBN[18] BADB[18] BB[72] BB[73] BB[74] BB[75] BT[72] BT[73] BT[74]
+   BT[75] LQB[18] VBA[18] WBI[18] WTI[18] WL[0] WL[1] WL[2] WL[3]
+   mm19a04_u_hs1prf_ar4x4m4
X_mm19a04_u_hs1prf_ar4x4m4_F8 VDDA[19] VDDAI[19] VDDP[19] VDDPI[19] VSS[19]
+   VBP[19] VBN[19] BADB[19] BB[76] BB[77] BB[78] BB[79] BT[76] BT[77] BT[78]
+   BT[79] LQB[19] VBA[19] WBI[19] WTI[19] WL[0] WL[1] WL[2] WL[3]
+   mm19a04_u_hs1prf_ar4x4m4
X_mm19a04_u_hs1prf_ar4x4m4_F7 VDDA[20] VDDAI[20] VDDP[20] VDDPI[20] VSS[20]
+   VBP[20] VBN[20] BADB[20] BB[80] BB[81] BB[82] BB[83] BT[80] BT[81] BT[82]
+   BT[83] LQB[20] VBA[20] WBI[20] WTI[20] WL[0] WL[1] WL[2] WL[3]
+   mm19a04_u_hs1prf_ar4x4m4
X_mm19a04_u_hs1prf_ar4x4m4_F6 VDDA[21] VDDAI[21] VDDP[21] VDDPI[21] VSS[21]
+   VBP[21] VBN[21] BADB[21] BB[84] BB[85] BB[86] BB[87] BT[84] BT[85] BT[86]
+   BT[87] LQB[21] VBA[21] WBI[21] WTI[21] WL[0] WL[1] WL[2] WL[3]
+   mm19a04_u_hs1prf_ar4x4m4
X_mm19a04_u_hs1prf_ar4x4m4_F5 VDDA[22] VDDAI[22] VDDP[22] VDDPI[22] VSS[22]
+   VBP[22] VBN[22] BADB[22] BB[88] BB[89] BB[90] BB[91] BT[88] BT[89] BT[90]
+   BT[91] LQB[22] VBA[22] WBI[22] WTI[22] WL[0] WL[1] WL[2] WL[3]
+   mm19a04_u_hs1prf_ar4x4m4
X_mm19a04_u_hs1prf_ar4x4m4_F4 VDDA[23] VDDAI[23] VDDP[23] VDDPI[23] VSS[23]
+   VBP[23] VBN[23] BADB[23] BB[92] BB[93] BB[94] BB[95] BT[92] BT[93] BT[94]
+   BT[95] LQB[23] VBA[23] WBI[23] WTI[23] WL[0] WL[1] WL[2] WL[3]
+   mm19a04_u_hs1prf_ar4x4m4
X_mm19a04_u_hs1prf_ar4x4m4_F3 VDDA[24] VDDAI[24] VDDP[24] VDDPI[24] VSS[24]
+   VBP[24] VBN[24] BADB[24] BB[96] BB[97] BB[98] BB[99] BT[96] BT[97] BT[98]
+   BT[99] LQB[24] VBA[24] WBI[24] WTI[24] WL[0] WL[1] WL[2] WL[3]
+   mm19a04_u_hs1prf_ar4x4m4
X_mm19a04_u_hs1prf_ar4x4m4_F2 VDDA[25] VDDAI[25] VDDP[25] VDDPI[25] VSS[25]
+   VBP[25] VBN[25] BADB[25] BB[100] BB[101] BB[102] BB[103] BT[100] BT[101]
+   BT[102] BT[103] LQB[25] VBA[25] WBI[25] WTI[25] WL[0] WL[1] WL[2] WL[3]
+   mm19a04_u_hs1prf_ar4x4m4
X_mm19a04_u_hs1prf_ar4x4m4_F1 VDDA[26] VDDAI[26] VDDP[26] VDDPI[26] VSS[26]
+   VBP[26] VBN[26] BADB[26] BB[104] BB[105] BB[106] BB[107] BT[104] BT[105]
+   BT[106] BT[107] LQB[26] VBA[26] WBI[26] WTI[26] WL[0] WL[1] WL[2] WL[3]
+   mm19a04_u_hs1prf_ar4x4m4
X_mm19a04_u_hs1prf_ar4x4m4_F0 VDDA[27] VDDAI[27] VDDP[27] VDDPI[27] VSS[27]
+   VBP[27] VBN[27] BADB[27] BB[108] BB[109] BB[110] BB[111] BT[108] BT[109]
+   BT[110] BT[111] LQB[27] VBA[27] WBI[27] WTI[27] WL[0] WL[1] WL[2] WL[3]
+   mm19a04_u_hs1prf_ar4x4m4
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_ary_rt BADB[0] BADB[1] BADB[2] BADB[3] BADB[4]
+       BADB[5] BADB[6] BADB[7] BADB[8] BADB[9] BADB[10] BADB[11] BADB[12]
+       BADB[13] BADB[14] BADB[15] BADB[16] BADB[17] BADB[18] BADB[19] BADB[20]
+       BADB[21] BADB[22] BADB[23] BADB[24] BADB[25] BADB[26] BADB[27] BB[0]
+       BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11]
+       BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+       BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31]
+       BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41]
+       BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51]
+       BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61]
+       BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+       BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81]
+       BB[82] BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91]
+       BB[92] BB[93] BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101]
+       BB[102] BB[103] BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110]
+       BB[111] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9]
+       BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19]
+       BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28] BT[29]
+       BT[30] BT[31] BT[32] BT[33] BT[34] BT[35] BT[36] BT[37] BT[38] BT[39]
+       BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47] BT[48] BT[49]
+       BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57] BT[58] BT[59]
+       BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68] BT[69]
+       BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79]
+       BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89]
+       BT[90] BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99]
+       BT[100] BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108]
+       BT[109] BT[110] BT[111] LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6]
+       LQB[7] LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15]
+       LQB[16] LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24]
+       LQB[25] LQB[26] LQB[27] PGIOIR VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+       VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14]
+       VBA[15] VBA[16] VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23]
+       VBA[24] VBA[25] VBA[26] VBA[27] VBA[28] VBN[0] VBN[1] VBN[2] VBN[3]
+       VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12]
+       VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20] VBN[21]
+       VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28] VBP[0] VBP[1]
+       VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+       VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20]
+       VBP[21] VBP[22] VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VDDA[0]
+       VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9]
+       VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17]
+       VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24] VDDA[25]
+       VDDA[26] VDDA[27] VDDA[28] VDDAI_H_T1[0] VDDAI_H_T1[1] VDDAI_H_T1[2]
+       VDDAI_H_T1[3] VDDAI_H_T1[4] VDDAI_H_T1[5] VDDAI_H_T1[6] VDDAI_H_T1[7]
+       VDDAI_H_T1[8] VDDAI_H_T1[9] VDDAI_H_T1[10] VDDAI_H_T1[11] VDDAI_H_T1[12]
+       VDDAI_H_T1[13] VDDAI_H_T1[14] VDDAI_H_T1[15] VDDAI_H_T1[16]
+       VDDAI_H_T1[17] VDDAI_H_T1[18] VDDAI_H_T1[19] VDDAI_H_T1[20]
+       VDDAI_H_T1[21] VDDAI_H_T1[22] VDDAI_H_T1[23] VDDAI_H_T1[24]
+       VDDAI_H_T1[25] VDDAI_H_T1[26] VDDAI_H_T1[27] VDDAI_H_T1[28] VDDP[0]
+       VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9]
+       VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17]
+       VDDP[18] VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25]
+       VDDP[26] VDDP[27] VDDP[28] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+       VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+       VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18]
+       VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25]
+       VDDPI[26] VDDPI[27] VEDGE_O VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+       VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14]
+       VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23]
+       VSS[24] VSS[25] VSS[26] VSS[27] VSS[28] WBI[0] WBI[1] WBI[2] WBI[3]
+       WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12]
+       WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21]
+       WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27] WL[0] WL[1] WL[2] WL[3]
+       WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9]
+       WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18]
+       WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27]
X_ary_rt_seg1 BADB[0] BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7]
+   BADB[8] BADB[9] BADB[10] BADB[11] BADB[12] BADB[13] BADB[14] BADB[15]
+   BADB[16] BADB[17] BADB[18] BADB[19] BADB[20] BADB[21] BADB[22] BADB[23]
+   BADB[24] BADB[25] BADB[26] BADB[27] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5]
+   BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+   BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27]
+   BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38]
+   BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49]
+   BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60]
+   BB[61] BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+   BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82]
+   BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93]
+   BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103]
+   BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68]
+   BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79]
+   BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90]
+   BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100]
+   BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109]
+   BT[110] BT[111] LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7]
+   LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16]
+   LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25]
+   LQB[26] LQB[27] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23] VBA[24] VBA[25]
+   VBA[26] VBA[27] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7]
+   VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+   VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25]
+   VBN[26] VBN[27] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7]
+   VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+   VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+   VBP[26] VBP[27] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6]
+   VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+   VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22]
+   VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDAI_H_T1[0] VDDAI_H_T1[1]
+   VDDAI_H_T1[2] VDDAI_H_T1[3] VDDAI_H_T1[4] VDDAI_H_T1[5] VDDAI_H_T1[6]
+   VDDAI_H_T1[7] VDDAI_H_T1[8] VDDAI_H_T1[9] VDDAI_H_T1[10] VDDAI_H_T1[11]
+   VDDAI_H_T1[12] VDDAI_H_T1[13] VDDAI_H_T1[14] VDDAI_H_T1[15] VDDAI_H_T1[16]
+   VDDAI_H_T1[17] VDDAI_H_T1[18] VDDAI_H_T1[19] VDDAI_H_T1[20] VDDAI_H_T1[21]
+   VDDAI_H_T1[22] VDDAI_H_T1[23] VDDAI_H_T1[24] VDDAI_H_T1[25] VDDAI_H_T1[26]
+   VDDAI_H_T1[27] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6]
+   VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14]
+   VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21] VDDP[22]
+   VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDPI[0] VDDPI[1] VDDPI[2]
+   VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+   VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17]
+   VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24]
+   VDDPI[25] VDDPI[26] VDDPI[27] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+   VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15]
+   VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24]
+   VSS[25] VSS[26] VSS[27] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+   WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16]
+   WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25]
+   WBI[26] WBI[27] WL[0] WL[1] WL[2] WL[3] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4]
+   WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14]
+   WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23]
+   WTI[24] WTI[25] WTI[26] WTI[27] SNPS_RF_SP_UHS_256x28_ary_rt_seg1
X_mm19a04_u_edge4_hs1prf VDDA[28] VDDAI_H_T1[28] VDDP[28] VSS[28] VBP[28]
+   VBN[28] PGIOIR VBA[28] VEDGE_O WL[0] WL[1] WL[2] WL[3]
+   mm19a04_u_edge4_hs1prf
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_ary_right BADB[0] BADB[1] BADB[2] BADB[3] BADB[4]
+       BADB[5] BADB[6] BADB[7] BADB[8] BADB[9] BADB[10] BADB[11] BADB[12]
+       BADB[13] BADB[14] BADB[15] BADB[16] BADB[17] BADB[18] BADB[19] BADB[20]
+       BADB[21] BADB[22] BADB[23] BADB[24] BADB[25] BADB[26] BADB[27] BB[0]
+       BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11]
+       BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+       BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31]
+       BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41]
+       BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51]
+       BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61]
+       BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+       BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81]
+       BB[82] BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91]
+       BB[92] BB[93] BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101]
+       BB[102] BB[103] BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110]
+       BB[111] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9]
+       BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19]
+       BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28] BT[29]
+       BT[30] BT[31] BT[32] BT[33] BT[34] BT[35] BT[36] BT[37] BT[38] BT[39]
+       BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47] BT[48] BT[49]
+       BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57] BT[58] BT[59]
+       BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68] BT[69]
+       BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79]
+       BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89]
+       BT[90] BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99]
+       BT[100] BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108]
+       BT[109] BT[110] BT[111] LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6]
+       LQB[7] LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15]
+       LQB[16] LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24]
+       LQB[25] LQB[26] LQB[27] PGIOIR VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+       VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14]
+       VBA[15] VBA[16] VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23]
+       VBA[24] VBA[25] VBA[26] VBA[27] VBA[28] VBN[0] VBN[1] VBN[2] VBN[3]
+       VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12]
+       VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20] VBN[21]
+       VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28] VBP[0] VBP[1]
+       VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+       VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20]
+       VBP[21] VBP[22] VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VDDA[0]
+       VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9]
+       VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17]
+       VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24] VDDA[25]
+       VDDA[26] VDDA[27] VDDA[28] VDDAI_H_T1[0] VDDAI_H_T1[1] VDDAI_H_T1[2]
+       VDDAI_H_T1[3] VDDAI_H_T1[4] VDDAI_H_T1[5] VDDAI_H_T1[6] VDDAI_H_T1[7]
+       VDDAI_H_T1[8] VDDAI_H_T1[9] VDDAI_H_T1[10] VDDAI_H_T1[11] VDDAI_H_T1[12]
+       VDDAI_H_T1[13] VDDAI_H_T1[14] VDDAI_H_T1[15] VDDAI_H_T1[16]
+       VDDAI_H_T1[17] VDDAI_H_T1[18] VDDAI_H_T1[19] VDDAI_H_T1[20]
+       VDDAI_H_T1[21] VDDAI_H_T1[22] VDDAI_H_T1[23] VDDAI_H_T1[24]
+       VDDAI_H_T1[25] VDDAI_H_T1[26] VDDAI_H_T1[27] VDDAI_H_T1[28] VDDP[0]
+       VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9]
+       VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17]
+       VDDP[18] VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25]
+       VDDP[26] VDDP[27] VDDP[28] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+       VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+       VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18]
+       VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25]
+       VDDPI[26] VDDPI[27] VEDGE_O VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+       VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14]
+       VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23]
+       VSS[24] VSS[25] VSS[26] VSS[27] VSS[28] WBI[0] WBI[1] WBI[2] WBI[3]
+       WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12]
+       WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21]
+       WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27] WL[0] WL[1] WL[2] WL[3]
+       WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13] WL[14]
+       WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23] WL[24]
+       WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33] WL[34]
+       WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42] WL[43] WL[44]
+       WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53] WL[54]
+       WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63] WTI[0]
+       WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10]
+       WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19]
+       WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27]
X_ary_rt_S0 BADB[0] BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7]
+   BADB[8] BADB[9] BADB[10] BADB[11] BADB[12] BADB[13] BADB[14] BADB[15]
+   BADB[16] BADB[17] BADB[18] BADB[19] BADB[20] BADB[21] BADB[22] BADB[23]
+   BADB[24] BADB[25] BADB[26] BADB[27] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5]
+   BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+   BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27]
+   BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38]
+   BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49]
+   BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60]
+   BB[61] BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+   BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82]
+   BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93]
+   BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103]
+   BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68]
+   BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79]
+   BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90]
+   BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100]
+   BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109]
+   BT[110] BT[111] LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7]
+   LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16]
+   LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25]
+   LQB[26] LQB[27] PGIOIR VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23] VBA[24] VBA[25]
+   VBA[26] VBA[27] VBA[28] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+   VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+   VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25]
+   VBN[26] VBN[27] VBN[28] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+   VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+   VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+   VBP[26] VBP[27] VBP[28] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5]
+   VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+   VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22]
+   VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDAI_H_T1[0]
+   VDDAI_H_T1[1] VDDAI_H_T1[2] VDDAI_H_T1[3] VDDAI_H_T1[4] VDDAI_H_T1[5]
+   VDDAI_H_T1[6] VDDAI_H_T1[7] VDDAI_H_T1[8] VDDAI_H_T1[9] VDDAI_H_T1[10]
+   VDDAI_H_T1[11] VDDAI_H_T1[12] VDDAI_H_T1[13] VDDAI_H_T1[14] VDDAI_H_T1[15]
+   VDDAI_H_T1[16] VDDAI_H_T1[17] VDDAI_H_T1[18] VDDAI_H_T1[19] VDDAI_H_T1[20]
+   VDDAI_H_T1[21] VDDAI_H_T1[22] VDDAI_H_T1[23] VDDAI_H_T1[24] VDDAI_H_T1[25]
+   VDDAI_H_T1[26] VDDAI_H_T1[27] VDDAI_H_T1[28] VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20]
+   VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28]
+   VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+   VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+   VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21]
+   VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VEDGE_O VSS[0]
+   VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+   VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19]
+   VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28]
+   WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9]
+   WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18]
+   WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27]
+   WL[0] WL[1] WL[2] WL[3] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16]
+   WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25]
+   WTI[26] WTI[27] SNPS_RF_SP_UHS_256x28_ary_rt
X_ary_rt_S1 BADB[0] BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7]
+   BADB[8] BADB[9] BADB[10] BADB[11] BADB[12] BADB[13] BADB[14] BADB[15]
+   BADB[16] BADB[17] BADB[18] BADB[19] BADB[20] BADB[21] BADB[22] BADB[23]
+   BADB[24] BADB[25] BADB[26] BADB[27] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5]
+   BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+   BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27]
+   BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38]
+   BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49]
+   BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60]
+   BB[61] BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+   BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82]
+   BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93]
+   BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103]
+   BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68]
+   BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79]
+   BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90]
+   BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100]
+   BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109]
+   BT[110] BT[111] LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7]
+   LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16]
+   LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25]
+   LQB[26] LQB[27] PGIOIR VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23] VBA[24] VBA[25]
+   VBA[26] VBA[27] VBA[28] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+   VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+   VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25]
+   VBN[26] VBN[27] VBN[28] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+   VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+   VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+   VBP[26] VBP[27] VBP[28] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5]
+   VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+   VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22]
+   VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDAI_H_T1[0]
+   VDDAI_H_T1[1] VDDAI_H_T1[2] VDDAI_H_T1[3] VDDAI_H_T1[4] VDDAI_H_T1[5]
+   VDDAI_H_T1[6] VDDAI_H_T1[7] VDDAI_H_T1[8] VDDAI_H_T1[9] VDDAI_H_T1[10]
+   VDDAI_H_T1[11] VDDAI_H_T1[12] VDDAI_H_T1[13] VDDAI_H_T1[14] VDDAI_H_T1[15]
+   VDDAI_H_T1[16] VDDAI_H_T1[17] VDDAI_H_T1[18] VDDAI_H_T1[19] VDDAI_H_T1[20]
+   VDDAI_H_T1[21] VDDAI_H_T1[22] VDDAI_H_T1[23] VDDAI_H_T1[24] VDDAI_H_T1[25]
+   VDDAI_H_T1[26] VDDAI_H_T1[27] VDDAI_H_T1[28] VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20]
+   VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28]
+   VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+   VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+   VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21]
+   VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VEDGE_O VSS[0]
+   VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+   VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19]
+   VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28]
+   WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9]
+   WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18]
+   WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27]
+   WL[4] WL[5] WL[6] WL[7] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16]
+   WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25]
+   WTI[26] WTI[27] SNPS_RF_SP_UHS_256x28_ary_rt
X_ary_rt_S2 BADB[0] BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7]
+   BADB[8] BADB[9] BADB[10] BADB[11] BADB[12] BADB[13] BADB[14] BADB[15]
+   BADB[16] BADB[17] BADB[18] BADB[19] BADB[20] BADB[21] BADB[22] BADB[23]
+   BADB[24] BADB[25] BADB[26] BADB[27] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5]
+   BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+   BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27]
+   BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38]
+   BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49]
+   BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60]
+   BB[61] BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+   BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82]
+   BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93]
+   BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103]
+   BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68]
+   BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79]
+   BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90]
+   BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100]
+   BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109]
+   BT[110] BT[111] LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7]
+   LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16]
+   LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25]
+   LQB[26] LQB[27] PGIOIR VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23] VBA[24] VBA[25]
+   VBA[26] VBA[27] VBA[28] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+   VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+   VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25]
+   VBN[26] VBN[27] VBN[28] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+   VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+   VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+   VBP[26] VBP[27] VBP[28] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5]
+   VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+   VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22]
+   VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDAI_H_T1[0]
+   VDDAI_H_T1[1] VDDAI_H_T1[2] VDDAI_H_T1[3] VDDAI_H_T1[4] VDDAI_H_T1[5]
+   VDDAI_H_T1[6] VDDAI_H_T1[7] VDDAI_H_T1[8] VDDAI_H_T1[9] VDDAI_H_T1[10]
+   VDDAI_H_T1[11] VDDAI_H_T1[12] VDDAI_H_T1[13] VDDAI_H_T1[14] VDDAI_H_T1[15]
+   VDDAI_H_T1[16] VDDAI_H_T1[17] VDDAI_H_T1[18] VDDAI_H_T1[19] VDDAI_H_T1[20]
+   VDDAI_H_T1[21] VDDAI_H_T1[22] VDDAI_H_T1[23] VDDAI_H_T1[24] VDDAI_H_T1[25]
+   VDDAI_H_T1[26] VDDAI_H_T1[27] VDDAI_H_T1[28] VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20]
+   VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28]
+   VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+   VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+   VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21]
+   VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VEDGE_O VSS[0]
+   VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+   VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19]
+   VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28]
+   WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9]
+   WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18]
+   WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27]
+   WL[8] WL[9] WL[10] WL[11] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16]
+   WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25]
+   WTI[26] WTI[27] SNPS_RF_SP_UHS_256x28_ary_rt
X_ary_rt_S3 BADB[0] BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7]
+   BADB[8] BADB[9] BADB[10] BADB[11] BADB[12] BADB[13] BADB[14] BADB[15]
+   BADB[16] BADB[17] BADB[18] BADB[19] BADB[20] BADB[21] BADB[22] BADB[23]
+   BADB[24] BADB[25] BADB[26] BADB[27] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5]
+   BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+   BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27]
+   BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38]
+   BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49]
+   BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60]
+   BB[61] BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+   BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82]
+   BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93]
+   BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103]
+   BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68]
+   BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79]
+   BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90]
+   BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100]
+   BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109]
+   BT[110] BT[111] LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7]
+   LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16]
+   LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25]
+   LQB[26] LQB[27] PGIOIR VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23] VBA[24] VBA[25]
+   VBA[26] VBA[27] VBA[28] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+   VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+   VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25]
+   VBN[26] VBN[27] VBN[28] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+   VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+   VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+   VBP[26] VBP[27] VBP[28] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5]
+   VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+   VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22]
+   VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDAI_H_T1[0]
+   VDDAI_H_T1[1] VDDAI_H_T1[2] VDDAI_H_T1[3] VDDAI_H_T1[4] VDDAI_H_T1[5]
+   VDDAI_H_T1[6] VDDAI_H_T1[7] VDDAI_H_T1[8] VDDAI_H_T1[9] VDDAI_H_T1[10]
+   VDDAI_H_T1[11] VDDAI_H_T1[12] VDDAI_H_T1[13] VDDAI_H_T1[14] VDDAI_H_T1[15]
+   VDDAI_H_T1[16] VDDAI_H_T1[17] VDDAI_H_T1[18] VDDAI_H_T1[19] VDDAI_H_T1[20]
+   VDDAI_H_T1[21] VDDAI_H_T1[22] VDDAI_H_T1[23] VDDAI_H_T1[24] VDDAI_H_T1[25]
+   VDDAI_H_T1[26] VDDAI_H_T1[27] VDDAI_H_T1[28] VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20]
+   VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28]
+   VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+   VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+   VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21]
+   VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VEDGE_O VSS[0]
+   VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+   VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19]
+   VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28]
+   WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9]
+   WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18]
+   WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27]
+   WL[12] WL[13] WL[14] WL[15] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16]
+   WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25]
+   WTI[26] WTI[27] SNPS_RF_SP_UHS_256x28_ary_rt
X_ary_rt_S4 BADB[0] BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7]
+   BADB[8] BADB[9] BADB[10] BADB[11] BADB[12] BADB[13] BADB[14] BADB[15]
+   BADB[16] BADB[17] BADB[18] BADB[19] BADB[20] BADB[21] BADB[22] BADB[23]
+   BADB[24] BADB[25] BADB[26] BADB[27] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5]
+   BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+   BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27]
+   BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38]
+   BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49]
+   BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60]
+   BB[61] BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+   BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82]
+   BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93]
+   BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103]
+   BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68]
+   BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79]
+   BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90]
+   BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100]
+   BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109]
+   BT[110] BT[111] LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7]
+   LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16]
+   LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25]
+   LQB[26] LQB[27] PGIOIR VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23] VBA[24] VBA[25]
+   VBA[26] VBA[27] VBA[28] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+   VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+   VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25]
+   VBN[26] VBN[27] VBN[28] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+   VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+   VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+   VBP[26] VBP[27] VBP[28] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5]
+   VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+   VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22]
+   VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDAI_H_T1[0]
+   VDDAI_H_T1[1] VDDAI_H_T1[2] VDDAI_H_T1[3] VDDAI_H_T1[4] VDDAI_H_T1[5]
+   VDDAI_H_T1[6] VDDAI_H_T1[7] VDDAI_H_T1[8] VDDAI_H_T1[9] VDDAI_H_T1[10]
+   VDDAI_H_T1[11] VDDAI_H_T1[12] VDDAI_H_T1[13] VDDAI_H_T1[14] VDDAI_H_T1[15]
+   VDDAI_H_T1[16] VDDAI_H_T1[17] VDDAI_H_T1[18] VDDAI_H_T1[19] VDDAI_H_T1[20]
+   VDDAI_H_T1[21] VDDAI_H_T1[22] VDDAI_H_T1[23] VDDAI_H_T1[24] VDDAI_H_T1[25]
+   VDDAI_H_T1[26] VDDAI_H_T1[27] VDDAI_H_T1[28] VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20]
+   VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28]
+   VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+   VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+   VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21]
+   VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VEDGE_O VSS[0]
+   VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+   VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19]
+   VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28]
+   WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9]
+   WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18]
+   WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27]
+   WL[16] WL[17] WL[18] WL[19] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16]
+   WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25]
+   WTI[26] WTI[27] SNPS_RF_SP_UHS_256x28_ary_rt
X_ary_rt_S5 BADB[0] BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7]
+   BADB[8] BADB[9] BADB[10] BADB[11] BADB[12] BADB[13] BADB[14] BADB[15]
+   BADB[16] BADB[17] BADB[18] BADB[19] BADB[20] BADB[21] BADB[22] BADB[23]
+   BADB[24] BADB[25] BADB[26] BADB[27] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5]
+   BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+   BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27]
+   BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38]
+   BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49]
+   BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60]
+   BB[61] BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+   BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82]
+   BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93]
+   BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103]
+   BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68]
+   BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79]
+   BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90]
+   BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100]
+   BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109]
+   BT[110] BT[111] LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7]
+   LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16]
+   LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25]
+   LQB[26] LQB[27] PGIOIR VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23] VBA[24] VBA[25]
+   VBA[26] VBA[27] VBA[28] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+   VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+   VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25]
+   VBN[26] VBN[27] VBN[28] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+   VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+   VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+   VBP[26] VBP[27] VBP[28] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5]
+   VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+   VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22]
+   VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDAI_H_T1[0]
+   VDDAI_H_T1[1] VDDAI_H_T1[2] VDDAI_H_T1[3] VDDAI_H_T1[4] VDDAI_H_T1[5]
+   VDDAI_H_T1[6] VDDAI_H_T1[7] VDDAI_H_T1[8] VDDAI_H_T1[9] VDDAI_H_T1[10]
+   VDDAI_H_T1[11] VDDAI_H_T1[12] VDDAI_H_T1[13] VDDAI_H_T1[14] VDDAI_H_T1[15]
+   VDDAI_H_T1[16] VDDAI_H_T1[17] VDDAI_H_T1[18] VDDAI_H_T1[19] VDDAI_H_T1[20]
+   VDDAI_H_T1[21] VDDAI_H_T1[22] VDDAI_H_T1[23] VDDAI_H_T1[24] VDDAI_H_T1[25]
+   VDDAI_H_T1[26] VDDAI_H_T1[27] VDDAI_H_T1[28] VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20]
+   VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28]
+   VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+   VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+   VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21]
+   VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VEDGE_O VSS[0]
+   VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+   VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19]
+   VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28]
+   WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9]
+   WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18]
+   WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27]
+   WL[20] WL[21] WL[22] WL[23] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16]
+   WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25]
+   WTI[26] WTI[27] SNPS_RF_SP_UHS_256x28_ary_rt
X_ary_rt_S6 BADB[0] BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7]
+   BADB[8] BADB[9] BADB[10] BADB[11] BADB[12] BADB[13] BADB[14] BADB[15]
+   BADB[16] BADB[17] BADB[18] BADB[19] BADB[20] BADB[21] BADB[22] BADB[23]
+   BADB[24] BADB[25] BADB[26] BADB[27] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5]
+   BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+   BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27]
+   BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38]
+   BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49]
+   BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60]
+   BB[61] BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+   BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82]
+   BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93]
+   BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103]
+   BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68]
+   BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79]
+   BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90]
+   BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100]
+   BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109]
+   BT[110] BT[111] LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7]
+   LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16]
+   LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25]
+   LQB[26] LQB[27] PGIOIR VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23] VBA[24] VBA[25]
+   VBA[26] VBA[27] VBA[28] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+   VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+   VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25]
+   VBN[26] VBN[27] VBN[28] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+   VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+   VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+   VBP[26] VBP[27] VBP[28] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5]
+   VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+   VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22]
+   VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDAI_H_T1[0]
+   VDDAI_H_T1[1] VDDAI_H_T1[2] VDDAI_H_T1[3] VDDAI_H_T1[4] VDDAI_H_T1[5]
+   VDDAI_H_T1[6] VDDAI_H_T1[7] VDDAI_H_T1[8] VDDAI_H_T1[9] VDDAI_H_T1[10]
+   VDDAI_H_T1[11] VDDAI_H_T1[12] VDDAI_H_T1[13] VDDAI_H_T1[14] VDDAI_H_T1[15]
+   VDDAI_H_T1[16] VDDAI_H_T1[17] VDDAI_H_T1[18] VDDAI_H_T1[19] VDDAI_H_T1[20]
+   VDDAI_H_T1[21] VDDAI_H_T1[22] VDDAI_H_T1[23] VDDAI_H_T1[24] VDDAI_H_T1[25]
+   VDDAI_H_T1[26] VDDAI_H_T1[27] VDDAI_H_T1[28] VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20]
+   VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28]
+   VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+   VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+   VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21]
+   VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VEDGE_O VSS[0]
+   VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+   VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19]
+   VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28]
+   WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9]
+   WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18]
+   WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27]
+   WL[24] WL[25] WL[26] WL[27] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16]
+   WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25]
+   WTI[26] WTI[27] SNPS_RF_SP_UHS_256x28_ary_rt
X_ary_rt_S7 BADB[0] BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7]
+   BADB[8] BADB[9] BADB[10] BADB[11] BADB[12] BADB[13] BADB[14] BADB[15]
+   BADB[16] BADB[17] BADB[18] BADB[19] BADB[20] BADB[21] BADB[22] BADB[23]
+   BADB[24] BADB[25] BADB[26] BADB[27] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5]
+   BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+   BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27]
+   BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38]
+   BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49]
+   BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60]
+   BB[61] BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+   BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82]
+   BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93]
+   BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103]
+   BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68]
+   BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79]
+   BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90]
+   BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100]
+   BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109]
+   BT[110] BT[111] LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7]
+   LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16]
+   LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25]
+   LQB[26] LQB[27] PGIOIR VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23] VBA[24] VBA[25]
+   VBA[26] VBA[27] VBA[28] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+   VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+   VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25]
+   VBN[26] VBN[27] VBN[28] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+   VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+   VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+   VBP[26] VBP[27] VBP[28] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5]
+   VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+   VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22]
+   VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDAI_H_T1[0]
+   VDDAI_H_T1[1] VDDAI_H_T1[2] VDDAI_H_T1[3] VDDAI_H_T1[4] VDDAI_H_T1[5]
+   VDDAI_H_T1[6] VDDAI_H_T1[7] VDDAI_H_T1[8] VDDAI_H_T1[9] VDDAI_H_T1[10]
+   VDDAI_H_T1[11] VDDAI_H_T1[12] VDDAI_H_T1[13] VDDAI_H_T1[14] VDDAI_H_T1[15]
+   VDDAI_H_T1[16] VDDAI_H_T1[17] VDDAI_H_T1[18] VDDAI_H_T1[19] VDDAI_H_T1[20]
+   VDDAI_H_T1[21] VDDAI_H_T1[22] VDDAI_H_T1[23] VDDAI_H_T1[24] VDDAI_H_T1[25]
+   VDDAI_H_T1[26] VDDAI_H_T1[27] VDDAI_H_T1[28] VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20]
+   VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28]
+   VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+   VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+   VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21]
+   VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VEDGE_O VSS[0]
+   VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+   VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19]
+   VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28]
+   WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9]
+   WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18]
+   WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27]
+   WL[28] WL[29] WL[30] WL[31] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16]
+   WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25]
+   WTI[26] WTI[27] SNPS_RF_SP_UHS_256x28_ary_rt
X_ary_rt_F7 BADB[0] BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7]
+   BADB[8] BADB[9] BADB[10] BADB[11] BADB[12] BADB[13] BADB[14] BADB[15]
+   BADB[16] BADB[17] BADB[18] BADB[19] BADB[20] BADB[21] BADB[22] BADB[23]
+   BADB[24] BADB[25] BADB[26] BADB[27] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5]
+   BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+   BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27]
+   BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38]
+   BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49]
+   BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60]
+   BB[61] BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+   BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82]
+   BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93]
+   BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103]
+   BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68]
+   BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79]
+   BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90]
+   BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100]
+   BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109]
+   BT[110] BT[111] LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7]
+   LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16]
+   LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25]
+   LQB[26] LQB[27] PGIOIR VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23] VBA[24] VBA[25]
+   VBA[26] VBA[27] VBA[28] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+   VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+   VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25]
+   VBN[26] VBN[27] VBN[28] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+   VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+   VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+   VBP[26] VBP[27] VBP[28] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5]
+   VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+   VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22]
+   VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDAI_H_T1[0]
+   VDDAI_H_T1[1] VDDAI_H_T1[2] VDDAI_H_T1[3] VDDAI_H_T1[4] VDDAI_H_T1[5]
+   VDDAI_H_T1[6] VDDAI_H_T1[7] VDDAI_H_T1[8] VDDAI_H_T1[9] VDDAI_H_T1[10]
+   VDDAI_H_T1[11] VDDAI_H_T1[12] VDDAI_H_T1[13] VDDAI_H_T1[14] VDDAI_H_T1[15]
+   VDDAI_H_T1[16] VDDAI_H_T1[17] VDDAI_H_T1[18] VDDAI_H_T1[19] VDDAI_H_T1[20]
+   VDDAI_H_T1[21] VDDAI_H_T1[22] VDDAI_H_T1[23] VDDAI_H_T1[24] VDDAI_H_T1[25]
+   VDDAI_H_T1[26] VDDAI_H_T1[27] VDDAI_H_T1[28] VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20]
+   VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28]
+   VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+   VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+   VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21]
+   VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VEDGE_O VSS[0]
+   VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+   VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19]
+   VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28]
+   WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9]
+   WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18]
+   WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27]
+   WL[32] WL[33] WL[34] WL[35] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16]
+   WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25]
+   WTI[26] WTI[27] SNPS_RF_SP_UHS_256x28_ary_rt
X_ary_rt_F6 BADB[0] BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7]
+   BADB[8] BADB[9] BADB[10] BADB[11] BADB[12] BADB[13] BADB[14] BADB[15]
+   BADB[16] BADB[17] BADB[18] BADB[19] BADB[20] BADB[21] BADB[22] BADB[23]
+   BADB[24] BADB[25] BADB[26] BADB[27] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5]
+   BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+   BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27]
+   BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38]
+   BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49]
+   BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60]
+   BB[61] BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+   BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82]
+   BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93]
+   BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103]
+   BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68]
+   BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79]
+   BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90]
+   BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100]
+   BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109]
+   BT[110] BT[111] LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7]
+   LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16]
+   LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25]
+   LQB[26] LQB[27] PGIOIR VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23] VBA[24] VBA[25]
+   VBA[26] VBA[27] VBA[28] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+   VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+   VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25]
+   VBN[26] VBN[27] VBN[28] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+   VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+   VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+   VBP[26] VBP[27] VBP[28] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5]
+   VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+   VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22]
+   VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDAI_H_T1[0]
+   VDDAI_H_T1[1] VDDAI_H_T1[2] VDDAI_H_T1[3] VDDAI_H_T1[4] VDDAI_H_T1[5]
+   VDDAI_H_T1[6] VDDAI_H_T1[7] VDDAI_H_T1[8] VDDAI_H_T1[9] VDDAI_H_T1[10]
+   VDDAI_H_T1[11] VDDAI_H_T1[12] VDDAI_H_T1[13] VDDAI_H_T1[14] VDDAI_H_T1[15]
+   VDDAI_H_T1[16] VDDAI_H_T1[17] VDDAI_H_T1[18] VDDAI_H_T1[19] VDDAI_H_T1[20]
+   VDDAI_H_T1[21] VDDAI_H_T1[22] VDDAI_H_T1[23] VDDAI_H_T1[24] VDDAI_H_T1[25]
+   VDDAI_H_T1[26] VDDAI_H_T1[27] VDDAI_H_T1[28] VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20]
+   VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28]
+   VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+   VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+   VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21]
+   VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VEDGE_O VSS[0]
+   VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+   VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19]
+   VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28]
+   WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9]
+   WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18]
+   WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27]
+   WL[36] WL[37] WL[38] WL[39] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16]
+   WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25]
+   WTI[26] WTI[27] SNPS_RF_SP_UHS_256x28_ary_rt
X_ary_rt_F5 BADB[0] BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7]
+   BADB[8] BADB[9] BADB[10] BADB[11] BADB[12] BADB[13] BADB[14] BADB[15]
+   BADB[16] BADB[17] BADB[18] BADB[19] BADB[20] BADB[21] BADB[22] BADB[23]
+   BADB[24] BADB[25] BADB[26] BADB[27] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5]
+   BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+   BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27]
+   BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38]
+   BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49]
+   BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60]
+   BB[61] BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+   BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82]
+   BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93]
+   BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103]
+   BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68]
+   BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79]
+   BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90]
+   BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100]
+   BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109]
+   BT[110] BT[111] LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7]
+   LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16]
+   LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25]
+   LQB[26] LQB[27] PGIOIR VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23] VBA[24] VBA[25]
+   VBA[26] VBA[27] VBA[28] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+   VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+   VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25]
+   VBN[26] VBN[27] VBN[28] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+   VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+   VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+   VBP[26] VBP[27] VBP[28] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5]
+   VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+   VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22]
+   VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDAI_H_T1[0]
+   VDDAI_H_T1[1] VDDAI_H_T1[2] VDDAI_H_T1[3] VDDAI_H_T1[4] VDDAI_H_T1[5]
+   VDDAI_H_T1[6] VDDAI_H_T1[7] VDDAI_H_T1[8] VDDAI_H_T1[9] VDDAI_H_T1[10]
+   VDDAI_H_T1[11] VDDAI_H_T1[12] VDDAI_H_T1[13] VDDAI_H_T1[14] VDDAI_H_T1[15]
+   VDDAI_H_T1[16] VDDAI_H_T1[17] VDDAI_H_T1[18] VDDAI_H_T1[19] VDDAI_H_T1[20]
+   VDDAI_H_T1[21] VDDAI_H_T1[22] VDDAI_H_T1[23] VDDAI_H_T1[24] VDDAI_H_T1[25]
+   VDDAI_H_T1[26] VDDAI_H_T1[27] VDDAI_H_T1[28] VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20]
+   VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28]
+   VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+   VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+   VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21]
+   VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VEDGE_O VSS[0]
+   VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+   VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19]
+   VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28]
+   WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9]
+   WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18]
+   WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27]
+   WL[40] WL[41] WL[42] WL[43] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16]
+   WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25]
+   WTI[26] WTI[27] SNPS_RF_SP_UHS_256x28_ary_rt
X_ary_rt_F4 BADB[0] BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7]
+   BADB[8] BADB[9] BADB[10] BADB[11] BADB[12] BADB[13] BADB[14] BADB[15]
+   BADB[16] BADB[17] BADB[18] BADB[19] BADB[20] BADB[21] BADB[22] BADB[23]
+   BADB[24] BADB[25] BADB[26] BADB[27] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5]
+   BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+   BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27]
+   BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38]
+   BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49]
+   BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60]
+   BB[61] BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+   BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82]
+   BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93]
+   BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103]
+   BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68]
+   BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79]
+   BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90]
+   BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100]
+   BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109]
+   BT[110] BT[111] LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7]
+   LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16]
+   LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25]
+   LQB[26] LQB[27] PGIOIR VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23] VBA[24] VBA[25]
+   VBA[26] VBA[27] VBA[28] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+   VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+   VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25]
+   VBN[26] VBN[27] VBN[28] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+   VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+   VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+   VBP[26] VBP[27] VBP[28] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5]
+   VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+   VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22]
+   VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDAI_H_T1[0]
+   VDDAI_H_T1[1] VDDAI_H_T1[2] VDDAI_H_T1[3] VDDAI_H_T1[4] VDDAI_H_T1[5]
+   VDDAI_H_T1[6] VDDAI_H_T1[7] VDDAI_H_T1[8] VDDAI_H_T1[9] VDDAI_H_T1[10]
+   VDDAI_H_T1[11] VDDAI_H_T1[12] VDDAI_H_T1[13] VDDAI_H_T1[14] VDDAI_H_T1[15]
+   VDDAI_H_T1[16] VDDAI_H_T1[17] VDDAI_H_T1[18] VDDAI_H_T1[19] VDDAI_H_T1[20]
+   VDDAI_H_T1[21] VDDAI_H_T1[22] VDDAI_H_T1[23] VDDAI_H_T1[24] VDDAI_H_T1[25]
+   VDDAI_H_T1[26] VDDAI_H_T1[27] VDDAI_H_T1[28] VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20]
+   VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28]
+   VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+   VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+   VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21]
+   VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VEDGE_O VSS[0]
+   VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+   VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19]
+   VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28]
+   WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9]
+   WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18]
+   WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27]
+   WL[44] WL[45] WL[46] WL[47] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16]
+   WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25]
+   WTI[26] WTI[27] SNPS_RF_SP_UHS_256x28_ary_rt
X_ary_rt_F3 BADB[0] BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7]
+   BADB[8] BADB[9] BADB[10] BADB[11] BADB[12] BADB[13] BADB[14] BADB[15]
+   BADB[16] BADB[17] BADB[18] BADB[19] BADB[20] BADB[21] BADB[22] BADB[23]
+   BADB[24] BADB[25] BADB[26] BADB[27] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5]
+   BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+   BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27]
+   BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38]
+   BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49]
+   BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60]
+   BB[61] BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+   BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82]
+   BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93]
+   BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103]
+   BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68]
+   BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79]
+   BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90]
+   BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100]
+   BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109]
+   BT[110] BT[111] LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7]
+   LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16]
+   LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25]
+   LQB[26] LQB[27] PGIOIR VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23] VBA[24] VBA[25]
+   VBA[26] VBA[27] VBA[28] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+   VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+   VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25]
+   VBN[26] VBN[27] VBN[28] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+   VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+   VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+   VBP[26] VBP[27] VBP[28] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5]
+   VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+   VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22]
+   VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDAI_H_T1[0]
+   VDDAI_H_T1[1] VDDAI_H_T1[2] VDDAI_H_T1[3] VDDAI_H_T1[4] VDDAI_H_T1[5]
+   VDDAI_H_T1[6] VDDAI_H_T1[7] VDDAI_H_T1[8] VDDAI_H_T1[9] VDDAI_H_T1[10]
+   VDDAI_H_T1[11] VDDAI_H_T1[12] VDDAI_H_T1[13] VDDAI_H_T1[14] VDDAI_H_T1[15]
+   VDDAI_H_T1[16] VDDAI_H_T1[17] VDDAI_H_T1[18] VDDAI_H_T1[19] VDDAI_H_T1[20]
+   VDDAI_H_T1[21] VDDAI_H_T1[22] VDDAI_H_T1[23] VDDAI_H_T1[24] VDDAI_H_T1[25]
+   VDDAI_H_T1[26] VDDAI_H_T1[27] VDDAI_H_T1[28] VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20]
+   VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28]
+   VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+   VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+   VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21]
+   VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VEDGE_O VSS[0]
+   VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+   VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19]
+   VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28]
+   WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9]
+   WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18]
+   WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27]
+   WL[48] WL[49] WL[50] WL[51] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16]
+   WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25]
+   WTI[26] WTI[27] SNPS_RF_SP_UHS_256x28_ary_rt
X_ary_rt_F2 BADB[0] BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7]
+   BADB[8] BADB[9] BADB[10] BADB[11] BADB[12] BADB[13] BADB[14] BADB[15]
+   BADB[16] BADB[17] BADB[18] BADB[19] BADB[20] BADB[21] BADB[22] BADB[23]
+   BADB[24] BADB[25] BADB[26] BADB[27] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5]
+   BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+   BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27]
+   BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38]
+   BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49]
+   BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60]
+   BB[61] BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+   BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82]
+   BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93]
+   BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103]
+   BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68]
+   BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79]
+   BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90]
+   BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100]
+   BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109]
+   BT[110] BT[111] LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7]
+   LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16]
+   LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25]
+   LQB[26] LQB[27] PGIOIR VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23] VBA[24] VBA[25]
+   VBA[26] VBA[27] VBA[28] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+   VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+   VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25]
+   VBN[26] VBN[27] VBN[28] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+   VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+   VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+   VBP[26] VBP[27] VBP[28] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5]
+   VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+   VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22]
+   VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDAI_H_T1[0]
+   VDDAI_H_T1[1] VDDAI_H_T1[2] VDDAI_H_T1[3] VDDAI_H_T1[4] VDDAI_H_T1[5]
+   VDDAI_H_T1[6] VDDAI_H_T1[7] VDDAI_H_T1[8] VDDAI_H_T1[9] VDDAI_H_T1[10]
+   VDDAI_H_T1[11] VDDAI_H_T1[12] VDDAI_H_T1[13] VDDAI_H_T1[14] VDDAI_H_T1[15]
+   VDDAI_H_T1[16] VDDAI_H_T1[17] VDDAI_H_T1[18] VDDAI_H_T1[19] VDDAI_H_T1[20]
+   VDDAI_H_T1[21] VDDAI_H_T1[22] VDDAI_H_T1[23] VDDAI_H_T1[24] VDDAI_H_T1[25]
+   VDDAI_H_T1[26] VDDAI_H_T1[27] VDDAI_H_T1[28] VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20]
+   VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28]
+   VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+   VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+   VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21]
+   VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VEDGE_O VSS[0]
+   VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+   VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19]
+   VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28]
+   WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9]
+   WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18]
+   WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27]
+   WL[52] WL[53] WL[54] WL[55] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16]
+   WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25]
+   WTI[26] WTI[27] SNPS_RF_SP_UHS_256x28_ary_rt
X_ary_rt_F1 BADB[0] BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7]
+   BADB[8] BADB[9] BADB[10] BADB[11] BADB[12] BADB[13] BADB[14] BADB[15]
+   BADB[16] BADB[17] BADB[18] BADB[19] BADB[20] BADB[21] BADB[22] BADB[23]
+   BADB[24] BADB[25] BADB[26] BADB[27] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5]
+   BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+   BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27]
+   BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38]
+   BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49]
+   BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60]
+   BB[61] BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+   BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82]
+   BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93]
+   BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103]
+   BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68]
+   BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79]
+   BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90]
+   BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100]
+   BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109]
+   BT[110] BT[111] LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7]
+   LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16]
+   LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25]
+   LQB[26] LQB[27] PGIOIR VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23] VBA[24] VBA[25]
+   VBA[26] VBA[27] VBA[28] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+   VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+   VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25]
+   VBN[26] VBN[27] VBN[28] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+   VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+   VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+   VBP[26] VBP[27] VBP[28] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5]
+   VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+   VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22]
+   VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDAI_H_T1[0]
+   VDDAI_H_T1[1] VDDAI_H_T1[2] VDDAI_H_T1[3] VDDAI_H_T1[4] VDDAI_H_T1[5]
+   VDDAI_H_T1[6] VDDAI_H_T1[7] VDDAI_H_T1[8] VDDAI_H_T1[9] VDDAI_H_T1[10]
+   VDDAI_H_T1[11] VDDAI_H_T1[12] VDDAI_H_T1[13] VDDAI_H_T1[14] VDDAI_H_T1[15]
+   VDDAI_H_T1[16] VDDAI_H_T1[17] VDDAI_H_T1[18] VDDAI_H_T1[19] VDDAI_H_T1[20]
+   VDDAI_H_T1[21] VDDAI_H_T1[22] VDDAI_H_T1[23] VDDAI_H_T1[24] VDDAI_H_T1[25]
+   VDDAI_H_T1[26] VDDAI_H_T1[27] VDDAI_H_T1[28] VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20]
+   VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28]
+   VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+   VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+   VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21]
+   VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VEDGE_O VSS[0]
+   VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+   VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19]
+   VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28]
+   WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9]
+   WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18]
+   WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27]
+   WL[56] WL[57] WL[58] WL[59] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16]
+   WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25]
+   WTI[26] WTI[27] SNPS_RF_SP_UHS_256x28_ary_rt
X_ary_rt_F0 BADB[0] BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7]
+   BADB[8] BADB[9] BADB[10] BADB[11] BADB[12] BADB[13] BADB[14] BADB[15]
+   BADB[16] BADB[17] BADB[18] BADB[19] BADB[20] BADB[21] BADB[22] BADB[23]
+   BADB[24] BADB[25] BADB[26] BADB[27] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5]
+   BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+   BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27]
+   BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38]
+   BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49]
+   BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60]
+   BB[61] BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+   BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82]
+   BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93]
+   BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103]
+   BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68]
+   BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79]
+   BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90]
+   BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100]
+   BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109]
+   BT[110] BT[111] LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7]
+   LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16]
+   LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25]
+   LQB[26] LQB[27] PGIOIR VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23] VBA[24] VBA[25]
+   VBA[26] VBA[27] VBA[28] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+   VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+   VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25]
+   VBN[26] VBN[27] VBN[28] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+   VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+   VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+   VBP[26] VBP[27] VBP[28] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5]
+   VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+   VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22]
+   VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDAI_H_T1[0]
+   VDDAI_H_T1[1] VDDAI_H_T1[2] VDDAI_H_T1[3] VDDAI_H_T1[4] VDDAI_H_T1[5]
+   VDDAI_H_T1[6] VDDAI_H_T1[7] VDDAI_H_T1[8] VDDAI_H_T1[9] VDDAI_H_T1[10]
+   VDDAI_H_T1[11] VDDAI_H_T1[12] VDDAI_H_T1[13] VDDAI_H_T1[14] VDDAI_H_T1[15]
+   VDDAI_H_T1[16] VDDAI_H_T1[17] VDDAI_H_T1[18] VDDAI_H_T1[19] VDDAI_H_T1[20]
+   VDDAI_H_T1[21] VDDAI_H_T1[22] VDDAI_H_T1[23] VDDAI_H_T1[24] VDDAI_H_T1[25]
+   VDDAI_H_T1[26] VDDAI_H_T1[27] VDDAI_H_T1[28] VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20]
+   VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28]
+   VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+   VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+   VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21]
+   VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VEDGE_O VSS[0]
+   VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+   VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19]
+   VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28]
+   WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9]
+   WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18]
+   WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27]
+   WL[60] WL[61] WL[62] WL[63] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16]
+   WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25]
+   WTI[26] WTI[27] SNPS_RF_SP_UHS_256x28_ary_rt
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_ary_row_t ARYSDR ARYSD_BC1 ARYSD_BC2 B BADB[0]
+       BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7] BADB[8] BADB[9]
+       BADB[10] BADB[11] BADB[12] BADB[13] BADB[14] BADB[15] BADB[16] BADB[17]
+       BADB[18] BADB[19] BADB[20] BADB[21] BADB[22] BADB[23] BADB[24] BADB[25]
+       BADB[26] BADB[27] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8]
+       BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18]
+       BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28]
+       BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38]
+       BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48]
+       BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58]
+       BB[59] BB[60] BB[61] BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68]
+       BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78]
+       BB[79] BB[80] BB[81] BB[82] BB[83] BB[84] BB[85] BB[86] BB[87] BB[88]
+       BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95] BB[96] BB[97] BB[98]
+       BB[99] BB[100] BB[101] BB[102] BB[103] BB[104] BB[105] BB[106] BB[107]
+       BB[108] BB[109] BB[110] BB[111] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+       BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16]
+       BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26]
+       BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35] BT[36]
+       BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+       BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56]
+       BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66]
+       BT[67] BT[68] BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76]
+       BT[77] BT[78] BT[79] BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86]
+       BT[87] BT[88] BT[89] BT[90] BT[91] BT[92] BT[93] BT[94] BT[95] BT[96]
+       BT[97] BT[98] BT[99] BT[100] BT[101] BT[102] BT[103] BT[104] BT[105]
+       BT[106] BT[107] BT[108] BT[109] BT[110] BT[111] BYP_VLOAD C CENDP CKGATE
+       DEF_MODE DLYPDB EDGEB EDGET FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET
+       LBKADR LCGTH LDFTX LITESLP LOG0[0] LOG0[1] LOG1[0] LOG1[1] LQB[0] LQB[1]
+       LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7] LQB[8] LQB[9] LQB[10] LQB[11]
+       LQB[12] LQB[13] LQB[14] LQB[15] LQB[16] LQB[17] LQB[18] LQB[19] LQB[20]
+       LQB[21] LQB[22] LQB[23] LQB[24] LQB[25] LQB[26] LQB[27] LWEIB LXADR[0]
+       LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+       LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0]
+       PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] PGIOIR PROCOML
+       RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] RBLRD RBLWA RBLWR RM3CNT
+       RMT[0] RMT[1] RMT[2] RMT[3] RWLB T1T TEST_RNMB VBA[0] VBA[1] VBA[2]
+       VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12]
+       VBA[13] VBA[14] VBA[15] VBA[16] VBA[17] VBA[18] VBA[19] VBA[20] VBA[21]
+       VBA[22] VBA[23] VBA[24] VBA[25] VBA[26] VBA[27] VBA[28] VBA[29] VBN[0]
+       VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10]
+       VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19]
+       VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28]
+       VBN[29] VBN[30] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7]
+       VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+       VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+       VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+       VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11]
+       VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19]
+       VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27]
+       VDDA[28] VDDA[29] VDDA[30] VDDAI_H_T1[0] VDDAI_H_T1[1] VDDAI_H_T1[2]
+       VDDAI_H_T1[3] VDDAI_H_T1[4] VDDAI_H_T1[5] VDDAI_H_T1[6] VDDAI_H_T1[7]
+       VDDAI_H_T1[8] VDDAI_H_T1[9] VDDAI_H_T1[10] VDDAI_H_T1[11] VDDAI_H_T1[12]
+       VDDAI_H_T1[13] VDDAI_H_T1[14] VDDAI_H_T1[15] VDDAI_H_T1[16]
+       VDDAI_H_T1[17] VDDAI_H_T1[18] VDDAI_H_T1[19] VDDAI_H_T1[20]
+       VDDAI_H_T1[21] VDDAI_H_T1[22] VDDAI_H_T1[23] VDDAI_H_T1[24]
+       VDDAI_H_T1[25] VDDAI_H_T1[26] VDDAI_H_T1[27] VDDAI_H_T1[28] VDDF VDDP[0]
+       VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9]
+       VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17]
+       VDDP[18] VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25]
+       VDDP[26] VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDPI[0] VDDPI[1] VDDPI[2]
+       VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+       VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17]
+       VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24]
+       VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDWL VEDGE_O VSS[0]
+       VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+       VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19]
+       VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28]
+       VSS[29] VSS[30] VSSWLL VSSWLR WABUF[0] WABUF[1] WABUF[2] WBI[0] WBI[1]
+       WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11]
+       WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20]
+       WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27] WCLKB[0]
+       WCLKB[1] WCLKB[2] WCLKB[3] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+       WPBUF[2] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8]
+       WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16] WTI[17]
+       WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25] WTI[26]
+       WTI[27]
X_ary_cnt ARYSDR ARYSD_BC1 ARYSD_BC2 B BYP_VLOAD C CENDP CKGATE DEF_MODE DLYPDB
+   EDGEB EDGET FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR LCGTH LDFTX
+   LITESLP LOG0[0] LOG0[1] LOG1[0] LOG1[1] LWEIB LXADR[0] LXADR[1] LXADR[2]
+   LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1]
+   PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4]
+   PCB[5] PCB[6] PCB[7] PROCOML RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1]
+   RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB T1T TEST_RNMB
+   VBA[0] VBN[0] VBN[1] VBP[0] VBP[1] VDDA[0] VDDA[1] VDDF VDDP[0] VDDP[1]
+   VDDPI[0] VDDPI[1] VDDWL VSS[0] VSS[1] VSSWLL VSSWLR WABUF[0] WABUF[1]
+   WABUF[2] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] WL[0] WL[1] WL[2] WL[3] WL[4]
+   WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13] WL[14] WL[15]
+   WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23] WL[24] WL[25] WL[26]
+   WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33] WL[34] WL[35] WL[36] WL[37]
+   WL[38] WL[39] WL[40] WL[41] WL[42] WL[43] WL[44] WL[45] WL[46] WL[47] WL[48]
+   WL[49] WL[50] WL[51] WL[52] WL[53] WL[54] WL[55] WL[56] WL[57] WL[58] WL[59]
+   WL[60] WL[61] WL[62] WL[63] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] SNPS_RF_SP_UHS_256x28_ary_cnt
X_ary_right BADB[0] BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7]
+   BADB[8] BADB[9] BADB[10] BADB[11] BADB[12] BADB[13] BADB[14] BADB[15]
+   BADB[16] BADB[17] BADB[18] BADB[19] BADB[20] BADB[21] BADB[22] BADB[23]
+   BADB[24] BADB[25] BADB[26] BADB[27] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5]
+   BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+   BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27]
+   BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38]
+   BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49]
+   BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60]
+   BB[61] BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+   BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82]
+   BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93]
+   BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103]
+   BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68]
+   BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79]
+   BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90]
+   BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100]
+   BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109]
+   BT[110] BT[111] LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7]
+   LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16]
+   LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25]
+   LQB[26] LQB[27] PGIOIR VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23] VBA[24] VBA[25]
+   VBA[26] VBA[27] VBA[28] VBA[29] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7]
+   VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+   VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25]
+   VBN[26] VBN[27] VBN[28] VBN[29] VBN[30] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+   VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+   VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+   VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VDDA[2] VDDA[3] VDDA[4] VDDA[5]
+   VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+   VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22]
+   VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30]
+   VDDAI_H_T1[0] VDDAI_H_T1[1] VDDAI_H_T1[2] VDDAI_H_T1[3] VDDAI_H_T1[4]
+   VDDAI_H_T1[5] VDDAI_H_T1[6] VDDAI_H_T1[7] VDDAI_H_T1[8] VDDAI_H_T1[9]
+   VDDAI_H_T1[10] VDDAI_H_T1[11] VDDAI_H_T1[12] VDDAI_H_T1[13] VDDAI_H_T1[14]
+   VDDAI_H_T1[15] VDDAI_H_T1[16] VDDAI_H_T1[17] VDDAI_H_T1[18] VDDAI_H_T1[19]
+   VDDAI_H_T1[20] VDDAI_H_T1[21] VDDAI_H_T1[22] VDDAI_H_T1[23] VDDAI_H_T1[24]
+   VDDAI_H_T1[25] VDDAI_H_T1[26] VDDAI_H_T1[27] VDDAI_H_T1[28] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20]
+   VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28]
+   VDDP[29] VDDP[30] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+   VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+   VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21]
+   VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28]
+   VDDPI[29] VEDGE_O VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9]
+   VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18]
+   VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27]
+   VSS[28] VSS[29] VSS[30] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+   WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16]
+   WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25]
+   WBI[26] WBI[27] WL[0] WL[1] WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9]
+   WL[10] WL[11] WL[12] WL[13] WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20]
+   WL[21] WL[22] WL[23] WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31]
+   WL[32] WL[33] WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42]
+   WL[43] WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53]
+   WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63] WTI[0]
+   WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10]
+   WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19]
+   WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27]
+   SNPS_RF_SP_UHS_256x28_ary_right
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_ary_row ARYSDR ARYSD_BC1 ARYSD_BC2 B BADB[0]
+       BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7] BADB[8] BADB[9]
+       BADB[10] BADB[11] BADB[12] BADB[13] BADB[14] BADB[15] BADB[16] BADB[17]
+       BADB[18] BADB[19] BADB[20] BADB[21] BADB[22] BADB[23] BADB[24] BADB[25]
+       BADB[26] BADB[27] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8]
+       BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18]
+       BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28]
+       BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38]
+       BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48]
+       BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58]
+       BB[59] BB[60] BB[61] BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68]
+       BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78]
+       BB[79] BB[80] BB[81] BB[82] BB[83] BB[84] BB[85] BB[86] BB[87] BB[88]
+       BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95] BB[96] BB[97] BB[98]
+       BB[99] BB[100] BB[101] BB[102] BB[103] BB[104] BB[105] BB[106] BB[107]
+       BB[108] BB[109] BB[110] BB[111] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+       BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16]
+       BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26]
+       BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35] BT[36]
+       BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+       BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56]
+       BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66]
+       BT[67] BT[68] BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76]
+       BT[77] BT[78] BT[79] BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86]
+       BT[87] BT[88] BT[89] BT[90] BT[91] BT[92] BT[93] BT[94] BT[95] BT[96]
+       BT[97] BT[98] BT[99] BT[100] BT[101] BT[102] BT[103] BT[104] BT[105]
+       BT[106] BT[107] BT[108] BT[109] BT[110] BT[111] BYP_VLOAD C CENDP CKGATE
+       DEF_MODE DLYPDB EDGEB EDGET FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET
+       LBKADR LCGTH LDFTX LITESLP LOG0 LOG1 LQB[0] LQB[1] LQB[2] LQB[3] LQB[4]
+       LQB[5] LQB[6] LQB[7] LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13]
+       LQB[14] LQB[15] LQB[16] LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22]
+       LQB[23] LQB[24] LQB[25] LQB[26] LQB[27] LWEIB LXADR[0] LXADR[1] LXADR[2]
+       LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0]
+       PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+       PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] PGIOIR PROCOML RASSIST[0] RASSIST[1]
+       RASSISTB[0] RASSISTB[1] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2]
+       RMT[3] RWLB T1T TEST_RNMB VBA VBN VBP VDDA VDDAI_H_T1 VDDF VDDP VDDPI
+       VDDWL VEDGE_O VSS VSSWLL VSSWLR WABUF[0] WABUF[1] WABUF[2] WBI[0] WBI[1]
+       WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11]
+       WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20]
+       WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27] WCLKB[0]
+       WCLKB[1] WCLKB[2] WCLKB[3] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+       WPBUF[2] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8]
+       WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16] WTI[17]
+       WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25] WTI[26]
+       WTI[27]
X_ary_row_t ARYSDR ARYSD_BC1 ARYSD_BC2 B BADB[0] BADB[1] BADB[2] BADB[3] BADB[4]
+   BADB[5] BADB[6] BADB[7] BADB[8] BADB[9] BADB[10] BADB[11] BADB[12] BADB[13]
+   BADB[14] BADB[15] BADB[16] BADB[17] BADB[18] BADB[19] BADB[20] BADB[21]
+   BADB[22] BADB[23] BADB[24] BADB[25] BADB[26] BADB[27] BB[0] BB[1] BB[2]
+   BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14]
+   BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25]
+   BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+   BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47]
+   BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58]
+   BB[59] BB[60] BB[61] BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69]
+   BB[70] BB[71] BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80]
+   BB[81] BB[82] BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91]
+   BB[92] BB[93] BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101]
+   BB[102] BB[103] BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110]
+   BB[111] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10]
+   BT[11] BT[12] BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21]
+   BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32]
+   BT[33] BT[34] BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43]
+   BT[44] BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54]
+   BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65]
+   BT[66] BT[67] BT[68] BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76]
+   BT[77] BT[78] BT[79] BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87]
+   BT[88] BT[89] BT[90] BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98]
+   BT[99] BT[100] BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107]
+   BT[108] BT[109] BT[110] BT[111] BYP_VLOAD C CENDP CKGATE DEF_MODE DLYPDB
+   EDGEB EDGET FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR LCGTH LDFTX
+   LITESLP LOG0 LOG0 LOG1 LOG1 LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6]
+   LQB[7] LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16]
+   LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25]
+   LQB[26] LQB[27] LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+   LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4]
+   PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7]
+   PGIOIR PROCOML RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] RBLRD RBLWA
+   RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB T1T TEST_RNMB VBA VBA VBA VBA
+   VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA
+   VBA VBA VBA VBA VBA VBA VBA VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDAI_H_T1 VDDAI_H_T1
+   VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1
+   VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1
+   VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1
+   VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDF VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDWL VEDGE_O VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSSWLL VSSWLR WABUF[0] WABUF[1] WABUF[2] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10]
+   WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18] WBI[19]
+   WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27] WCLKB[0]
+   WCLKB[1] WCLKB[2] WCLKB[3] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8]
+   WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16] WTI[17]
+   WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25] WTI[26]
+   WTI[27] SNPS_RF_SP_UHS_256x28_ary_row_t
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_ref_cnt ARYSDR ARYSD_BC1 ARYSD_BC2 ARYSD_TOP CENDP
+       CKGATE DEF_MODE DLYPDB DRAIN_RIGHT2 FAST1_MODE FAST2_MODE FLOAT FLOATT
+       FLOAT_RET GATE_RIGHT1 GATE_RIGHT2 LBKADR LCGTH LCGTHB LDFTX LITESLP
+       LLSBR LOG0 LOG1 LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+       LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PROCOML RASSIST[0]
+       RASSIST[1] RASSISTB[0] RASSISTB[1] RBLRD RBLWA RBLWR RM3CNT RMT[0]
+       RMT[1] RMT[2] RMT[3] RWL RWLB RWLD SDB_BC1TR SDB_BC2TR SDOR_INR SDOR_OUT
+       T1T TEST_RNMB TOPEDGE VBA VBN[0] VBN[1] VBP[0] VBP[1] VDDA VDDF VDDP[0]
+       VDDP[1] VDDPI[0] VDDPI[1] VDDWL VDDWL_PCOM VSS[0] VSS[1] VSSWLL VSSWLR
+       WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+       WPBUF[2]

*** Jumper Report ***
* Jumper: LOG1 FLOAT_RET
* Jumper: LWEIB LWEIB_HV
* Jumper: RWL RWLD
* Jumper: VDDA VDDP[0] VDDP[1] VDDPI[0]
* Jumper: VSSWLL VSSWLR

*X_mm19a04_u_rw_edge_cd0 mm19a04_u_rw_edge_cd0
X_mm19a04_u_hs1prf_rw_gf22 VDDA VDDF VDDP[0] VDDPI[0] VSS[0] VSSWLL VSSWLR
+   VBP[0] VBN[0] RWLB_RD_NC RWLB_WR_NC CENDP CKGATE DEF_MODE FAST1_MODE
+   FAST2_MODE FLOAT_RET LBKADR LCGTHB LDFTX LITESLP LOG0 LOG1 LWEIB LXADR[0]
+   LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+   LYADR[1] RBLRD RBLWA RBLWR RM3CNT RWLB RWLB_BUF T1T TEST_RNMB WABUF[0]
+   WABUF[1] WABUF[2] WPBUF[0] WPBUF[1] WPBUF[2] FLOAT FLOATT LWEIB RMT[0]
+   RMT[1] RMT[2] RMT[3] RWLD WMT[0] WMT[1] WMT[2] WMT[3]
+   mm19a04_u_hs1prf_rw_gf22
X_mm19a04_u_hs1prf_rwbuf VDDA VDDP[1] VDDPI[1] VDDWL VDDWL_PCOM VSS[1] VBP[1]
+   VBN[1] ARYSD_TOP LCGTHB LLSBR SDB_BC1TR SDB_BC2TR DLYPDB DRAIN_RIGHT2
+   GATE_RIGHT1 GATE_RIGHT2 LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0]
+   RASSISTB[1] RWL RWLB_BUF RWLD SDOR_INR TOPEDGE VBA ARYSD_BC1 ARYSD_BC2
+   ARYSDR LCGTH PROCOML SDOR_OUT mm19a04_u_hs1prf_rwbuf
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_ref_rt_rwl_seg1 BADB[0] BADB[1] BADB[2] BADB[3]
+       BADB[4] BADB[5] BADB[6] BADB[7] BADB[8] BADB[9] BADB[10] BADB[11]
+       BADB[12] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9]
+       BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19]
+       BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29]
+       BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39]
+       BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49]
+       BB[50] BB[51] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8]
+       BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16] BT[17] BT[18]
+       BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28]
+       BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35] BT[36] BT[37] BT[38]
+       BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47] BT[48]
+       BT[49] BT[50] BT[51] DRAIN_LEFT1[0] DRAIN_LEFT2[0] DRAIN_RIGHT1[12]
+       DRAIN_RIGHT2[12] GATE_LEFT1[0] GATE_LEFT2[0] GATE_RIGHT1[12]
+       GATE_RIGHT2[12] LLSB LOG0 LOG1 LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5]
+       LQB[6] LQB[7] LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] RWL RWLD SDB_BC1T
+       SDB_BC2T SDOR_OUT VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+       VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBN[0] VBN[1] VBN[2] VBN[3]
+       VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBP[0]
+       VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10]
+       VBP[11] VBP[12] VDDA VDDAI[0] VDDAI[1] VDDAI[2] VDDAI[3] VDDAI[4]
+       VDDAI[5] VDDAI[6] VDDAI[7] VDDAI[8] VDDAI[9] VDDAI[10] VDDAI[11]
+       VDDAI[12] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6]
+       VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDPI[0] VDDPI[1]
+       VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9]
+       VDDPI[10] VDDPI[11] VDDPI[12] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+       VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] WBI[0] WBI[1] WBI[2]
+       WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12]
+       WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9]
+       WTI[10] WTI[11] WTI[12]

*** Jumper Report ***
* Jumper: VDDA VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]

X_mm19a04_u_hs1prf_rarm4x1_S0 VDDA VDDAI[0] VDDP[0] VDDPI[0] VSS[0] VBP[0]
+   VBN[0] BADB[0] BB[0] BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3]
+   DRAIN_LEFT1[0] DRAIN_LEFT2[0] DRAIN_RIGHT1[0] DRAIN_RIGHT2[0] GATE_LEFT1[0]
+   GATE_LEFT2[0] GATE_RIGHT1[0] GATE_RIGHT2[0] LOG0 LOG1 LQB[0] RWL RWLD
+   SDOR_OUT VBA[0] WBI[0] WTI[0] LLSB SDB_BC1T SDB_BC2T
+   mm19a04_u_hs1prf_rarm4x1
X_mm19a04_u_hs1prf_rarm4x1_S1 VDDA VDDAI[1] VDDP[1] VDDPI[1] VSS[1] VBP[1]
+   VBN[1] BADB[1] BB[4] BB[5] BB[6] BB[7] BT[4] BT[5] BT[6] BT[7]
+   DRAIN_LEFT1[1] DRAIN_LEFT2[1] DRAIN_RIGHT1[1] DRAIN_RIGHT2[1] GATE_LEFT1[1]
+   GATE_LEFT2[1] GATE_RIGHT1[1] GATE_RIGHT2[1] LOG0 LOG1 LQB[1] RWL RWLD
+   SDOR_OUT VBA[1] WBI[1] WTI[1] LLSB SDB_BC1T SDB_BC2T
+   mm19a04_u_hs1prf_rarm4x1
X_mm19a04_u_hs1prf_rarm4x1_S2 VDDA VDDAI[2] VDDP[2] VDDPI[2] VSS[2] VBP[2]
+   VBN[2] BADB[2] BB[8] BB[9] BB[10] BB[11] BT[8] BT[9] BT[10] BT[11]
+   DRAIN_LEFT1[2] DRAIN_LEFT2[2] DRAIN_RIGHT1[2] DRAIN_RIGHT2[2] GATE_LEFT1[2]
+   GATE_LEFT2[2] GATE_RIGHT1[2] GATE_RIGHT2[2] LOG0 LOG1 LQB[2] RWL RWLD
+   SDOR_OUT VBA[2] WBI[2] WTI[2] LLSB SDB_BC1T SDB_BC2T
+   mm19a04_u_hs1prf_rarm4x1
X_mm19a04_u_hs1prf_rarm4x1_S3 VDDA VDDAI[3] VDDP[3] VDDPI[3] VSS[3] VBP[3]
+   VBN[3] BADB[3] BB[12] BB[13] BB[14] BB[15] BT[12] BT[13] BT[14] BT[15]
+   DRAIN_LEFT1[3] DRAIN_LEFT2[3] DRAIN_RIGHT1[3] DRAIN_RIGHT2[3] GATE_LEFT1[3]
+   GATE_LEFT2[3] GATE_RIGHT1[3] GATE_RIGHT2[3] LOG0 LOG1 LQB[3] RWL RWLD
+   SDOR_OUT VBA[3] WBI[3] WTI[3] LLSB SDB_BC1T SDB_BC2T
+   mm19a04_u_hs1prf_rarm4x1
X_mm19a04_u_hs1prf_rarm4x1_S4 VDDA VDDAI[4] VDDP[4] VDDPI[4] VSS[4] VBP[4]
+   VBN[4] BADB[4] BB[16] BB[17] BB[18] BB[19] BT[16] BT[17] BT[18] BT[19]
+   DRAIN_LEFT1[4] DRAIN_LEFT2[4] DRAIN_RIGHT1[4] DRAIN_RIGHT2[4] GATE_LEFT1[4]
+   GATE_LEFT2[4] GATE_RIGHT1[4] GATE_RIGHT2[4] LOG0 LOG1 LQB[4] RWL RWLD
+   SDOR_OUT VBA[4] WBI[4] WTI[4] LLSB SDB_BC1T SDB_BC2T
+   mm19a04_u_hs1prf_rarm4x1
X_mm19a04_u_hs1prf_rarm4x1_S5 VDDA VDDAI[5] VDDP[5] VDDPI[5] VSS[5] VBP[5]
+   VBN[5] BADB[5] BB[20] BB[21] BB[22] BB[23] BT[20] BT[21] BT[22] BT[23]
+   DRAIN_LEFT1[5] DRAIN_LEFT2[5] DRAIN_RIGHT1[5] DRAIN_RIGHT2[5] GATE_LEFT1[5]
+   GATE_LEFT2[5] GATE_RIGHT1[5] GATE_RIGHT2[5] LOG0 LOG1 LQB[5] RWL RWLD
+   SDOR_OUT VBA[5] WBI[5] WTI[5] LLSB SDB_BC1T SDB_BC2T
+   mm19a04_u_hs1prf_rarm4x1
X_mm19a04_u_hs1prf_rarm4x1_F6 VDDA VDDAI[6] VDDP[6] VDDPI[6] VSS[6] VBP[6]
+   VBN[6] BADB[6] BB[24] BB[25] BB[26] BB[27] BT[24] BT[25] BT[26] BT[27]
+   DRAIN_LEFT1[6] DRAIN_LEFT2[6] DRAIN_RIGHT1[6] DRAIN_RIGHT2[6] GATE_LEFT1[6]
+   GATE_LEFT2[6] GATE_RIGHT1[6] GATE_RIGHT2[6] LOG0 LOG1 LQB[6] RWL RWLD
+   SDOR_OUT VBA[6] WBI[6] WTI[6] LLSB SDB_BC1T SDB_BC2T
+   mm19a04_u_hs1prf_rarm4x1
X_mm19a04_u_hs1prf_rarm4x1_F5 VDDA VDDAI[7] VDDP[7] VDDPI[7] VSS[7] VBP[7]
+   VBN[7] BADB[7] BB[28] BB[29] BB[30] BB[31] BT[28] BT[29] BT[30] BT[31]
+   DRAIN_LEFT1[7] DRAIN_LEFT2[7] DRAIN_RIGHT1[7] DRAIN_RIGHT2[7] GATE_LEFT1[7]
+   GATE_LEFT2[7] GATE_RIGHT1[7] GATE_RIGHT2[7] LOG0 LOG1 LQB[7] RWL RWLD
+   SDOR_OUT VBA[7] WBI[7] WTI[7] LLSB SDB_BC1T SDB_BC2T
+   mm19a04_u_hs1prf_rarm4x1
X_mm19a04_u_hs1prf_rarm4x1_F4 VDDA VDDAI[8] VDDP[8] VDDPI[8] VSS[8] VBP[8]
+   VBN[8] BADB[8] BB[32] BB[33] BB[34] BB[35] BT[32] BT[33] BT[34] BT[35]
+   DRAIN_LEFT1[8] DRAIN_LEFT2[8] DRAIN_RIGHT1[8] DRAIN_RIGHT2[8] GATE_LEFT1[8]
+   GATE_LEFT2[8] GATE_RIGHT1[8] GATE_RIGHT2[8] LOG0 LOG1 LQB[8] RWL RWLD
+   SDOR_OUT VBA[8] WBI[8] WTI[8] LLSB SDB_BC1T SDB_BC2T
+   mm19a04_u_hs1prf_rarm4x1
X_mm19a04_u_hs1prf_rarm4x1_F3 VDDA VDDAI[9] VDDP[9] VDDPI[9] VSS[9] VBP[9]
+   VBN[9] BADB[9] BB[36] BB[37] BB[38] BB[39] BT[36] BT[37] BT[38] BT[39]
+   DRAIN_LEFT1[9] DRAIN_LEFT2[9] DRAIN_RIGHT1[9] DRAIN_RIGHT2[9] GATE_LEFT1[9]
+   GATE_LEFT2[9] GATE_RIGHT1[9] GATE_RIGHT2[9] LOG0 LOG1 LQB[9] RWL RWLD
+   SDOR_OUT VBA[9] WBI[9] WTI[9] LLSB SDB_BC1T SDB_BC2T
+   mm19a04_u_hs1prf_rarm4x1
X_mm19a04_u_hs1prf_rarm4x1_F2 VDDA VDDAI[10] VDDP[10] VDDPI[10] VSS[10] VBP[10]
+   VBN[10] BADB[10] BB[40] BB[41] BB[42] BB[43] BT[40] BT[41] BT[42] BT[43]
+   DRAIN_LEFT1[10] DRAIN_LEFT2[10] DRAIN_RIGHT1[10] DRAIN_RIGHT2[10]
+   GATE_LEFT1[10] GATE_LEFT2[10] GATE_RIGHT1[10] GATE_RIGHT2[10] LOG0 LOG1
+   LQB[10] RWL RWLD SDOR_OUT VBA[10] WBI[10] WTI[10] LLSB SDB_BC1T SDB_BC2T
+   mm19a04_u_hs1prf_rarm4x1
X_mm19a04_u_hs1prf_rarm4x1_F1 VDDA VDDAI[11] VDDP[11] VDDPI[11] VSS[11] VBP[11]
+   VBN[11] BADB[11] BB[44] BB[45] BB[46] BB[47] BT[44] BT[45] BT[46] BT[47]
+   DRAIN_LEFT1[11] DRAIN_LEFT2[11] DRAIN_RIGHT1[11] DRAIN_RIGHT2[11]
+   GATE_LEFT1[11] GATE_LEFT2[11] GATE_RIGHT1[11] GATE_RIGHT2[11] LOG0 LOG1
+   LQB[11] RWL RWLD SDOR_OUT VBA[11] WBI[11] WTI[11] LLSB SDB_BC1T SDB_BC2T
+   mm19a04_u_hs1prf_rarm4x1
X_mm19a04_u_hs1prf_rarm4x1_F0 VDDA VDDAI[12] VDDP[12] VDDPI[12] VSS[12] VBP[12]
+   VBN[12] BADB[12] BB[48] BB[49] BB[50] BB[51] BT[48] BT[49] BT[50] BT[51]
+   DRAIN_LEFT1[12] DRAIN_LEFT2[12] DRAIN_RIGHT1[12] DRAIN_RIGHT2[12]
+   GATE_LEFT1[12] GATE_LEFT2[12] GATE_RIGHT1[12] GATE_RIGHT2[12] LOG0 LOG1
+   LQB[12] RWL RWLD SDOR_OUT VBA[12] WBI[12] WTI[12] LLSB SDB_BC1T SDB_BC2T
+   mm19a04_u_hs1prf_rarm4x1
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_ref_return BADB BB[0] BB[1] BB[2] BB[3] BT[0]
+       BT[1] BT[2] BT[3] DRAIN_LEFT1 DRAIN_LEFT2 DRAIN_RIGHT1 DRAIN_RIGHT2
+       GATE_LEFT1 GATE_LEFT2 GATE_RIGHT1 GATE_RIGHT2 LLSBR LOG0 LOG1 LQB RWL[0]
+       RWL[1] SDB_BC1TR SDB_BC2TR SDOR_OUTR VBA VBN VBP VDDA VDDAI VDDP VDDPI
+       VSS WBI WTI

*** Jumper Report ***
* Jumper: VDDA VDDP VDDPI

X_mm19a04_u_hs1prf_rarm4x1_ret VDDA VDDAI VDDP VDDPI VSS VBP VBN BADB BB[0]
+   BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3] DRAIN_LEFT1 DRAIN_LEFT2
+   DRAIN_RIGHT1 DRAIN_RIGHT2 GATE_LEFT1 GATE_LEFT2 GATE_RIGHT1 GATE_RIGHT2 LOG0
+   LOG1 LQB RWL[0] RWL[1] SDOR_OUTR VBA WBI WTI LLSBR SDB_BC1TR SDB_BC2TR
+   mm19a04_u_hs1prf_rarm4x1_ret
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_ref_rt_log0_seg1 BADB[0] BADB[1] BADB[2] BADB[3]
+       BADB[4] BADB[5] BADB[6] BADB[7] BADB[8] BADB[9] BADB[10] BADB[11]
+       BADB[12] BADB[13] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8]
+       BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18]
+       BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28]
+       BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38]
+       BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48]
+       BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BT[0] BT[1] BT[2] BT[3]
+       BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14]
+       BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+       BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34]
+       BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44]
+       BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54]
+       BT[55] DRAIN_LEFT1[0] DRAIN_LEFT2[0] DRAIN_RIGHT1[13] DRAIN_RIGHT2[13]
+       GATE_LEFT1[0] GATE_LEFT2[0] GATE_RIGHT1[13] GATE_RIGHT2[13] LLSB LOG0
+       LOG1 LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7] LQB[8]
+       LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] SDB_BC1T SDB_BC2T SDOR_OUT VBA[0]
+       VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10]
+       VBA[11] VBA[12] VBA[13] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+       VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBP[0] VBP[1]
+       VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+       VBP[12] VBP[13] VDDA VDDAI[0] VDDAI[1] VDDAI[2] VDDAI[3] VDDAI[4]
+       VDDAI[5] VDDAI[6] VDDAI[7] VDDAI[8] VDDAI[9] VDDAI[10] VDDAI[11]
+       VDDAI[12] VDDAI[13] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5]
+       VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+       VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+       VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VSS[0] VSS[1]
+       VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11]
+       VSS[12] VSS[13] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7]
+       WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WTI[0] WTI[1] WTI[2]
+       WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12]
+       WTI[13]

*** Jumper Report ***
* Jumper: VDDA VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13]

X_mm19a04_u_hs1prf_rarm4x1_S0 VDDA VDDAI[0] VDDP[0] VDDPI[0] VSS[0] VBP[0]
+   VBN[0] BADB[0] BB[0] BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3]
+   DRAIN_LEFT1[0] DRAIN_LEFT2[0] DRAIN_RIGHT1[0] DRAIN_RIGHT2[0] GATE_LEFT1[0]
+   GATE_LEFT2[0] GATE_RIGHT1[0] GATE_RIGHT2[0] LOG0 LOG1 LQB[0] LOG1 LOG1
+   SDOR_OUT VBA[0] WBI[0] WTI[0] LLSB SDB_BC1T SDB_BC2T
+   mm19a04_u_hs1prf_rarm4x1
X_mm19a04_u_hs1prf_rarm4x1_S1 VDDA VDDAI[1] VDDP[1] VDDPI[1] VSS[1] VBP[1]
+   VBN[1] BADB[1] BB[4] BB[5] BB[6] BB[7] BT[4] BT[5] BT[6] BT[7]
+   DRAIN_LEFT1[1] DRAIN_LEFT2[1] DRAIN_RIGHT1[1] DRAIN_RIGHT2[1] GATE_LEFT1[1]
+   GATE_LEFT2[1] GATE_RIGHT1[1] GATE_RIGHT2[1] LOG0 LOG1 LQB[1] LOG1 LOG1
+   SDOR_OUT VBA[1] WBI[1] WTI[1] LLSB SDB_BC1T SDB_BC2T
+   mm19a04_u_hs1prf_rarm4x1
X_mm19a04_u_hs1prf_rarm4x1_S2 VDDA VDDAI[2] VDDP[2] VDDPI[2] VSS[2] VBP[2]
+   VBN[2] BADB[2] BB[8] BB[9] BB[10] BB[11] BT[8] BT[9] BT[10] BT[11]
+   DRAIN_LEFT1[2] DRAIN_LEFT2[2] DRAIN_RIGHT1[2] DRAIN_RIGHT2[2] GATE_LEFT1[2]
+   GATE_LEFT2[2] GATE_RIGHT1[2] GATE_RIGHT2[2] LOG0 LOG1 LQB[2] LOG1 LOG1
+   SDOR_OUT VBA[2] WBI[2] WTI[2] LLSB SDB_BC1T SDB_BC2T
+   mm19a04_u_hs1prf_rarm4x1
X_mm19a04_u_hs1prf_rarm4x1_S3 VDDA VDDAI[3] VDDP[3] VDDPI[3] VSS[3] VBP[3]
+   VBN[3] BADB[3] BB[12] BB[13] BB[14] BB[15] BT[12] BT[13] BT[14] BT[15]
+   DRAIN_LEFT1[3] DRAIN_LEFT2[3] DRAIN_RIGHT1[3] DRAIN_RIGHT2[3] GATE_LEFT1[3]
+   GATE_LEFT2[3] GATE_RIGHT1[3] GATE_RIGHT2[3] LOG0 LOG1 LQB[3] LOG1 LOG1
+   SDOR_OUT VBA[3] WBI[3] WTI[3] LLSB SDB_BC1T SDB_BC2T
+   mm19a04_u_hs1prf_rarm4x1
X_mm19a04_u_hs1prf_rarm4x1_S4 VDDA VDDAI[4] VDDP[4] VDDPI[4] VSS[4] VBP[4]
+   VBN[4] BADB[4] BB[16] BB[17] BB[18] BB[19] BT[16] BT[17] BT[18] BT[19]
+   DRAIN_LEFT1[4] DRAIN_LEFT2[4] DRAIN_RIGHT1[4] DRAIN_RIGHT2[4] GATE_LEFT1[4]
+   GATE_LEFT2[4] GATE_RIGHT1[4] GATE_RIGHT2[4] LOG0 LOG1 LQB[4] LOG1 LOG1
+   SDOR_OUT VBA[4] WBI[4] WTI[4] LLSB SDB_BC1T SDB_BC2T
+   mm19a04_u_hs1prf_rarm4x1
X_mm19a04_u_hs1prf_rarm4x1_S5 VDDA VDDAI[5] VDDP[5] VDDPI[5] VSS[5] VBP[5]
+   VBN[5] BADB[5] BB[20] BB[21] BB[22] BB[23] BT[20] BT[21] BT[22] BT[23]
+   DRAIN_LEFT1[5] DRAIN_LEFT2[5] DRAIN_RIGHT1[5] DRAIN_RIGHT2[5] GATE_LEFT1[5]
+   GATE_LEFT2[5] GATE_RIGHT1[5] GATE_RIGHT2[5] LOG0 LOG1 LQB[5] LOG1 LOG1
+   SDOR_OUT VBA[5] WBI[5] WTI[5] LLSB SDB_BC1T SDB_BC2T
+   mm19a04_u_hs1prf_rarm4x1
X_mm19a04_u_hs1prf_rarm4x1_S6 VDDA VDDAI[6] VDDP[6] VDDPI[6] VSS[6] VBP[6]
+   VBN[6] BADB[6] BB[24] BB[25] BB[26] BB[27] BT[24] BT[25] BT[26] BT[27]
+   DRAIN_LEFT1[6] DRAIN_LEFT2[6] DRAIN_RIGHT1[6] DRAIN_RIGHT2[6] GATE_LEFT1[6]
+   GATE_LEFT2[6] GATE_RIGHT1[6] GATE_RIGHT2[6] LOG0 LOG1 LQB[6] LOG1 LOG1
+   SDOR_OUT VBA[6] WBI[6] WTI[6] LLSB SDB_BC1T SDB_BC2T
+   mm19a04_u_hs1prf_rarm4x1
X_mm19a04_u_hs1prf_rarm4x1_F6 VDDA VDDAI[7] VDDP[7] VDDPI[7] VSS[7] VBP[7]
+   VBN[7] BADB[7] BB[28] BB[29] BB[30] BB[31] BT[28] BT[29] BT[30] BT[31]
+   DRAIN_LEFT1[7] DRAIN_LEFT2[7] DRAIN_RIGHT1[7] DRAIN_RIGHT2[7] GATE_LEFT1[7]
+   GATE_LEFT2[7] GATE_RIGHT1[7] GATE_RIGHT2[7] LOG0 LOG1 LQB[7] LOG1 LOG1
+   SDOR_OUT VBA[7] WBI[7] WTI[7] LLSB SDB_BC1T SDB_BC2T
+   mm19a04_u_hs1prf_rarm4x1
X_mm19a04_u_hs1prf_rarm4x1_F5 VDDA VDDAI[8] VDDP[8] VDDPI[8] VSS[8] VBP[8]
+   VBN[8] BADB[8] BB[32] BB[33] BB[34] BB[35] BT[32] BT[33] BT[34] BT[35]
+   DRAIN_LEFT1[8] DRAIN_LEFT2[8] DRAIN_RIGHT1[8] DRAIN_RIGHT2[8] GATE_LEFT1[8]
+   GATE_LEFT2[8] GATE_RIGHT1[8] GATE_RIGHT2[8] LOG0 LOG1 LQB[8] LOG1 LOG1
+   SDOR_OUT VBA[8] WBI[8] WTI[8] LLSB SDB_BC1T SDB_BC2T
+   mm19a04_u_hs1prf_rarm4x1
X_mm19a04_u_hs1prf_rarm4x1_F4 VDDA VDDAI[9] VDDP[9] VDDPI[9] VSS[9] VBP[9]
+   VBN[9] BADB[9] BB[36] BB[37] BB[38] BB[39] BT[36] BT[37] BT[38] BT[39]
+   DRAIN_LEFT1[9] DRAIN_LEFT2[9] DRAIN_RIGHT1[9] DRAIN_RIGHT2[9] GATE_LEFT1[9]
+   GATE_LEFT2[9] GATE_RIGHT1[9] GATE_RIGHT2[9] LOG0 LOG1 LQB[9] LOG1 LOG1
+   SDOR_OUT VBA[9] WBI[9] WTI[9] LLSB SDB_BC1T SDB_BC2T
+   mm19a04_u_hs1prf_rarm4x1
X_mm19a04_u_hs1prf_rarm4x1_F3 VDDA VDDAI[10] VDDP[10] VDDPI[10] VSS[10] VBP[10]
+   VBN[10] BADB[10] BB[40] BB[41] BB[42] BB[43] BT[40] BT[41] BT[42] BT[43]
+   DRAIN_LEFT1[10] DRAIN_LEFT2[10] DRAIN_RIGHT1[10] DRAIN_RIGHT2[10]
+   GATE_LEFT1[10] GATE_LEFT2[10] GATE_RIGHT1[10] GATE_RIGHT2[10] LOG0 LOG1
+   LQB[10] LOG1 LOG1 SDOR_OUT VBA[10] WBI[10] WTI[10] LLSB SDB_BC1T SDB_BC2T
+   mm19a04_u_hs1prf_rarm4x1
X_mm19a04_u_hs1prf_rarm4x1_F2 VDDA VDDAI[11] VDDP[11] VDDPI[11] VSS[11] VBP[11]
+   VBN[11] BADB[11] BB[44] BB[45] BB[46] BB[47] BT[44] BT[45] BT[46] BT[47]
+   DRAIN_LEFT1[11] DRAIN_LEFT2[11] DRAIN_RIGHT1[11] DRAIN_RIGHT2[11]
+   GATE_LEFT1[11] GATE_LEFT2[11] GATE_RIGHT1[11] GATE_RIGHT2[11] LOG0 LOG1
+   LQB[11] LOG1 LOG1 SDOR_OUT VBA[11] WBI[11] WTI[11] LLSB SDB_BC1T SDB_BC2T
+   mm19a04_u_hs1prf_rarm4x1
X_mm19a04_u_hs1prf_rarm4x1_F1 VDDA VDDAI[12] VDDP[12] VDDPI[12] VSS[12] VBP[12]
+   VBN[12] BADB[12] BB[48] BB[49] BB[50] BB[51] BT[48] BT[49] BT[50] BT[51]
+   DRAIN_LEFT1[12] DRAIN_LEFT2[12] DRAIN_RIGHT1[12] DRAIN_RIGHT2[12]
+   GATE_LEFT1[12] GATE_LEFT2[12] GATE_RIGHT1[12] GATE_RIGHT2[12] LOG0 LOG1
+   LQB[12] LOG1 LOG1 SDOR_OUT VBA[12] WBI[12] WTI[12] LLSB SDB_BC1T SDB_BC2T
+   mm19a04_u_hs1prf_rarm4x1
X_mm19a04_u_hs1prf_rarm4x1_F0 VDDA VDDAI[13] VDDP[13] VDDPI[13] VSS[13] VBP[13]
+   VBN[13] BADB[13] BB[52] BB[53] BB[54] BB[55] BT[52] BT[53] BT[54] BT[55]
+   DRAIN_LEFT1[13] DRAIN_LEFT2[13] DRAIN_RIGHT1[13] DRAIN_RIGHT2[13]
+   GATE_LEFT1[13] GATE_LEFT2[13] GATE_RIGHT1[13] GATE_RIGHT2[13] LOG0 LOG1
+   LQB[13] LOG1 LOG1 SDOR_OUT VBA[13] WBI[13] WTI[13] LLSB SDB_BC1T SDB_BC2T
+   mm19a04_u_hs1prf_rarm4x1
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_ref_rt BADB[0] BADB[1] BADB[2] BADB[3] BADB[4]
+       BADB[5] BADB[6] BADB[7] BADB[8] BADB[9] BADB[10] BADB[11] BADB[12]
+       BADB[13] BADB[14] BADB[15] BADB[16] BADB[17] BADB[18] BADB[19] BADB[20]
+       BADB[21] BADB[22] BADB[23] BADB[24] BADB[25] BADB[26] BADB[27] BB[0]
+       BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11]
+       BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+       BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31]
+       BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41]
+       BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51]
+       BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61]
+       BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+       BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81]
+       BB[82] BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91]
+       BB[92] BB[93] BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101]
+       BB[102] BB[103] BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110]
+       BB[111] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9]
+       BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19]
+       BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28] BT[29]
+       BT[30] BT[31] BT[32] BT[33] BT[34] BT[35] BT[36] BT[37] BT[38] BT[39]
+       BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47] BT[48] BT[49]
+       BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57] BT[58] BT[59]
+       BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68] BT[69]
+       BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79]
+       BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89]
+       BT[90] BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99]
+       BT[100] BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108]
+       BT[109] BT[110] BT[111] DRAIN_LEFT1[0] DRAIN_LEFT2[0] GATE_LEFT1[0]
+       GATE_LEFT2[0] LLSBR LOG0 LOG1 LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5]
+       LQB[6] LQB[7] LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14]
+       LQB[15] LQB[16] LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23]
+       LQB[24] LQB[25] LQB[26] LQB[27] PGIOIR RWL SDB_BC1TR SDB_BC2TR SDOR_OUTR
+       VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9]
+       VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16] VBA[17] VBA[18]
+       VBA[19] VBA[20] VBA[21] VBA[22] VBA[23] VBA[24] VBA[25] VBA[26] VBA[27]
+       VBA[28] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+       VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+       VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+       VBN[27] VBN[28] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7]
+       VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+       VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+       VBP[26] VBP[27] VBP[28] VDDA VDDAI_H_T1[0] VDDAI_H_T1[1] VDDAI_H_T1[2]
+       VDDAI_H_T1[3] VDDAI_H_T1[4] VDDAI_H_T1[5] VDDAI_H_T1[6] VDDAI_H_T1[7]
+       VDDAI_H_T1[8] VDDAI_H_T1[9] VDDAI_H_T1[10] VDDAI_H_T1[11] VDDAI_H_T1[12]
+       VDDAI_H_T1[13] VDDAI_H_T1[14] VDDAI_H_T1[15] VDDAI_H_T1[16]
+       VDDAI_H_T1[17] VDDAI_H_T1[18] VDDAI_H_T1[19] VDDAI_H_T1[20]
+       VDDAI_H_T1[21] VDDAI_H_T1[22] VDDAI_H_T1[23] VDDAI_H_T1[24]
+       VDDAI_H_T1[25] VDDAI_H_T1[26] VDDAI_H_T1[27] VDDP[0] VDDP[1] VDDP[2]
+       VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+       VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+       VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+       VDDP[27] VDDP[28] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5]
+       VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+       VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19]
+       VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26]
+       VDDPI[27] VDDPI[28] VEDGE_O VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+       VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14]
+       VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23]
+       VSS[24] VSS[25] VSS[26] VSS[27] VSS[28] WBI[0] WBI[1] WBI[2] WBI[3]
+       WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12]
+       WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21]
+       WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27] WTI[0] WTI[1] WTI[2]
+       WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12]
+       WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21]
+       WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27]

*** Jumper Report ***
* Jumper: LOG0 PGIOIR
* Jumper: VBA[28] VSS[28]
* Jumper: VDDA VDDP[28]

X_ref_rt_rwl_seg1 BADB[0] BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6]
+   BADB[7] BADB[8] BADB[9] BADB[10] BADB[11] BADB[12] BB[0] BB[1] BB[2] BB[3]
+   BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14]
+   BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25]
+   BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+   BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47]
+   BB[48] BB[49] BB[50] BB[51] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7]
+   BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16] BT[17] BT[18]
+   BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28] BT[29]
+   BT[30] BT[31] BT[32] BT[33] BT[34] BT[35] BT[36] BT[37] BT[38] BT[39] BT[40]
+   BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51]
+   DRAIN_LEFT1[0] DRAIN_LEFT2[0] DRAIN_RIGHT1[0] DRAIN_RIGHT2[0] GATE_LEFT1[0]
+   GATE_LEFT2[0] GATE_RIGHT1[0] GATE_RIGHT2[0] LLSBR LOG0 LOG1 LQB[0] LQB[1]
+   LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7] LQB[8] LQB[9] LQB[10] LQB[11]
+   LQB[12] RWL RWL SDB_BC1TR SDB_BC2TR SDOR_OUTR VBA[0] VBA[1] VBA[2] VBA[3]
+   VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBN[0]
+   VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10]
+   VBN[11] VBN[12] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7]
+   VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VDDA VDDAI_H_T1[0] VDDAI_H_T1[1]
+   VDDAI_H_T1[2] VDDAI_H_T1[3] VDDAI_H_T1[4] VDDAI_H_T1[5] VDDAI_H_T1[6]
+   VDDAI_H_T1[7] VDDAI_H_T1[8] VDDAI_H_T1[9] VDDAI_H_T1[10] VDDAI_H_T1[11]
+   VDDAI_H_T1[12] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6]
+   VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDPI[0] VDDPI[1]
+   VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9]
+   VDDPI[10] VDDPI[11] VDDPI[12] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+   VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] WBI[0] WBI[1] WBI[2]
+   WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9]
+   WTI[10] WTI[11] WTI[12] SNPS_RF_SP_UHS_256x28_ref_rt_rwl_seg1
X_ref_return BADB[13] BB[52] BB[53] BB[54] BB[55] BT[52] BT[53] BT[54] BT[55]
+   DRAIN_LEFT1[1] DRAIN_LEFT2[1] DRAIN_RIGHT1[1] DRAIN_RIGHT2[1] GATE_LEFT1[1]
+   GATE_LEFT2[1] GATE_RIGHT1[1] GATE_RIGHT2[1] LLSBR LOG0 LOG1 LQB[13] RWL RWL
+   SDB_BC1TR SDB_BC2TR SDOR_OUTR VBA[13] VBN[13] VBP[13] VDDA VDDAI_H_T1[13]
+   VDDP[13] VDDPI[13] VSS[13] WBI[13] WTI[13] SNPS_RF_SP_UHS_256x28_ref_return
X_ref_rt_log0_seg1 BADB[14] BADB[15] BADB[16] BADB[17] BADB[18] BADB[19]
+   BADB[20] BADB[21] BADB[22] BADB[23] BADB[24] BADB[25] BADB[26] BADB[27]
+   BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BB[64] BB[65] BB[66]
+   BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75] BB[76] BB[77]
+   BB[78] BB[79] BB[80] BB[81] BB[82] BB[83] BB[84] BB[85] BB[86] BB[87] BB[88]
+   BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95] BB[96] BB[97] BB[98] BB[99]
+   BB[100] BB[101] BB[102] BB[103] BB[104] BB[105] BB[106] BB[107] BB[108]
+   BB[109] BB[110] BB[111] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62]
+   BT[63] BT[64] BT[65] BT[66] BT[67] BT[68] BT[69] BT[70] BT[71] BT[72] BT[73]
+   BT[74] BT[75] BT[76] BT[77] BT[78] BT[79] BT[80] BT[81] BT[82] BT[83] BT[84]
+   BT[85] BT[86] BT[87] BT[88] BT[89] BT[90] BT[91] BT[92] BT[93] BT[94] BT[95]
+   BT[96] BT[97] BT[98] BT[99] BT[100] BT[101] BT[102] BT[103] BT[104] BT[105]
+   BT[106] BT[107] BT[108] BT[109] BT[110] BT[111] DRAIN_LEFT1[2]
+   DRAIN_LEFT2[2] DRAIN_RIGHT1[2] DRAIN_RIGHT2[2] GATE_LEFT1[2] GATE_LEFT2[2]
+   GATE_RIGHT1[2] GATE_RIGHT2[2] LLSBR LOG0 LOG1 LQB[14] LQB[15] LQB[16]
+   LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25]
+   LQB[26] LQB[27] SDB_BC1TR SDB_BC2TR SDOR_OUTR VBA[14] VBA[15] VBA[16]
+   VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23] VBA[24] VBA[25]
+   VBA[26] VBA[27] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20]
+   VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBP[14] VBP[15]
+   VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24]
+   VBP[25] VBP[26] VBP[27] VDDA VDDAI_H_T1[14] VDDAI_H_T1[15] VDDAI_H_T1[16]
+   VDDAI_H_T1[17] VDDAI_H_T1[18] VDDAI_H_T1[19] VDDAI_H_T1[20] VDDAI_H_T1[21]
+   VDDAI_H_T1[22] VDDAI_H_T1[23] VDDAI_H_T1[24] VDDAI_H_T1[25] VDDAI_H_T1[26]
+   VDDAI_H_T1[27] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19]
+   VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27]
+   VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20]
+   VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27]
+   VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22]
+   VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] WBI[14] WBI[15] WBI[16] WBI[17]
+   WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26]
+   WBI[27] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21]
+   WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27]
+   SNPS_RF_SP_UHS_256x28_ref_rt_log0_seg1
X_mm19a04_u_hs1prf_pg_pwedge VDDA VDDAI_H_T1[28] VDDP[28] VDDPI[28] VSS[28]
+   VBP[28] VBN[28] VEDGE_O DRAIN_LEFT2[3] GATE_LEFT1[3] GATE_LEFT2[3] LOG0 LOG1
+   PGIOIR SDOR_OUT VBA[28] SDOR_IN mm19a04_u_hs1prf_pg_pwedge
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_ref_row_t ARYSDR ARYSD_BC1 ARYSD_BC2 ARYSD_TOP
+       BADB[0] BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7] BADB[8]
+       BADB[9] BADB[10] BADB[11] BADB[12] BADB[13] BADB[14] BADB[15] BADB[16]
+       BADB[17] BADB[18] BADB[19] BADB[20] BADB[21] BADB[22] BADB[23] BADB[24]
+       BADB[25] BADB[26] BADB[27] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+       BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+       BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+       BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BB[64] BB[65] BB[66]
+       BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75] BB[76]
+       BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83] BB[84] BB[85] BB[86]
+       BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95] BB[96]
+       BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103] BB[104] BB[105]
+       BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BT[0] BT[1] BT[2] BT[3]
+       BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14]
+       BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+       BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34]
+       BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44]
+       BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54]
+       BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64]
+       BT[65] BT[66] BT[67] BT[68] BT[69] BT[70] BT[71] BT[72] BT[73] BT[74]
+       BT[75] BT[76] BT[77] BT[78] BT[79] BT[80] BT[81] BT[82] BT[83] BT[84]
+       BT[85] BT[86] BT[87] BT[88] BT[89] BT[90] BT[91] BT[92] BT[93] BT[94]
+       BT[95] BT[96] BT[97] BT[98] BT[99] BT[100] BT[101] BT[102] BT[103]
+       BT[104] BT[105] BT[106] BT[107] BT[108] BT[109] BT[110] BT[111] CENDP
+       CKGATE DEF_MODE DLYPDB FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET
+       LBKADR LCGTH LDFTX LITESLP LOG0 LOG1 LQB[0] LQB[1] LQB[2] LQB[3] LQB[4]
+       LQB[5] LQB[6] LQB[7] LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13]
+       LQB[14] LQB[15] LQB[16] LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22]
+       LQB[23] LQB[24] LQB[25] LQB[26] LQB[27] LWEIB LXADR[0] LXADR[1] LXADR[2]
+       LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PGIOIR
+       PROCOML RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] RBLRD RBLWA RBLWR
+       RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB T1T TEST_RNMB TOPEDGE VBA[0]
+       VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10]
+       VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16] VBA[17] VBA[18] VBA[19]
+       VBA[20] VBA[21] VBA[22] VBA[23] VBA[24] VBA[25] VBA[26] VBA[27] VBA[28]
+       VBA[29] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+       VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+       VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+       VBN[27] VBN[28] VBN[29] VBN[30] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4]
+       VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+       VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+       VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VDDA
+       VDDAI_H_T1[0] VDDAI_H_T1[1] VDDAI_H_T1[2] VDDAI_H_T1[3] VDDAI_H_T1[4]
+       VDDAI_H_T1[5] VDDAI_H_T1[6] VDDAI_H_T1[7] VDDAI_H_T1[8] VDDAI_H_T1[9]
+       VDDAI_H_T1[10] VDDAI_H_T1[11] VDDAI_H_T1[12] VDDAI_H_T1[13]
+       VDDAI_H_T1[14] VDDAI_H_T1[15] VDDAI_H_T1[16] VDDAI_H_T1[17]
+       VDDAI_H_T1[18] VDDAI_H_T1[19] VDDAI_H_T1[20] VDDAI_H_T1[21]
+       VDDAI_H_T1[22] VDDAI_H_T1[23] VDDAI_H_T1[24] VDDAI_H_T1[25]
+       VDDAI_H_T1[26] VDDAI_H_T1[27] VDDF VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+       VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11]
+       VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19]
+       VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27]
+       VDDP[28] VDDP[29] VDDP[30] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+       VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+       VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18]
+       VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25]
+       VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30] VDDWL VDDWL_PCOM
+       VEDGE_O VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+       VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17]
+       VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26]
+       VSS[27] VSS[28] VSS[29] VSS[30] VSSWLL VSSWLR WABUF[0] WABUF[1] WABUF[2]
+       WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9]
+       WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18]
+       WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27]
+       WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WTI[0] WTI[1]
+       WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11]
+       WTI[12] WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20]
+       WTI[21] WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27]
X_ref_cnt ARYSDR ARYSD_BC1 ARYSD_BC2 ARYSD_TOP CENDP CKGATE DEF_MODE DLYPDB
+   DRAIN_RIGHT2 FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET GATE_RIGHT1
+   GATE_RIGHT2 LBKADR LCGTH LCGTHB LDFTX LITESLP LLSBR LOG0 LOG1 LWEIB LXADR[0]
+   LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+   LYADR[1] PROCOML RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] RBLRD RBLWA
+   RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWL RWLB RWL SDB_BC1TR SDB_BC2TR
+   SDOR_INR SDOR_OUT T1T TEST_RNMB TOPEDGE VBA[0] VBN[0] VBN[1] VBP[0] VBP[1]
+   VDDA VDDF VDDP[0] VDDP[1] VDDPI[0] VDDPI[1] VDDWL VDDWL_PCOM VSS[0] VSS[1]
+   VSSWLL VSSWLR WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3]
+   WPBUF[0] WPBUF[1] WPBUF[2] SNPS_RF_SP_UHS_256x28_ref_cnt
X_ref_rt BADB[0] BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7] BADB[8]
+   BADB[9] BADB[10] BADB[11] BADB[12] BADB[13] BADB[14] BADB[15] BADB[16]
+   BADB[17] BADB[18] BADB[19] BADB[20] BADB[21] BADB[22] BADB[23] BADB[24]
+   BADB[25] BADB[26] BADB[27] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7]
+   BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18]
+   BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29]
+   BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40]
+   BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51]
+   BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62]
+   BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73]
+   BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83] BB[84]
+   BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95]
+   BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103] BB[104] BB[105]
+   BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BT[0] BT[1] BT[2] BT[3]
+   BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14]
+   BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25]
+   BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35] BT[36]
+   BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47]
+   BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57] BT[58]
+   BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68] BT[69]
+   BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79] BT[80]
+   BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90] BT[91]
+   BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100] BT[101]
+   BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109] BT[110]
+   BT[111] DRAIN_LEFT1 DRAIN_LEFT2 GATE_LEFT1 GATE_LEFT2 LLSBR LOG0 LOG1 LQB[0]
+   LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7] LQB[8] LQB[9] LQB[10]
+   LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16] LQB[17] LQB[18] LQB[19]
+   LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25] LQB[26] LQB[27] PGIOIR RWL
+   SDB_BC1TR SDB_BC2TR SDOR_OUTR VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23] VBA[24] VBA[25]
+   VBA[26] VBA[27] VBA[28] VBA[29] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7]
+   VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+   VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25]
+   VBN[26] VBN[27] VBN[28] VBN[29] VBN[30] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+   VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+   VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+   VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VDDA VDDAI_H_T1[0] VDDAI_H_T1[1]
+   VDDAI_H_T1[2] VDDAI_H_T1[3] VDDAI_H_T1[4] VDDAI_H_T1[5] VDDAI_H_T1[6]
+   VDDAI_H_T1[7] VDDAI_H_T1[8] VDDAI_H_T1[9] VDDAI_H_T1[10] VDDAI_H_T1[11]
+   VDDAI_H_T1[12] VDDAI_H_T1[13] VDDAI_H_T1[14] VDDAI_H_T1[15] VDDAI_H_T1[16]
+   VDDAI_H_T1[17] VDDAI_H_T1[18] VDDAI_H_T1[19] VDDAI_H_T1[20] VDDAI_H_T1[21]
+   VDDAI_H_T1[22] VDDAI_H_T1[23] VDDAI_H_T1[24] VDDAI_H_T1[25] VDDAI_H_T1[26]
+   VDDAI_H_T1[27] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8]
+   VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16]
+   VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24]
+   VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18]
+   VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25]
+   VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30] VEDGE_O VSS[2] VSS[3]
+   VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13]
+   VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22]
+   VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10]
+   WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18] WBI[19]
+   WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27] WTI[0]
+   WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10]
+   WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19]
+   WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27]
+   SNPS_RF_SP_UHS_256x28_ref_rt
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_ref_row ARYSDR ARYSD_BC1 ARYSD_BC2 ARYSD_TOP
+       BADB[0] BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7] BADB[8]
+       BADB[9] BADB[10] BADB[11] BADB[12] BADB[13] BADB[14] BADB[15] BADB[16]
+       BADB[17] BADB[18] BADB[19] BADB[20] BADB[21] BADB[22] BADB[23] BADB[24]
+       BADB[25] BADB[26] BADB[27] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+       BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+       BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+       BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BB[64] BB[65] BB[66]
+       BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75] BB[76]
+       BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83] BB[84] BB[85] BB[86]
+       BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95] BB[96]
+       BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103] BB[104] BB[105]
+       BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BT[0] BT[1] BT[2] BT[3]
+       BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14]
+       BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+       BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34]
+       BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44]
+       BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54]
+       BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64]
+       BT[65] BT[66] BT[67] BT[68] BT[69] BT[70] BT[71] BT[72] BT[73] BT[74]
+       BT[75] BT[76] BT[77] BT[78] BT[79] BT[80] BT[81] BT[82] BT[83] BT[84]
+       BT[85] BT[86] BT[87] BT[88] BT[89] BT[90] BT[91] BT[92] BT[93] BT[94]
+       BT[95] BT[96] BT[97] BT[98] BT[99] BT[100] BT[101] BT[102] BT[103]
+       BT[104] BT[105] BT[106] BT[107] BT[108] BT[109] BT[110] BT[111] CENDP
+       CKGATE DEF_MODE DLYPDB FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET
+       LBKADR LCGTH LDFTX LITESLP LOG0 LOG1 LQB[0] LQB[1] LQB[2] LQB[3] LQB[4]
+       LQB[5] LQB[6] LQB[7] LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13]
+       LQB[14] LQB[15] LQB[16] LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22]
+       LQB[23] LQB[24] LQB[25] LQB[26] LQB[27] LWEIB LXADR[0] LXADR[1] LXADR[2]
+       LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PGIOIR
+       PROCOML RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] RBLRD RBLWA RBLWR
+       RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB T1T TEST_RNMB TOPEDGE VBA VBN
+       VBP VDDA VDDAI_H_T1 VDDF VDDP VDDPI VDDWL VDDWL_PCOM VEDGE_O VSS VSSWLL
+       VSSWLR WABUF[0] WABUF[1] WABUF[2] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4]
+       WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13]
+       WBI[14] WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22]
+       WBI[23] WBI[24] WBI[25] WBI[26] WBI[27] WMT[0] WMT[1] WMT[2] WMT[3]
+       WPBUF[0] WPBUF[1] WPBUF[2] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+       WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14]
+       WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23]
+       WTI[24] WTI[25] WTI[26] WTI[27]
X_ref_row_t ARYSDR ARYSD_BC1 ARYSD_BC2 ARYSD_TOP BADB[0] BADB[1] BADB[2] BADB[3]
+   BADB[4] BADB[5] BADB[6] BADB[7] BADB[8] BADB[9] BADB[10] BADB[11] BADB[12]
+   BADB[13] BADB[14] BADB[15] BADB[16] BADB[17] BADB[18] BADB[19] BADB[20]
+   BADB[21] BADB[22] BADB[23] BADB[24] BADB[25] BADB[26] BADB[27] BB[0] BB[1]
+   BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13]
+   BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24]
+   BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35]
+   BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+   BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57]
+   BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68]
+   BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79]
+   BB[80] BB[81] BB[82] BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90]
+   BB[91] BB[92] BB[93] BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100]
+   BB[101] BB[102] BB[103] BB[104] BB[105] BB[106] BB[107] BB[108] BB[109]
+   BB[110] BB[111] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9]
+   BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20]
+   BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31]
+   BT[32] BT[33] BT[34] BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42]
+   BT[43] BT[44] BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53]
+   BT[54] BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64]
+   BT[65] BT[66] BT[67] BT[68] BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75]
+   BT[76] BT[77] BT[78] BT[79] BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86]
+   BT[87] BT[88] BT[89] BT[90] BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97]
+   BT[98] BT[99] BT[100] BT[101] BT[102] BT[103] BT[104] BT[105] BT[106]
+   BT[107] BT[108] BT[109] BT[110] BT[111] CENDP CKGATE DEF_MODE DLYPDB
+   FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR LCGTH LDFTX LITESLP LOG0
+   LOG1 LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7] LQB[8] LQB[9]
+   LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16] LQB[17] LQB[18]
+   LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25] LQB[26] LQB[27]
+   LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6]
+   LXADR[7] LYADR[0] LYADR[1] PGIOIR PROCOML RASSIST[0] RASSIST[1] RASSISTB[0]
+   RASSISTB[1] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB T1T
+   TEST_RNMB TOPEDGE VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA
+   VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VDDA VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1
+   VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1
+   VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1
+   VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1 VDDAI_H_T1
+   VDDAI_H_T1 VDDAI_H_T1 VDDF VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDWL VDDWL_PCOM VEDGE_O VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSSWLL VSSWLR WABUF[0] WABUF[1] WABUF[2] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4]
+   WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14]
+   WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23]
+   WBI[24] WBI[25] WBI[26] WBI[27] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0]
+   WPBUF[1] WPBUF[2] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16]
+   WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25]
+   WTI[26] WTI[27] SNPS_RF_SP_UHS_256x28_ref_row_t
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_top ARYSDR ARYSD_BC1 ARYSD_BC2 ARYSD_TOP BADB[28]
+       BADB[29] BADB[30] BADB[31] BADB[32] BADB[33] BADB[34] BADB[35] BADB[36]
+       BADB[37] BADB[38] BADB[39] BADB[40] BADB[41] BADB[42] BADB[43] BADB[44]
+       BADB[45] BADB[46] BADB[47] BADB[48] BADB[49] BADB[50] BADB[51] BADB[52]
+       BADB[53] BADB[54] BADB[55] BC0 BC1 BC2 BKADR CENDP CKGATE[1] CLK D[0]
+       D[1] D[2] D[3] D[4] D[5] D[6] D[7] D[8] D[9] D[10] D[11] D[12] D[13]
+       D[14] D[15] D[16] D[17] D[18] D[19] D[20] D[21] D[22] D[23] D[24] D[25]
+       D[26] D[27] DEF_MODE DFTCLKEN DLYPDB DS FAST1_MODE FAST2_MODE FISO FLOAT
+       FLOATT FLOAT_RET[1] LBKADR[1] LDFTX LITESLP LOG0 LOG1 LQB[28] LQB[29]
+       LQB[30] LQB[31] LQB[32] LQB[33] LQB[34] LQB[35] LQB[36] LQB[37] LQB[38]
+       LQB[39] LQB[40] LQB[41] LQB[42] LQB[43] LQB[44] LQB[45] LQB[46] LQB[47]
+       LQB[48] LQB[49] LQB[50] LQB[51] LQB[52] LQB[53] LQB[54] LQB[55] LS LWEIB
+       LXADR[8] LXADR[9] LXADR[10] LXADR[11] LXADR[12] LXADR[13] LXADR[14]
+       LXADR[15] LYADR[2] LYADR[3] ME PGIOIR PROCOM[0] PROCOM[1] PROCOML Q[0]
+       Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13]
+       Q[14] Q[15] Q[16] Q[17] Q[18] Q[19] Q[20] Q[21] Q[22] Q[23] Q[24] Q[25]
+       Q[26] Q[27] RA[0] RA[1] RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1]
+       RBLRD RBLWA RBLWR RM[0] RM[1] RM[2] RM[3] RM3CNT RME RMT[0] RMT[1]
+       RMT[2] RMT[3] RSCEN RSCIN RSCLK RSCOUT RSCRST RWLB SD T1T TEST1 TEST_RNM
+       TEST_RNMB TOPEDGE VBN VBP VDDA VDDAI_H_T1 VDDF VDDP VDDPI VDDWL_PCOM[1]
+       VEDGE_O VSS VSSWLL VSSWLR WA[0] WA[1] WABUF[0] WABUF[1] WABUF[2] WBI[28]
+       WBI[29] WBI[30] WBI[31] WBI[32] WBI[33] WBI[34] WBI[35] WBI[36] WBI[37]
+       WBI[38] WBI[39] WBI[40] WBI[41] WBI[42] WBI[43] WBI[44] WBI[45] WBI[46]
+       WBI[47] WBI[48] WBI[49] WBI[50] WBI[51] WBI[52] WBI[53] WBI[54] WBI[55]
+       WE WEM[0] WEM[1] WEM[2] WEM[3] WEM[4] WEM[5] WEM[6] WEM[7] WEM[8] WEM[9]
+       WEM[10] WEM[11] WEM[12] WEM[13] WEM[14] WEM[15] WEM[16] WEM[17] WEM[18]
+       WEM[19] WEM[20] WEM[21] WEM[22] WEM[23] WEM[24] WEM[25] WEM[26] WEM[27]
+       WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WPULSE[0]
+       WPULSE[1] WPULSE[2] WTI[28] WTI[29] WTI[30] WTI[31] WTI[32] WTI[33]
+       WTI[34] WTI[35] WTI[36] WTI[37] WTI[38] WTI[39] WTI[40] WTI[41] WTI[42]
+       WTI[43] WTI[44] WTI[45] WTI[46] WTI[47] WTI[48] WTI[49] WTI[50] WTI[51]
+       WTI[52] WTI[53] WTI[54] WTI[55] XADR[0] XADR[1] XADR[2] XADR[3] XADR[4]
+       XADR[5] XADR[6] XADR[7] YADR[0] YADR[1]

*** Jumper Report ***
* Jumper: LOG0 BKADR DFTCLKEN DS FISO RA[0] RA[1] RSCEN RSCIN RSCLK RSCRST SD XADR[6] XADR[7]
* Jumper: LOG1 WEM[0] WEM[1] WEM[2] WEM[3] WEM[4] WEM[5] WEM[6] WEM[7] WEM[8] WEM[9] WEM[10] WEM[11] WEM[12] WEM[13] WEM[14] WEM[15] WEM[16] WEM[17] WEM[18] WEM[19] WEM[20] WEM[21] WEM[22] WEM[23] WEM[24] WEM[25] WEM[26] WEM[27]

*X_pin_row BC0 BC1 BC2 BKADR CLK D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] D[8]
*+  D[9] D[10] D[11] D[12] D[13] D[14] D[15] D[16] D[17] D[18] D[19] D[20] D[21]
*+  D[22] D[23] D[24] D[25] D[26] D[27] DFTCLKEN DS FISO LOG0 LOG1 LS ME
*+  PROCOM[0] PROCOM[1] Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] Q[8] Q[9] Q[10]
*+  Q[11] Q[12] Q[13] Q[14] Q[15] Q[16] Q[17] Q[18] Q[19] Q[20] Q[21] Q[22]
*+  Q[23] Q[24] Q[25] Q[26] Q[27] RA[0] RA[1] RM[0] RM[1] RM[2] RM[3] RME RSCEN
*+  RSCIN RSCLK RSCOUT RSCRST SD TEST1 TEST_RNM VBN VBN VBN VBP VBP VBP VDDF
*+  VDDP VDDPI VNWP VSS VSS WA[0] WA[1] WE WEM[0] WEM[1] WEM[2] WEM[3] WEM[4]
*+  WEM[5] WEM[6] WEM[7] WEM[8] WEM[9] WEM[10] WEM[11] WEM[12] WEM[13] WEM[14]
*+  WEM[15] WEM[16] WEM[17] WEM[18] WEM[19] WEM[20] WEM[21] WEM[22] WEM[23]
*+  WEM[24] WEM[25] WEM[26] WEM[27] WPULSE[0] WPULSE[1] WPULSE[2] XADR[0]
*+  XADR[1] XADR[2] XADR[3] XADR[4] XADR[5] XADR[6] XADR[7] YADR[0] YADR[1]
*+  SNPS_RF_SP_UHS_256x28_pin_row
X_gio_row ARYSDR ARYSD_BC1 ARYSD_BC2 BC0 BC1 BC2 BKADR CB[0] CB[1] CB[2] CB[3]
+   CB[4] CB[5] CB[6] CB[7] CB[8] CB[9] CB[10] CB[11] CB[12] CB[13] CB[14]
+   CB[15] CB[16] CB[17] CB[18] CB[19] CB[20] CB[21] CB[22] CB[23] CB[24] CB[25]
+   CB[26] CB[27] CENDP CKGATE[0] CLK CLKB CLKDEL CLKDEL CLKB LOG0 CT[0] CT[1]
+   CT[2] CT[3] CT[4] CT[5] CT[6] CT[7] CT[8] CT[9] CT[10] CT[11] CT[12] CT[13]
+   CT[14] CT[15] CT[16] CT[17] CT[18] CT[19] CT[20] CT[21] CT[22] CT[23] CT[24]
+   CT[25] CT[26] CT[27] D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] D[8] D[9] D[10]
+   D[11] D[12] D[13] D[14] D[15] D[16] D[17] D[18] D[19] D[20] D[21] D[22]
+   D[23] D[24] D[25] D[26] D[27] DEF1 DEF12B_PROG DEF12_PROG DEF1B DEF2 DEF2B
+   DEF_MODE DEF1 DFTCLKEN LOG0 DIB[0] DIB[1] DIB[2] DIB[3] DIB[4] DIB[5] DIB[6]
+   DIB[7] DIB[8] DIB[9] DIB[10] DIB[11] DIB[12] DIB[13] DIB[14] DIB[15] DIB[16]
+   DIB[17] DIB[18] DIB[19] DIB[20] DIB[21] DIB[22] DIB[23] DIB[24] DIB[25]
+   DIB[26] DIB[27] DINB[0] DINB[1] DINB[2] DINB[3] DINB[4] DINB[5] DINB[6]
+   DINB[7] DINB[8] DINB[9] DINB[10] DINB[11] DINB[12] DINB[13] DINB[14]
+   DINB[15] DINB[16] DINB[17] DINB[18] DINB[19] DINB[20] DINB[21] DINB[22]
+   DINB[23] DINB[24] DINB[25] DINB[26] DINB[27] DISCHG DLYPDB LOG0 DINB[0]
+   DINB[1] DINB[2] DINB[3] DINB[4] DINB[5] DINB[6] DINB[7] DINB[8] DINB[9]
+   DINB[10] DINB[11] DINB[12] DINB[13] DINB[14] DINB[15] DINB[16] DINB[17]
+   DINB[18] DINB[19] DINB[20] DINB[21] DINB[22] DINB[23] DINB[24] DINB[25]
+   DINB[26] DINB[27] FAST1_MODE FAST2_MODE FISO FLOAT FLOAT_RET[0] LOG1 LOG0
+   IV_WB[0] IV_WB[1] IV_WB[2] IV_WB[3] IV_WB[4] IV_WB[5] IV_WB[6] IV_WB[7]
+   IV_WB[8] IV_WB[9] IV_WB[10] IV_WB[11] IV_WB[12] IV_WB[13] IV_WB[14]
+   IV_WB[15] IV_WB[16] IV_WB[17] IV_WB[18] IV_WB[19] IV_WB[20] IV_WB[21]
+   IV_WB[22] IV_WB[23] IV_WB[24] IV_WB[25] IV_WB[26] IV_WB[27] IV_WT[0]
+   IV_WT[1] IV_WT[2] IV_WT[3] IV_WT[4] IV_WT[5] IV_WT[6] IV_WT[7] IV_WT[8]
+   IV_WT[9] IV_WT[10] IV_WT[11] IV_WT[12] IV_WT[13] IV_WT[14] IV_WT[15]
+   IV_WT[16] IV_WT[17] IV_WT[18] IV_WT[19] IV_WT[20] IV_WT[21] IV_WT[22]
+   IV_WT[23] IV_WT[24] IV_WT[25] IV_WT[26] IV_WT[27] LBKADR[0] LCLKB LCLKT
+   LDFTX LOG0 LDIB[0] LDIB[1] LDIB[2] LDIB[3] LDIB[4] LDIB[5] LDIB[6] LDIB[7]
+   LDIB[8] LDIB[9] LDIB[10] LDIB[11] LDIB[12] LDIB[13] LDIB[14] LDIB[15]
+   LDIB[16] LDIB[17] LDIB[18] LDIB[19] LDIB[20] LDIB[21] LDIB[22] LDIB[23]
+   LDIB[24] LDIB[25] LDIB[26] LDIB[27] LITESLP LME LOG0 LOG1 LQB[0] LQB[1]
+   LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7] LQB[8] LQB[9] LQB[10] LQB[11]
+   LQB[12] LQB[13] LQB[14] LQB[15] LQB[16] LQB[17] LQB[18] LQB[19] LQB[20]
+   LQB[21] LQB[22] LQB[23] LQB[24] LQB[25] LQB[26] LQB[27] LS LWE LWEIB LWIB[0]
+   LWIB[1] LWIB[2] LWIB[3] LWIB[4] LWIB[5] LWIB[6] LWIB[7] LWIB[8] LWIB[9]
+   LWIB[10] LWIB[11] LWIB[12] LWIB[13] LWIB[14] LWIB[15] LWIB[16] LWIB[17]
+   LWIB[18] LWIB[19] LWIB[20] LWIB[21] LWIB[22] LWIB[23] LWIB[24] LWIB[25]
+   LWIB[26] LWIB[27] LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+   LXADR[6] LXADR[7] LYADR[0] LYADR[1] MCLKB MCLKT ME MEB_I MEB_I MEORDFTCLKEN
+   LOG1 IV_WB[0] IV_WB[1] IV_WB[2] IV_WB[3] IV_WB[4] IV_WB[5] IV_WB[6] IV_WB[7]
+   IV_WB[8] IV_WB[9] IV_WB[10] IV_WB[11] IV_WB[12] IV_WB[13] IV_WB[14]
+   IV_WB[15] IV_WB[16] IV_WB[17] IV_WB[18] IV_WB[19] IV_WB[20] IV_WB[21]
+   IV_WB[22] IV_WB[23] IV_WB[24] IV_WB[25] IV_WB[26] IV_WB[27] IV_WT[0]
+   IV_WT[1] IV_WT[2] IV_WT[3] IV_WT[4] IV_WT[5] IV_WT[6] IV_WT[7] IV_WT[8]
+   IV_WT[9] IV_WT[10] IV_WT[11] IV_WT[12] IV_WT[13] IV_WT[14] IV_WT[15]
+   IV_WT[16] IV_WT[17] IV_WT[18] IV_WT[19] IV_WT[20] IV_WT[21] IV_WT[22]
+   IV_WT[23] IV_WT[24] IV_WT[25] IV_WT[26] IV_WT[27] PLBKADR PROCOM[0]
+   PROCOM[1] PROCOML PWDOR Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] Q[8] Q[9]
+   Q[10] Q[11] Q[12] Q[13] Q[14] Q[15] Q[16] Q[17] Q[18] Q[19] Q[20] Q[21]
+   Q[22] Q[23] Q[24] Q[25] Q[26] Q[27] RA[0] RA[1] RASSIST[0] RASSIST[1] RM[0]
+   RM[1] RM[2] RM3CNT VSS VSS VSS RMDEF1[3] RMDEF1_PROCOM00[0]
+   RMDEF1_PROCOM00[1] RMDEF1_PROCOM00[2] RMDEF1_PROCOM00[3] RMDEF1_PROCOM01[0]
+   RMDEF1_PROCOM01[1] RMDEF1_PROCOM01[2] RMDEF1_PROCOM01[3] RMDEF1[3] VSS
+   RMDEF1[3] RMDEF1[3] RMDEF2_PROCOM00[0] RMDEF2_PROCOM00[1] RMDEF2_PROCOM00[2]
+   RMDEF2_PROCOM00[3] RMDEF2_PROCOM01[0] RMDEF2_PROCOM01[1] RMDEF2_PROCOM01[2]
+   RMDEF2_PROCOM01[3] RME LOG1 LOG1 LOG0 VSS RMDEF1[3] RMDEF1[3] RMDEF1[3]
+   RMT[0] RMT[1] RMT[2] RMT[3] RSCEN RSCIN RSCLK RSCOUT RSCRST RWLCKB SD T1T
+   TEST1 TEST_RNM TEST_RNMB VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDF VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI_DR VDDPI_DR VDDPI_DR VDDPI_DR VDDPI_DR
+   VDDPI_DR VDDPI_DR VDDPI_DR VDDPI_DR VDDPI_DR VDDPI_DR VDDPI_DR VDDPI_DR
+   VDDPI_DR VDDPI_DR VDDPI_DR VDDPI_DR VDDPI_DR VDDPI_DR VDDPI_DR VDDPI_DR
+   VDDPI_DR VDDPI_DR VDDPI_DR VDDPI_DR VDDPI_DR VDDPI_DR VDDPI_DR RMDEF1[3]
+   VEDGE VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS WA[0] WA[1] WA[2]
+   WABUF[0] WABUF[1] WABUF[2] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+   WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16]
+   WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25]
+   WBI[26] WBI[27] WE WEM[0] WEM[1] WEM[2] WEM[3] WEM[4] WEM[5] WEM[6] WEM[7]
+   WEM[8] WEM[9] WEM[10] WEM[11] WEM[12] WEM[13] WEM[14] WEM[15] WEM[16]
+   WEM[17] WEM[18] WEM[19] WEM[20] WEM[21] WEM[22] WEM[23] WEM[24] WEM[25]
+   WEM[26] WEM[27] WEMB[0] WEMB[1] WEMB[2] WEMB[3] WEMB[4] WEMB[5] WEMB[6]
+   WEMB[7] WEMB[8] WEMB[9] WEMB[10] WEMB[11] WEMB[12] WEMB[13] WEMB[14]
+   WEMB[15] WEMB[16] WEMB[17] WEMB[18] WEMB[19] WEMB[20] WEMB[21] WEMB[22]
+   WEMB[23] WEMB[24] WEMB[25] WEMB[26] WEMB[27] WEMB[0] WEMB[1] WEMB[2] WEMB[3]
+   WEMB[4] WEMB[5] WEMB[6] WEMB[7] WEMB[8] WEMB[9] WEMB[10] WEMB[11] WEMB[12]
+   WEMB[13] WEMB[14] WEMB[15] WEMB[16] WEMB[17] WEMB[18] WEMB[19] WEMB[20]
+   WEMB[21] WEMB[22] WEMB[23] WEMB[24] WEMB[25] WEMB[26] WEMB[27] WFLOAT VSS
+   VSS VSS VSS WMDEF1_PROCOM00[0] WMDEF1_PROCOM00[1] WMDEF1_PROCOM00[2]
+   WMDEF1_PROCOM00[3] WMDEF1_PROCOM01[0] WMDEF1_PROCOM01[1] WMDEF1_PROCOM01[2]
+   WMDEF1_PROCOM01[3] RMDEF1[3] RMDEF1[3] VSS RMDEF1[3] WMDEF2_PROCOM00[0]
+   WMDEF2_PROCOM00[1] WMDEF2_PROCOM00[2] WMDEF2_PROCOM00[3] WMDEF2_PROCOM01[0]
+   WMDEF2_PROCOM01[1] WMDEF2_PROCOM01[2] WMDEF2_PROCOM01[3] VSS VSS RMDEF1[3]
+   RMDEF1[3] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WPULSE[0]
+   WPULSE[1] WPULSE[2] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16]
+   WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25]
+   WTI[26] WTI[27] XADR[0] XADR[1] XADR[2] XADR[3] XADR[4] XADR[5] XADR[6]
+   XADR[7] YADR[0] YADR[1] SNPS_RF_SP_UHS_256x28_gio_row
X_sac_wa_row ARYSDR ARYSD_BC1 ARYSD_BC2 BYP_VLOAD CENDP DEF_MODE DLYPDB DLYPW[1]
+   ENLPGB_R[0] FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET[0] LBKADR[0] LCGTH
+   LCGTHB LCGTHB_PCHG LDFTX LITESLP LOG0 LOG1 LQB[0] LQB[1] LQB[2] LQB[3]
+   LQB[4] LQB[5] LQB[6] LQB[7] LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13]
+   LQB[14] LQB[15] LQB[16] LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22]
+   LQB[23] LQB[24] LQB[25] LQB[26] LQB[27] LWEIB LWERD LWEWR LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PM[0] PM[1] PM[2] PM[3] PRCKDLY PROCOML PWDOR RASSIST[0] RASSIST[1] RB[0]
+   RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12]
+   RB[13] RB[14] RB[15] RB[16] RB[17] RB[18] RB[19] RB[20] RB[21] RB[22] RB[23]
+   RB[24] RB[25] RB[26] RB[27] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2]
+   RMT[3] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10]
+   RT[11] RT[12] RT[13] RT[14] RT[15] RT[16] RT[17] RT[18] RT[19] RT[20] RT[21]
+   RT[22] RT[23] RT[24] RT[25] RT[26] RT[27] RWLB SAEB_INT T1T TAP0 PRCKDLY
+   TAP2 TAP3 TEST_RNMB VBN VBP VDDA VDDF VDDP VDDPI VEDGE VSS VSS_WA[0]
+   VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7]
+   VSS_WA[8] VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12] VSS_WA[13] VSS_WA[14]
+   VSS_WA[15] VSS_WA[16] VSS_WA[17] VSS_WA[18] VSS_WA[19] VSS_WA[20] VSS_WA[21]
+   VSS_WA[22] VSS_WA[23] VSS_WA[24] VSS_WA[25] VSS_WA[26] VSS_WA[27] WABUF[0]
+   WABUF[1] WABUF[2] WAPRCLK WAPRCLKBUF WAPRCLKBUFB_RETI WA_R0 WA_R1 WB[0]
+   WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11] WB[12]
+   WB[13] WB[14] WB[15] WB[16] WB[17] WB[18] WB[19] WB[20] WB[21] WB[22] WB[23]
+   WB[24] WB[25] WB[26] WB[27] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+   WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16]
+   WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25]
+   WBI[26] WBI[27] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT[0]
+   WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12]
+   WT[13] WT[14] WT[15] WT[16] WT[17] WT[18] WT[19] WT[20] WT[21] WT[22] WT[23]
+   WT[24] WT[25] WT[26] WT[27] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16]
+   WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25]
+   WTI[26] WTI[27] SNPS_RF_SP_UHS_256x28_sac_wa_row
X_sac_row ARYSDR ARYSD_BC1 ARYSD_BC2 BADB[0] BADB[1] BADB[2] BADB[3] BADB[4]
+   BADB[5] BADB[6] BADB[7] BADB[8] BADB[9] BADB[10] BADB[11] BADB[12] BADB[13]
+   BADB[14] BADB[15] BADB[16] BADB[17] BADB[18] BADB[19] BADB[20] BADB[21]
+   BADB[22] BADB[23] BADB[24] BADB[25] BADB[26] BADB[27] BYP_VLOAD CENDP
+   CKGATE[1] DEF_MODE DLYPDB DLYPW[1] LOG0 FAST1_MODE FAST2_MODE FLOAT FLOATT
+   FLOAT_RET[0] LBKADR[0] LCGTH LCGTHB LCGTHB_PCHG LDFTX LITESLP LOG0 LOG1
+   LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7] LQB[8] LQB[9]
+   LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16] LQB[17] LQB[18]
+   LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25] LQB[26] LQB[27]
+   LWEIB LWERD LWEWR LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+   LXADR[6] LXADR[7] LYADR[0] LYADR[1] LYADRB LYADR[1] LYADRB PM[0] PM[1] PM[2]
+   PM[3] PRCLKB PROCOML PWDOR RASSIST[0] RASSIST[1] RB[0] RB[1] RB[2] RB[3]
+   RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14]
+   RB[15] RB[16] RB[17] RB[18] RB[19] RB[20] RB[21] RB[22] RB[23] RB[24] RB[25]
+   RB[26] RB[27] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RT[0]
+   RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12]
+   RT[13] RT[14] RT[15] RT[16] RT[17] RT[18] RT[19] RT[20] RT[21] RT[22] RT[23]
+   RT[24] RT[25] RT[26] RT[27] RWLB T1T TEST_RNMB VBN VBP VDDA VDDF VDDP VDDPI
+   VEDGE VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS_WA[0] VSS_WA[1]
+   VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7] VSS_WA[8]
+   VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12] VSS_WA[13] VSS_WA[14] VSS_WA[15]
+   VSS_WA[16] VSS_WA[17] VSS_WA[18] VSS_WA[19] VSS_WA[20] VSS_WA[21] VSS_WA[22]
+   VSS_WA[23] VSS_WA[24] VSS_WA[25] VSS_WA[26] VSS_WA[27] WABUF[0] WABUF[1]
+   WABUF[2] WAPRCLKBUFB_RETI WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7]
+   WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WB[16] WB[17] WB[18]
+   WB[19] WB[20] WB[21] WB[22] WB[23] WB[24] WB[25] WB[26] WB[27] WBI[0] WBI[1]
+   WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11]
+   WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20]
+   WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27] WMT[0] WMT[1] WMT[2]
+   WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6]
+   WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WT[16] WT[17]
+   WT[18] WT[19] WT[20] WT[21] WT[22] WT[23] WT[24] WT[25] WT[26] WT[27] WTI[0]
+   WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10]
+   WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19]
+   WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27]
+   SNPS_RF_SP_UHS_256x28_sac_row
X_mux_row ARYSDR ARYSD_BC1 ARYSD_BC2 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+   BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17]
+   BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28]
+   BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39]
+   BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50]
+   BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61]
+   BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71] BB[72]
+   BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83]
+   BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94]
+   BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103] BB[104]
+   BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BT[0] BT[1] BT[2]
+   BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14]
+   BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25]
+   BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35] BT[36]
+   BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47]
+   BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57] BT[58]
+   BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68] BT[69]
+   BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79] BT[80]
+   BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90] BT[91]
+   BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100] BT[101]
+   BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109] BT[110]
+   BT[111] BYP_VLOAD CENDP CKGATE[1] DEF_MODE DLYPDB FAST1_MODE FAST2_MODE
+   FLOAT FLOATT FLOAT_RET[1] LBKADR[0] LBKADRB LBKADR_TOP LCGTH LCGTHB_PCHG
+   LDFTX LITESLP LOG0 LOG1 LQB[28] LQB[29] LQB[30] LQB[31] LQB[32] LQB[33]
+   LQB[34] LQB[35] LQB[36] LQB[37] LQB[38] LQB[39] LQB[40] LQB[41] LQB[42]
+   LQB[43] LQB[44] LQB[45] LQB[46] LQB[47] LQB[48] LQB[49] LQB[50] LQB[51]
+   LQB[52] LQB[53] LQB[54] LQB[55] LWEIB LWERD LWEWR LXADR[0] LXADR[1] LXADR[2]
+   LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LXADR_TOP[0] LXADR_TOP[1]
+   LXADR_TOP[2] LXADR_TOP[3] LXADR_TOP[4] LXADR_TOP[5] LXADR_TOP[6]
+   LXADR_TOP[7] LYADR[0] LYADR[1] LYADR_TOP[0] LYADR_TOP[1] B PBB[1] PBB[2]
+   PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] C PCB[1] PCB[2] PCB[3] PCB[4] PCB[5]
+   PCB[6] PCB[7] PGIOIR LOG0 PM[0] PM[1] PM[2] PM[3] PROCOML RASSIST[0]
+   RASSIST[1] RASSISTB[0] RASSISTB[1] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6]
+   RB[7] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RB[16] RB[17]
+   RB[18] RB[19] RB[20] RB[21] RB[22] RB[23] RB[24] RB[25] RB[26] RB[27] RBLRD
+   RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RT[0] RT[1] RT[2] RT[3] RT[4]
+   RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15]
+   RT[16] RT[17] RT[18] RT[19] RT[20] RT[21] RT[22] RT[23] RT[24] RT[25] RT[26]
+   RT[27] RWLB SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8]
+   SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] SEL[16] SEL[17]
+   SEL[18] SEL[19] SEL[20] SEL[21] SEL[22] SEL[23] SEL[24] SEL[25] SEL[26]
+   SEL[27] T1T TEST_RNMB VSS VBN VBP VDDA VDDAI_H_T1 VDDF VDDP VDDPI VDDWL
+   VDDWL_PCOM[0] VEDGE_O VSS VSSWLL VSSWLR WABUF[0] WABUF[1] WABUF[2] WB[0]
+   WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11] WB[12]
+   WB[13] WB[14] WB[15] WB[16] WB[17] WB[18] WB[19] WB[20] WB[21] WB[22] WB[23]
+   WB[24] WB[25] WB[26] WB[27] WBI[28] WBI[29] WBI[30] WBI[31] WBI[32] WBI[33]
+   WBI[34] WBI[35] WBI[36] WBI[37] WBI[38] WBI[39] WBI[40] WBI[41] WBI[42]
+   WBI[43] WBI[44] WBI[45] WBI[46] WBI[47] WBI[48] WBI[49] WBI[50] WBI[51]
+   WBI[52] WBI[53] WBI[54] WBI[55] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] WMT[0]
+   WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT[0] WT[1] WT[2] WT[3]
+   WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14]
+   WT[15] WT[16] WT[17] WT[18] WT[19] WT[20] WT[21] WT[22] WT[23] WT[24] WT[25]
+   WT[26] WT[27] WTI[28] WTI[29] WTI[30] WTI[31] WTI[32] WTI[33] WTI[34]
+   WTI[35] WTI[36] WTI[37] WTI[38] WTI[39] WTI[40] WTI[41] WTI[42] WTI[43]
+   WTI[44] WTI[45] WTI[46] WTI[47] WTI[48] WTI[49] WTI[50] WTI[51] WTI[52]
+   WTI[53] WTI[54] WTI[55] SNPS_RF_SP_UHS_256x28_mux_row
X_ary_row ARYSDR ARYSD_BC1 ARYSD_BC2 B BADB[28] BADB[29] BADB[30] BADB[31]
+   BADB[32] BADB[33] BADB[34] BADB[35] BADB[36] BADB[37] BADB[38] BADB[39]
+   BADB[40] BADB[41] BADB[42] BADB[43] BADB[44] BADB[45] BADB[46] BADB[47]
+   BADB[48] BADB[49] BADB[50] BADB[51] BADB[52] BADB[53] BADB[54] BADB[55]
+   BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11]
+   BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21] BB[22]
+   BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33]
+   BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44]
+   BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55]
+   BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BB[64] BB[65] BB[66]
+   BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75] BB[76] BB[77]
+   BB[78] BB[79] BB[80] BB[81] BB[82] BB[83] BB[84] BB[85] BB[86] BB[87] BB[88]
+   BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95] BB[96] BB[97] BB[98] BB[99]
+   BB[100] BB[101] BB[102] BB[103] BB[104] BB[105] BB[106] BB[107] BB[108]
+   BB[109] BB[110] BB[111] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7]
+   BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16] BT[17] BT[18]
+   BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28] BT[29]
+   BT[30] BT[31] BT[32] BT[33] BT[34] BT[35] BT[36] BT[37] BT[38] BT[39] BT[40]
+   BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51]
+   BT[52] BT[53] BT[54] BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62]
+   BT[63] BT[64] BT[65] BT[66] BT[67] BT[68] BT[69] BT[70] BT[71] BT[72] BT[73]
+   BT[74] BT[75] BT[76] BT[77] BT[78] BT[79] BT[80] BT[81] BT[82] BT[83] BT[84]
+   BT[85] BT[86] BT[87] BT[88] BT[89] BT[90] BT[91] BT[92] BT[93] BT[94] BT[95]
+   BT[96] BT[97] BT[98] BT[99] BT[100] BT[101] BT[102] BT[103] BT[104] BT[105]
+   BT[106] BT[107] BT[108] BT[109] BT[110] BT[111] BYP_VLOAD C CENDP CKGATE[1]
+   DEF_MODE DLYPDB EDGEB EDGET FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET[1]
+   LBKADR[1] LCGTH LDFTX LITESLP LOG0 LOG1 LQB[28] LQB[29] LQB[30] LQB[31]
+   LQB[32] LQB[33] LQB[34] LQB[35] LQB[36] LQB[37] LQB[38] LQB[39] LQB[40]
+   LQB[41] LQB[42] LQB[43] LQB[44] LQB[45] LQB[46] LQB[47] LQB[48] LQB[49]
+   LQB[50] LQB[51] LQB[52] LQB[53] LQB[54] LQB[55] LWEIB LXADR[8] LXADR[9]
+   LXADR[10] LXADR[11] LXADR[12] LXADR[13] LXADR[14] LXADR[15] LYADR[2]
+   LYADR[3] B PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] C PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] PGIOIR PROCOML RASSIST[0] RASSIST[1]
+   RASSISTB[0] RASSISTB[1] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3]
+   RWLB T1T TEST_RNMB VSS VBN VBP VDDA VDDAI_H_T1 VDDF VDDP VDDPI VDDWL VEDGE_O
+   VSS VSSWLL VSSWLR WABUF[0] WABUF[1] WABUF[2] WBI[28] WBI[29] WBI[30] WBI[31]
+   WBI[32] WBI[33] WBI[34] WBI[35] WBI[36] WBI[37] WBI[38] WBI[39] WBI[40]
+   WBI[41] WBI[42] WBI[43] WBI[44] WBI[45] WBI[46] WBI[47] WBI[48] WBI[49]
+   WBI[50] WBI[51] WBI[52] WBI[53] WBI[54] WBI[55] WCLKB[0] WCLKB[1] WCLKB[2]
+   WCLKB[3] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WTI[28]
+   WTI[29] WTI[30] WTI[31] WTI[32] WTI[33] WTI[34] WTI[35] WTI[36] WTI[37]
+   WTI[38] WTI[39] WTI[40] WTI[41] WTI[42] WTI[43] WTI[44] WTI[45] WTI[46]
+   WTI[47] WTI[48] WTI[49] WTI[50] WTI[51] WTI[52] WTI[53] WTI[54] WTI[55]
+   SNPS_RF_SP_UHS_256x28_ary_row
X_ref_row ARYSDR ARYSD_BC1 ARYSD_BC2 ARYSD_TOP BADB[28] BADB[29] BADB[30]
+   BADB[31] BADB[32] BADB[33] BADB[34] BADB[35] BADB[36] BADB[37] BADB[38]
+   BADB[39] BADB[40] BADB[41] BADB[42] BADB[43] BADB[44] BADB[45] BADB[46]
+   BADB[47] BADB[48] BADB[49] BADB[50] BADB[51] BADB[52] BADB[53] BADB[54]
+   BADB[55] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BB[64] BB[65]
+   BB[66] BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75] BB[76]
+   BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83] BB[84] BB[85] BB[86] BB[87]
+   BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95] BB[96] BB[97] BB[98]
+   BB[99] BB[100] BB[101] BB[102] BB[103] BB[104] BB[105] BB[106] BB[107]
+   BB[108] BB[109] BB[110] BB[111] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6]
+   BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16] BT[17]
+   BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28]
+   BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35] BT[36] BT[37] BT[38] BT[39]
+   BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47] BT[48] BT[49] BT[50]
+   BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61]
+   BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68] BT[69] BT[70] BT[71] BT[72]
+   BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79] BT[80] BT[81] BT[82] BT[83]
+   BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90] BT[91] BT[92] BT[93] BT[94]
+   BT[95] BT[96] BT[97] BT[98] BT[99] BT[100] BT[101] BT[102] BT[103] BT[104]
+   BT[105] BT[106] BT[107] BT[108] BT[109] BT[110] BT[111] CENDP CKGATE[1]
+   DEF_MODE DLYPDB FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET[1] LBKADR[1]
+   LCGTH LDFTX LITESLP LOG0 LOG1 LQB[28] LQB[29] LQB[30] LQB[31] LQB[32]
+   LQB[33] LQB[34] LQB[35] LQB[36] LQB[37] LQB[38] LQB[39] LQB[40] LQB[41]
+   LQB[42] LQB[43] LQB[44] LQB[45] LQB[46] LQB[47] LQB[48] LQB[49] LQB[50]
+   LQB[51] LQB[52] LQB[53] LQB[54] LQB[55] LWEIB LXADR[8] LXADR[9] LXADR[10]
+   LXADR[11] LXADR[12] LXADR[13] LXADR[14] LXADR[15] LYADR[2] LYADR[3] PGIOIR
+   PROCOML RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] RBLRD RBLWA RBLWR
+   RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB T1T TEST_RNMB TOPEDGE VSS VBN VBP
+   VDDA VDDAI_H_T1 VDDF VDDP VDDPI VDDWL VDDWL_PCOM[1] VEDGE_O VSS VSSWLL
+   VSSWLR WABUF[0] WABUF[1] WABUF[2] WBI[28] WBI[29] WBI[30] WBI[31] WBI[32]
+   WBI[33] WBI[34] WBI[35] WBI[36] WBI[37] WBI[38] WBI[39] WBI[40] WBI[41]
+   WBI[42] WBI[43] WBI[44] WBI[45] WBI[46] WBI[47] WBI[48] WBI[49] WBI[50]
+   WBI[51] WBI[52] WBI[53] WBI[54] WBI[55] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0]
+   WPBUF[1] WPBUF[2] WTI[28] WTI[29] WTI[30] WTI[31] WTI[32] WTI[33] WTI[34]
+   WTI[35] WTI[36] WTI[37] WTI[38] WTI[39] WTI[40] WTI[41] WTI[42] WTI[43]
+   WTI[44] WTI[45] WTI[46] WTI[47] WTI[48] WTI[49] WTI[50] WTI[51] WTI[52]
+   WTI[53] WTI[54] WTI[55] SNPS_RF_SP_UHS_256x28_ref_row
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28_TOP_LAY ADR[0] ADR[1] ADR[2] ADR[3] ADR[5] ADR[6]
+       ADR[7] ADR[8] BC0 BC1 BC2 CKGATE CLK D[0] D[1] D[2] D[3] D[4] D[5] D[6]
+       D[7] D[8] D[9] D[10] D[11] D[12] D[13] D[14] D[15] D[16] D[17] D[18]
+       D[19] D[20] D[21] D[22] D[23] D[24] D[25] D[26] D[27] LS ME Q[0] Q[1]
+       Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13] Q[14]
+       Q[15] Q[16] Q[17] Q[18] Q[19] Q[20] Q[21] Q[22] Q[23] Q[24] Q[25] Q[26]
+       Q[27] RM[0] RM[1] RM[2] RM[3] RME TEST1 TEST_RNM VDD VNW_N VPW_P VSS
+       WA[0] WA[1] WE WPULSE[0] WPULSE[1] WPULSE[2]
X_top ARYSDR ARYSD_BC1 ARYSD_BC2 ARYSD_TOP BADB[0] BADB[1] BADB[2] BADB[3]
+   BADB[4] BADB[5] BADB[6] BADB[7] BADB[8] BADB[9] BADB[10] BADB[11] BADB[12]
+   BADB[13] BADB[14] BADB[15] BADB[16] BADB[17] BADB[18] BADB[19] BADB[20]
+   BADB[21] BADB[22] BADB[23] BADB[24] BADB[25] BADB[26] BADB[27] BC0 BC1 BC2
+   LOG0 CENDP CKGATE CLK D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] D[8] D[9]
+   D[10] D[11] D[12] D[13] D[14] D[15] D[16] D[17] D[18] D[19] D[20] D[21]
+   D[22] D[23] D[24] D[25] D[26] D[27] DEF_MODE LOG0 LOG1 LOG0 FAST1_MODE
+   FAST2_MODE LOG0 FLOAT FLOATT LOG1 LBKADR LOG0 LITESLP LOG0 LOG1 LQB[0]
+   LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7] LQB[8] LQB[9] LQB[10]
+   LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16] LQB[17] LQB[18] LQB[19]
+   LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25] LQB[26] LQB[27] LS LWEIB
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] ME LOG0 PROCOM[0] PROCOM[1] PROCOML Q[0] Q[1] Q[2] Q[3]
+   Q[4] Q[5] Q[6] Q[7] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13] Q[14] Q[15] Q[16]
+   Q[17] Q[18] Q[19] Q[20] Q[21] Q[22] Q[23] Q[24] Q[25] Q[26] Q[27] LOG0 LOG0
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] RBLRD RBLWA RBLWR RM[0] RM[1]
+   RM[2] RM[3] RM3CNT RME RMT[0] RMT[1] RMT[2] RMT[3] LOG0 LOG0 LOG0 RSCOUT
+   LOG0 RWLB LOG0 T1T TEST1 TEST_RNM TEST_RNMB TOPEDGE VNW_N VPW_P VDD
+   VDDAI_H_T1 VDD VDD VDD VDDWL_PCOM VEDGE_O VSS VSSWLL VSSWLL WA[0] WA[1]
+   WABUF[0] WABUF[1] WABUF[2] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+   WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16]
+   WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25]
+   WBI[26] WBI[27] WE LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1
+   LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1
+   LOG1 LOG1 WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WPULSE[0]
+   WPULSE[1] WPULSE[2] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16]
+   WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25]
+   WTI[26] WTI[27] ADR[2] ADR[3] ADR[5] ADR[6] ADR[7] ADR[8] LOG0 LOG0 ADR[0]
+   ADR[1] SNPS_RF_SP_UHS_256x28_top
.ENDS
.SUBCKT SNPS_RF_SP_UHS_256x28 ADR[0] ADR[1] ADR[2] ADR[3] ADR[4] ADR[5] ADR[6]
+       ADR[7] BC0 BC1 BC2 CLK D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] D[8] D[9]
+       D[10] D[11] D[12] D[13] D[14] D[15] D[16] D[17] D[18] D[19] D[20] D[21]
+       D[22] D[23] D[24] D[25] D[26] D[27] LS ME Q[0] Q[1] Q[2] Q[3] Q[4] Q[5]
+       Q[6] Q[7] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13] Q[14] Q[15] Q[16] Q[17]
+       Q[18] Q[19] Q[20] Q[21] Q[22] Q[23] Q[24] Q[25] Q[26] Q[27] RM[0] RM[1]
+       RM[2] RM[3] RME TEST1 TEST_RNM VDD VNW_N VPW_P VSS WA[0] WA[1] WE
+       WPULSE[0] WPULSE[1] WPULSE[2]
X_TOP_LAY ADR[0] ADR[1] ADR[2] ADR[3] ADR[4] ADR[5] ADR[6] ADR[7] BC0 BC1 BC2
+   VSS CLK D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] D[8] D[9] D[10] D[11] D[12]
+   D[13] D[14] D[15] D[16] D[17] D[18] D[19] D[20] D[21] D[22] D[23] D[24]
+   D[25] D[26] D[27] LS ME Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] Q[8] Q[9]
+   Q[10] Q[11] Q[12] Q[13] Q[14] Q[15] Q[16] Q[17] Q[18] Q[19] Q[20] Q[21]
+   Q[22] Q[23] Q[24] Q[25] Q[26] Q[27] RM[0] RM[1] RM[2] RM[3] RME TEST1
+   TEST_RNM VDD VNW_N VPW_P VSS WA[0] WA[1] WE WPULSE[0] WPULSE[1] WPULSE[2]
+   SNPS_RF_SP_UHS_256x28_TOP_LAY
 Xvpw_p_h VPW_P vassert_hi vmax=0
 Xvpw_p_l VPW_P vassert_lo vmin=-1.5
 Xvnw_n_l VNW_N vassert_lo vmin=0
 Xvnw_n_h VNW_N vassert_hi vmax=1.2
 Xvss_h VSS vassert_hi vmax=0
 Xvss_l VSS vassert_lo vmin=0
 Xvdd_h VDD vassert_hi vmax=0.9
 Xvdd_l VDD vassert_lo vmin=0.45
.ENDS
