*---------------------------------------------------------------------*
*               Copyright(c) Synopsys, Inc.                           *
*     All Rights reserved - Unpublished -rights reserved under        *
*     the Copyright laws of the United States of America.             *
*                                                                     *
*  U.S. Patents: 7,093,156 B1 and 7,406,620 B2 (and more pending).    *
*                                                                     *
*  This file includes the Confidential information of Synopsys, Inc.  *
*  and GLOBALFOUNDRIES.                                               *
*  The receiver of this Confidential Information shall not disclose   *
*  it to any third party and shall protect its confidentiality by     *
*  using the same degree of care, but not less than a reasonable      *
*  degree of care, as the receiver uses to protect receiver's own     *
*  Confidential Information.                                          *
*  Licensee acknowledges and agrees that all output generated for     *
*  Licensee by Synopsys, Inc. as described in the pertinent Program   *
*  Schedule(s), or generated by Licensee through use of any Compiler  *
*  licensed hereunder contains information that complies with the     *
*  Virtual Component Identification Physical Tagging Standard (VCID)  *
*  as maintained by the Virtual Socket Interface Alliance (VSIA).     *
*  Such information may be expressed in GDSII Layer 63 or other such  *
*  layer designated by the VSIA, hardware definition languages, or    *
*  other formats.  Licensee is not authorized to alter or change any  *
*  such information.                                                  *
*---------------------------------------------------------------------*
*                                                                     *
*  Built for linux64 and running on linux64.                          *
*                                                                     *
*  Software           : Rev: U-2022.12                                *
*  Library Format     : Rev: 1.05.00                                  *
*  Compiler Name      : gf22nsd41p11s1dcl02msa05                      *
*  Platform           : Linux3.10.0-957.5.1.el7.x86_64                *
*                     : #1 SMP Wed Dec 19 10:46:58 EST 2018x86_64     *
*  Date of Generation : Fri Dec 09 14:09:30 CET 2022                  *
*                                                                     *
*---------------------------------------------------------------------*
.option MACMOD=1
.option SCALE=1

.subckt mm16a05_u_logrepedge VDDP VSS VBP VBN LOG0 LOG1
MPLOG VDDP LOG0 LOG1 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=10
M0 LOG0 LOG1 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=10
.ends

.subckt mm16a05_u_hdsp_plus_capgio VDDP VDDPI VSS VBP VBN LOG0 LOG1 PWDO VEDGE
Xlogrep_gio VDDP VSS VBP VBN LOG0 LOG1 mm16a05_u_logrepedge
.ends

.subckt mm16a05_u_inv_bulk_n_vt2_p_vt2 VDD VSS VBP VBN X A CPP=104n P_LA_n=4n
+ P_LA_p=4n ULP=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=758n wp=1092n
MNA X A VSS VBN slvtnfet cpp=cpp p_la=p_la_n ulp=ulp nf=nf_n l=ln w=wn m=m_n
MPA X A VDD VBP slvtpfet cpp=cpp p_la=p_la_p ulp=ulp nf=nf_p l=lp w=wp m=m_p
.ends

.subckt mm16a05_u_data_drv_ysel VDDP VDDPI VSS VBP VBN DATA_OUT DATA_IN
XI56 VDDPI VSS VBP VBN DATA_OUT DATA_IN mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=758n
+ wp=1092n
.ends

.subckt mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=600n wn2=600n wp1=450n wp2=450n
MPA2 X A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
MPA1 X A1 VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MNA1 X A1 net22 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 net22 A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2
+ w=wn2 m=m_n2
.ends

.subckt mm16a05_u_resolver_hdsp VDDP VDDPI VDDPI_RL VSS VBP VBN QTI LQB PDB QB
+ QT
MI84 VDDPI QB QTI VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=450n m=2
MI73 VDDPI_RL QT LQB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=180n m=5
MI74 LQB QTI net71 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=900n m=2
MI75 net71 PDB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=900n m=2
MI83 QTI QB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
.ends

.subckt mm16a05_u_data_drv VDDP VDDPI VSS VBP VBN DATA_OUT DATA_IN
XI56 VDDPI VSS VBP VBN DATA_OUT DATA_IN mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=758n
+ wp=1092n
.ends

.subckt mm16a05_u_xmux_ysel VDDP VDDPI VDDPI_RL VSS VBP VBN ND_SELB ND_WB ND_WT
+ QTI SELB WB WT LQB IV_SELB IV_WB IV_WT LYSEL PDB QB QT WBI WTI
XI70 VDDP VDDPI VSS VBP VBN SELB IV_SELB mm16a05_u_data_drv_ysel
XI73 VDDPI VSS VBP VBN ND_WT LYSEL WTI
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=600n wn2=600n wp1=450n
+ wp2=450n
XI65 VDDPI VSS VBP VBN ND_WB LYSEL WBI
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=600n wn2=600n wp1=450n
+ wp2=450n
XI71 VDDP VDDPI VDDPI_RL VSS VBP VBN QTI LQB PDB QB QT mm16a05_u_resolver_hdsp
XI69 VDDP VDDPI VSS VBP VBN WT IV_WT mm16a05_u_data_drv
XI68 VDDP VDDPI VSS VBP VBN WB IV_WB mm16a05_u_data_drv
XI61 VDDPI VSS VBP VBN ND_SELB LYSEL mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=350n
+ wp=450n
.ends

.subckt mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=120n wn2=120n wp1=360n wp2=360n
MNA1 X A1 VSS VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 X A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MPA2 net10 A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2
+ w=wp2 m=m_p2
MPA1 X A1 net10 VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
.ends

.subckt mm16a05_u_we_ysel VDDP VDDPI VSS VBP VBN LYSEL LQB WBI WTI LYI[0]
+ LYI[1]
XI50 VDDPI VSS VBP VBN LYSEL LYI[1] LYI[0]
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=360n
+ wp2=360n
.ends

.subckt mm16a05_u_output_drv_gf22 VDDP VDDPI VSS VBP VBN Q_OUT Q_IN
XI4 VDDPI VSS VBP VBN Q_OUT Q_IN mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1 wn=220n
+ wp=315n
.ends

.subckt mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 VDD VSS VBP VBN X A S0
+ S1 CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=120n wn2=120n wp1=120n wp2=120n
MNA net020 A VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MNS0 X S0 net020 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MPA net16 A VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MPS1 X S1 net16 VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
.ends

.subckt mm16a05_u_latch_lqb VDDP VDDPI VSS VBP VBN LQB LQB_N[0] LQB_N[1]
+ LQB_P[0] LQB_P[1]
M58 VDDP LQB_P[1] net5 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=400n
+ m=1
MI77 net5 LQB_P[0] net6 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=400n
+ m=1
M1 net6 IFF LQB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=400n m=1
MI79 net7 LQB_N[0] net8 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
M5 net8 LQB_N[1] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
M4 LQB IFF net7 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
XI31 VDDPI VSS VBP VBN IFF LQB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
.ends

.subckt mm16a05_u_do_hdsp VDDP VDDPI VDDPI_DR VSS VBP VBN DIB_LT D_AL Q WEM_AL
+ WIB LQB DCLKT DIN DINB LDFTYBUF LQB_N[0] LQB_N[1] LQB_P[0] LQB_P[1] SEB SET
+ WEM WEMB
XI16 VDDPI VSS VBP VBN DWEMT DINB WEMH
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=206n wn2=206n wp1=120n
+ wp2=120n
XI69 VDDPI VSS VBP VBN DWEMB DINT WEMH
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=206n wn2=206n wp1=120n
+ wp2=120n
XI65 VDDP VDDPI VSS VBP VBN Q LQB mm16a05_u_output_drv_gf22
XI57 VDDPI VSS VBP VBN LDFTYBUFB LDFTYBUF mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=220n
XI59 VDDPI VSS VBP VBN WEM_AL WEM mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI61 VDDPI VSS VBP VBN WEMH WEMB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI4 VDDPI VSS VBP VBN D_AL DIN mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI70 VDDPI VSS VBP VBN DINT DINB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI68 VDDPI VSS VBP VBN WIB DIB_LT LDFTYBUF LDFTYBUFB
+ mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=220n wp2=220n
XI63 VDDPI VSS VBP VBN WIB DWEMB LDFTYBUFB LDFTYBUF
+ mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=220n wp2=220n
XI207 VDDPI VSS VBP VBN DIB_LT DWEMT SEB SET
+ mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=220n wp2=220n
XLQB VDDP VDDPI VSS VBP VBN LQB LQB_N[0] LQB_N[1] LQB_P[0] LQB_P[1]
+ mm16a05_u_latch_lqb
.ends

.subckt mm16a05_u_latch_lqb_ctrl_cm16 VDDP VDDPI VSS VBP VBN LQB_N_OUT[0]
+ LQB_N_OUT[1] LQB_P_OUT[0] LQB_P_OUT[1] LQB_N_IN[0] LQB_N_IN[1] LQB_N_IN[2]
+ LQB_N_IN[3] LQB_P_IN[0] LQB_P_IN[1] LQB_P_IN[2] LQB_P_IN[3]
XI81 VDDPI VSS VBP VBN LQB_P_OUT[0] LQB_P_IN[1] LQB_P_IN[0]
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=120n
+ wp2=120n
XI80 VDDPI VSS VBP VBN LQB_P_OUT[1] LQB_P_IN[3] LQB_P_IN[2]
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=120n
+ wp2=120n
XI83 VDDPI VSS VBP VBN LQB_N_OUT[1] LQB_NB[2] LQB_NB[3]
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=240n
+ wp2=240n
XI82 VDDPI VSS VBP VBN LQB_N_OUT[0] LQB_NB[0] LQB_NB[1]
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=240n
+ wp2=240n
XI84[0] VDDPI VSS VBP VBN LQB_NB[0] LQB_N_IN[0] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=320n wp=320n
XI84[1] VDDPI VSS VBP VBN LQB_NB[1] LQB_N_IN[1] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=320n wp=320n
XI84[2] VDDPI VSS VBP VBN LQB_NB[2] LQB_N_IN[2] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=320n wp=320n
XI84[3] VDDPI VSS VBP VBN LQB_NB[3] LQB_N_IN[3] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=320n wp=320n
.ends

.subckt mm16a05_u_l2bio VDDP VDDPI VSS VBP VBN Q QB CB CT DIN
XI7 VDDPI VSS VBP VBN Q QB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=160n wp=160n
XI3 VDDPI VSS VBP VBN QB Q CT CB
+ mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XI11 VDDPI VSS VBP VBN QB DIN CB CT
+ mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2
+ m_n2=2 m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
.ends

.subckt mm16a05_u_dclk_ct_cb_gen VDDPI VSS VBP VBN CB CT DCLK
XI2 VDDPI VSS VBP VBN CB CT mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n wp=160n
XI1 VDDPI VSS VBP VBN CT DCLKB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI0 VDDPI VSS VBP VBN DCLKB DCLK mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=160n
+ wp=160n
.ends

.subckt mm16a05_u_di_dft_plus VDDP VDDPI VSS VBP VBN CB CT LDIB LWIB WBI WTI
+ LQB SEB SET DCLKT DIB WIB
XD VDDP VDDPI VSS VBP VBN LDIB WTI CB CT DIB mm16a05_u_l2bio
XW VDDP VDDPI VSS VBP VBN LWIB WBI CB CT WIB mm16a05_u_l2bio
XI51 VDDPI VSS VBP VBN CB CT DCLKT mm16a05_u_dclk_ct_cb_gen
.ends

.subckt mm16a05_u_gio16_plus VDDP VDDPI VDDPI_DR VDDPI_RL VSS VBP VBN CB CT
+ D_AL LDIB LQB LWIB ND_SEL[0] ND_SEL[1] ND_SEL[2] ND_SEL[3] ND_WB[0] ND_WB[1]
+ ND_WB[2] ND_WB[3] ND_WT[0] ND_WT[1] ND_WT[2] ND_WT[3] Q SEL[0] SEL[1] SEL[2]
+ SEL[3] WB[0] WB[1] WB[2] WB[3] WEM_AL WT[0] WT[1] WT[2] WT[3] DIB LOG0 LOG1
+ DCLKT DIN DINB IV_SEL[0] IV_SEL[1] IV_SEL[2] IV_SEL[3] IV_WB[0] IV_WB[1]
+ IV_WB[2] IV_WB[3] IV_WT[0] IV_WT[1] IV_WT[2] IV_WT[3] LDFTYBUF LYB[0] LYB[1]
+ PDB QB[0] QB[1] QB[2] QB[3] QT[0] QT[1] QT[2] QT[3] SEB SET WEM WEMB
X1 VDDP VDDPI VDDP VSS VBP VBN ND_SEL[1] ND_WB[1] ND_WT[1] net176 SEL[1] WB[1]
+ WT[1] LQB IV_SEL[1] IV_WB[1] IV_WT[1] LYSEL[1] PDB QB[1] QT[1] WBI WTI
+ mm16a05_u_xmux_ysel
X0 VDDP VDDPI VDDP VSS VBP VBN ND_SEL[0] ND_WB[0] ND_WT[0] net175 SEL[0] WB[0]
+ WT[0] LQB IV_SEL[0] IV_WB[0] IV_WT[0] LYSEL[0] PDB QB[0] QT[0] WBI WTI
+ mm16a05_u_xmux_ysel
XM VDDP VDDPI VDDP VSS VBP VBN ND_SEL[3] ND_WB[3] ND_WT[3] net178 SEL[3] WB[3]
+ WT[3] LQB IV_SEL[3] IV_WB[3] IV_WT[3] LYSELFF PDB QB[3] QT[3] WBI WTI
+ mm16a05_u_xmux_ysel
X2 VDDP VDDPI VDDP VSS VBP VBN ND_SEL[2] ND_WB[2] ND_WT[2] net177 SEL[2] WB[2]
+ WT[2] LQB IV_SEL[2] IV_WB[2] IV_WT[2] LYSEL[2] PDB QB[2] QT[2] WBI WTI
+ mm16a05_u_xmux_ysel
XI37 VDDPI VSS VBP VBN WBI net239 mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI64 VDDPI VSS VBP VBN WTI net237 mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
Xlyt[0] VDDPI VSS VBP VBN LYT[0] LYB[0] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
Xlyt[1] VDDPI VSS VBP VBN LYT[1] LYB[1] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XSEL3 VDDP VDDPI VSS VBP VBN LYSELFF LQB WBI WTI LYB[0] LYB[1]
+ mm16a05_u_we_ysel
XSEL2 VDDP VDDPI VSS VBP VBN LYSEL[2] LQB WBI WTI LYT[0] LYB[1]
+ mm16a05_u_we_ysel
XSEL1 VDDP VDDPI VSS VBP VBN LYSEL[1] LQB WBI WTI LYB[0] LYT[1]
+ mm16a05_u_we_ysel
XSEL0 VDDP VDDPI VSS VBP VBN LYSEL[0] LQB WBI WTI LYT[0] LYT[1]
+ mm16a05_u_we_ysel
XDO VDDP VDDPI VDDPI_DR VSS VBP VBN DIB D_AL Q WEM_AL net195 LQB DCLKT DIN DINB
+ LDFTYBUF LQB_N[0] LQB_N[1] LQB_P[0] LQB_P[1] SEB SET WEM WEMB
+ mm16a05_u_do_hdsp
XI30 VDDP VDDPI VSS VBP VBN LQB_N[0] LQB_N[1] LQB_P[0] LQB_P[1] QT[0] QT[1]
+ QT[2] QT[3] QB[0] QB[1] QB[2] QB[3] mm16a05_u_latch_lqb_ctrl_cm16
XDI VDDP VDDPI VSS VBP VBN CB CT LDIB LWIB net239 net237 LQB SEB SET DCLKT DIB
+ net195 mm16a05_u_di_dft_plus
.ends

.subckt mm16a05_u_hdsp_plus_giom16x1 VDDP VDDPI VDDPI_DR VDDPI_RL VSS VBP VBN
+ CB CT D_AL LDIB LQB LWIB ND_SEL[0] ND_SEL[1] ND_SEL[2] ND_SEL[3] ND_WB[0]
+ ND_WB[1] ND_WB[2] ND_WB[3] ND_WT[0] ND_WT[1] ND_WT[2] ND_WT[3] Q SEL[0]
+ SEL[1] SEL[2] SEL[3] WB[0] WB[1] WB[2] WB[3] WEM_AL WT[0] WT[1] WT[2] WT[3]
+ DIB LOG0 LOG1 LYB[0] LYB[1] QB[0] QB[1] QB[2] QB[3] QT[0] QT[1] QT[2] QT[3] D
+ DCLKT DINB DLYPDB IV_SEL[0] IV_SEL[1] IV_SEL[2] IV_SEL[3] IV_WB[0] IV_WB[1]
+ IV_WB[2] IV_WB[3] IV_WT[0] IV_WT[1] IV_WT[2] IV_WT[3] LDFTYBUF SE_DB SE_DT
+ WEM WEMB
MI14 net119 DCLKT net119 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=288n
+ m=15
Xgio_0 VDDP VDDPI VDDPI_DR VDDPI_RL VSS VBP VBN CB CT D_AL LDIB LQB LWIB
+ ND_SEL[0] ND_SEL[1] ND_SEL[2] ND_SEL[3] ND_WB[0] ND_WB[1] ND_WB[2] ND_WB[3]
+ ND_WT[0] ND_WT[1] ND_WT[2] ND_WT[3] Q SEL[0] SEL[1] SEL[2] SEL[3] WB[0] WB[1]
+ WB[2] WB[3] WEM_AL WT[0] WT[1] WT[2] WT[3] DIB LOG0 LOG1 DCLKT D DINB
+ IV_SEL[0] IV_SEL[1] IV_SEL[2] IV_SEL[3] IV_WB[0] IV_WB[1] IV_WB[2] IV_WB[3]
+ IV_WT[0] IV_WT[1] IV_WT[2] IV_WT[3] LDFTYBUF LYB[0] LYB[1] DLYPDB QB[0] QB[1]
+ QB[2] QB[3] QT[0] QT[1] QT[2] QT[3] SE_DB SE_DT WEM WEMB mm16a05_u_gio16_plus
.ends

.subckt mm16a05_u_pg_arysd_buf_dr VDDA VSS VBP VBN ARYSD ARYSD_BC1 ARYSD_BC2
+ ARYSDB ARYSDB_BC1 ARYSDB_BC2 SDCLPSB
XI12 VDDA VSS VBP VBN ARYSD ARYSDB_SDCLPSB mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1
+ wn=430n wp=430n
XI9 VDDA VSS VBP VBN ARYSD_BC1 ARYSDB_BC1 mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=320n wp=320n
XI11 VDDA VSS VBP VBN ARYSD_BC2 ARYSDB_BC2 mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=320n wp=320n
XI17 VDDA VSS VBP VBN ARYSDB_SDCLPSB ARYSDB SDCLPSB
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=320n
+ wp2=320n
.ends

.subckt mm16a05_u_hdsp_plus_gcenbuf_dr VDDA VDDP VDDPI VSS VBP VBN DCLKT LYB[0]
+ LYB[1] RASSIST[0] RASSIST[1] ARYSD ARYSDB ARYSDB_BC1 ARYSDB_BC2 ARYSD_BC1
+ ARYSD_BC2 DLYPDB GSE_DB GSE_DT LDFTYBUF LOG0 LOG1 LCLKBIO LY[0] LY[1]
+ LYADR[2] LYADR[3] RAB[0] RAB[1] SDCLPSB
XDCLKT VDDPI VSS VBP VBN net137 LCLKBIO mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=400n
+ wp=400n
XDCLK VDDPI VSS VBP VBN DCLKT net137 mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1 wn=400n
+ wp=600n
XINV_LY[0] VDDPI VSS VBP VBN LYB[0] LY[0] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=5 m_p=5 nf_n=1 nf_p=1
+ wn=400n wp=600n
XINV_LY[1] VDDPI VSS VBP VBN LYB[1] LY[1] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=5 m_p=5 nf_n=1 nf_p=1
+ wn=400n wp=600n
XIRA[0] VDDPI VSS VBP VBN RASSIST[0] RAB[0] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=400.0n wp=400.0n
XIRA[1] VDDPI VSS VBP VBN RASSIST[1] RAB[1] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=400.0n wp=400.0n
XIPG_ARYSD_BUF VDDA VSS VBP VBN ARYSD ARYSD_BC1 ARYSD_BC2 ARYSDB ARYSDB_BC1
+ ARYSDB_BC2 SDCLPSB mm16a05_u_pg_arysd_buf_dr
.ends

.subckt mm16a05_u_inv_bulk_n_vt3_p_vt3 VDD VSS VBP VBN X A CPP=104n P_LA_n=4n
+ P_LA_p=4n ULP=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=758n wp=1092n
MNA X A VSS VBN slvtnfet cpp=cpp p_la=p_la_n ulp=ulp nf=nf_n l=ln w=wn m=m_n
MPA X A VDD VBP slvtpfet cpp=cpp p_la=p_la_p ulp=ulp nf=nf_p l=lp w=wp m=m_p
.ends

.subckt mm16a05_u_tg_bulk_n_vt2_p_vt2 VBP VBN A B S SB CPP=104n P_LA_n=4n
+ P_LA_p=4n ULP=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=320n wp=320n
MNS A S B VBN slvtnfet cpp=cpp p_la=p_la_n ulp=ulp nf=nf_n l=ln w=wn m=m_n
MPSB A SB B VBP slvtpfet cpp=cpp p_la=p_la_p ulp=ulp nf=nf_p l=lp w=wp m=m_p
.ends

.subckt mm16a05_u_pg_lsltch_sp VDDP VDDPI VSS VBP VBN LITESLP RWLCKB LS RFLOAT
+ WFLOAT
XI27 VDDPI VSS VBP VBN LDPB LDP RWLCKT RWLCKB
+ mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XI23 VDDPI VSS VBP VBN LSB LS mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=283.0n wp=283.0n
XI3 VDDPI VSS VBP VBN LDP LDPB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI26 VDDP VSS VBP VBN RWLCKB RWLCKT mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=280.0n
+ wp=280.0n
XI32 VDDPI VSS VBP VBN LITESLP LDPB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=5 m_p=5 nf_n=1 nf_p=1 wn=280n
+ wp=280n
XI1 VDDPI VSS VBP VBN RWLCKT RFLOAT mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=280n
+ wp=280n
XI33 VBP VBN LSB LDPB RWLCKB RWLCKT mm16a05_u_tg_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
.ends

.subckt mm16a05_u_rm4to1 VDDP VDDPI VSS VBP VBN AT BT CT DT A B C D SEL[0]
+ SEL[1]
*XI8 VBP VBN net39 mm16a05_u_init1
*XI9 VBP VBN net40 mm16a05_u_init0
XI1 VBP VBN B BT SEL[1] SEL[0] mm16a05_u_tg_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
XI0 VBP VBN A AT SEL[1] SEL[0] mm16a05_u_tg_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
XI2 VBP VBN C CT SEL[1] SEL[0] mm16a05_u_tg_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
XI3 VBP VBN D DT SEL[1] SEL[0] mm16a05_u_tg_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
.ends

.subckt mm16a05_u_blatch_rm VDDPI VNWP VSS VBP VBN OUT OUTB CB CT IN
XI0 VDDPI VSS VBP VBN OUTB IN CB CT
+ mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XI1 VDDPI VSS VBP VBN OUTB OUT CT CB
+ mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
*XI39 VBP VBN OUTB mm16a05_u_init1
XI2 VDDPI VSS VBP VBN OUT OUTB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
.ends

.subckt mm16a05_u_rmmx VDDP VDDPI VSS VBP VBN QB A BCB BCT TA
XA VDDPI VSS VBP VBN QB A BCB BCT
+ mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n
+ wp1=240n wp2=240n
XTA VDDPI VSS VBP VBN QB TA BCT BCB
+ mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n
+ wp1=240n wp2=240n
.ends

.subckt mm16a05_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 VDD VSS
+ VBP VBN X A1 A2 A3 CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_n3=4n P_LA_p1=4n
+ P_LA_p2=4n P_LA_p3=4n ULP=0 ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n
+ m_n1=1 m_n2=1 m_n3=1 m_p1=1 m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1
+ nf_p2=1 nf_p3=1 wn1=120n wn2=120n wn3=120n wp1=120n wp2=120n wp3=120n
MNA1 X A1 net19 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 net19 A2 net018 VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2
+ w=wn2 m=m_n2
MNA3 net018 A3 VSS VBN slvtnfet cpp=cpp p_la=p_la_n3 ulp=ulp nf=nf_n3 l=ln3
+ w=wn3 m=m_n3
MPA1 X A1 VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MPA3 X A3 VDD VBP slvtpfet cpp=cpp p_la=p_la_p3 ulp=ulp nf=nf_p3 l=lp3 w=wp3
+ m=m_p3
MPA2 X A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
.ends

.subckt mm16a05_u_hdsp_rm2to4_procom_change1_plus VDDP VDDPI VSS VBP VBN
+ SEL_RM0 SEL_RM0123 SEL_RM0B SEL_RM1 SEL_RM1B SEL_RM2 SEL_RM2B SEL_RM3
+ SEL_RM3B SEL_RM4 SEL_RM5 LOG0 LOG1 LCLKB LCLKT RM[0] RM[1] RM[2] RME RMENI[0]
+ RMENI[1] RMENI[2]
XLRM1 VDDPI VDDP VSS VBP VBN LRMB[1] LRM[1] LCLKB LCLKT RM_RMI[1]
+ mm16a05_u_blatch_rm
XLRM0 VDDPI VDDP VSS VBP VBN LRMB[0] LRM[0] LCLKB LCLKT RM_RMI[0]
+ mm16a05_u_blatch_rm
XLRM2 VDDPI VDDP VSS VBP VBN LRMB[2] LRM[2] LCLKB LCLKT RM_RMI[2]
+ mm16a05_u_blatch_rm
XIRM_RMI0 VDDP VDDPI VSS VBP VBN RM_RMI[0] RM[0] RME RMEB RMENI[0]
+ mm16a05_u_rmmx
XIRM_RMI1 VDDP VDDPI VSS VBP VBN RM_RMI[1] RM[1] RME RMEB RMENI[1]
+ mm16a05_u_rmmx
XIRM_RMI2 VDDP VDDPI VSS VBP VBN RM_RMI[2] RM[2] RME RMEB RMENI[2]
+ mm16a05_u_rmmx
MI57 net163 LRMB[0] SEL_RM5 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=320n m=1
MI58 net163 LRMB[1] SEL_RM5 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=320n m=1
MPA VDDPI LRMB[2] net163 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
MNA SEL_RM5 LRMB[1] net169 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=320n m=1
MI56 SEL_RM5 LRMB[2] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
MI55 net169 LRMB[0] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
XI78 VDDPI VSS VBP VBN SEL_RM1B LRM[0] LRMB[1] LRMB[2]
+ mm16a05_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=320n
+ wn2=320n wn3=320n wp1=320n wp2=320n wp3=320n
XI79 VDDPI VSS VBP VBN SEL_RM0B LRMB[0] LRMB[1] LRMB[2]
+ mm16a05_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=320n
+ wn2=320n wn3=320n wp1=320n wp2=320n wp3=320n
XI71 VDDPI VSS VBP VBN SEL_RM2B LRMB[0] LRM[1] LRMB[2]
+ mm16a05_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=320n
+ wn2=320n wn3=320n wp1=320n wp2=320n wp3=320n
XI76 VDDPI VSS VBP VBN SEL_RM4B LRM[2] LRMB[1] LRMB[0]
+ mm16a05_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=320n
+ wn2=320n wn3=320n wp1=320n wp2=320n wp3=320n
XI80 VDDPI VSS VBP VBN SEL_RM3B SEL_RM3 mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=320n
Xnr2_ckdel1 VDDPI VSS VBP VBN SEL_RM0123 LRM[2] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI74 VDDPI VSS VBP VBN SEL_RM4 SEL_RM4B mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI4 VDDPI VSS VBP VBN SEL_RM0 SEL_RM0B mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI61 VDDPI VSS VBP VBN RMEB RME mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI68 VDDPI VSS VBP VBN SEL_RM1 SEL_RM1B mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI72 VDDPI VSS VBP VBN SEL_RM2 SEL_RM2B mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI69 VDDPI VSS VBP VBN SEL_RM3 LRMB[2] net234
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=320n
+ wp2=320n
XI81 VDDPI VSS VBP VBN net234 LRM[0] LRM[1]
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=320n
+ wp2=320n
.ends

.subckt mm16a05_u_rm4to1_pmos VDDP VBP VBN AT BT CT DT A B C D SELB[1]
MI5 A SELB[1] AT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M2 D SELB[1] DT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M1 C SELB[1] CT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M0 B SELB[1] BT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
.ends

.subckt mm16a05_u_hdsp_plus_rm_wm_ctrl_procom_change VDDP VDDPI VDDMINB VSS VBP
+ VBN DEF1 DEF1B DEF2 DEF2B DEF_MODE FAST1_MODE FAST2_MODE RT[0] RT[1] RT[2]
+ RT[3] WT[0] WT[1] WT[2] WT[3] LOG0 LOG1 DEF12B_PROG DEF12_PROG DEF_PROG LCLKB
+ LCLKT RM[0] RM[1] RM[2] RMDEF1[0] RMDEF1[1] RMDEF1[2] RMDEF1[3] RMDEF2[0]
+ RMDEF2[1] RMDEF2[2] RMDEF2[3] RME RMENI[0] RMENI[1] RMENI[2] RMSLOW[0]
+ RMSLOW[1] RMSLOW[2] RMSLOW[3] WMDEF1[0] WMDEF1[1] WMDEF1[2] WMDEF1[3]
+ WMDEF2[0] WMDEF2[1] WMDEF2[2] WMDEF2[3] WMSLOW[0] WMSLOW[1] WMSLOW[2]
+ WMSLOW[3]
XI121 VDDP VDDPI VSS VBP VBN WT[0] WT[1] WT[2] WT[3] WMDEF1[0] WMDEF1[1]
+ WMDEF1[2] WMDEF1[3] DEF_PROGB DEF_PROG mm16a05_u_rm4to1
XI122 VDDP VDDPI VSS VBP VBN RT[0] RT[1] RT[2] RT[3] RMDEF1[0] RMDEF1[1]
+ RMDEF1[2] RMDEF1[3] DEF_PROGB DEF_PROG mm16a05_u_rm4to1
XI59 VDDP VDDPI VSS VBP VBN WT[0] WT[1] WT[2] WT[3] WMSLOW[0] WMSLOW[1]
+ WMSLOW[2] WMSLOW[3] SLOWB SLOW mm16a05_u_rm4to1
XI58 VDDP VDDPI VSS VBP VBN WT[0] WT[1] WT[2] WT[3] WMDEF2[0] WMDEF2[1]
+ WMDEF2[2] WMDEF2[3] DEF12B_PROG DEF12_PROG mm16a05_u_rm4to1
XI53 VDDP VDDPI VSS VBP VBN RT[0] RT[1] RT[2] RT[3] RMSLOW[0] RMSLOW[1]
+ RMSLOW[2] RMSLOW[3] SLOWB SLOW mm16a05_u_rm4to1
XRMD VDDP VDDPI VSS VBP VBN RT[0] RT[1] RT[2] RT[3] RMDEF2[0] RMDEF2[1]
+ RMDEF2[2] RMDEF2[3] DEF12B_PROG DEF12_PROG mm16a05_u_rm4to1
XIRM_MUX VDDP VDDPI VSS VBP VBN VDDMIN DEF_MODE VDDMINB SLOW SLOWB DEF2 DEF2B
+ DEF1 DEF1B FAST1_MODE FAST2_MODE LOG0 LOG1 LCLKB LCLKT RM[0] RM[1] RM[2] RME
+ RMENI[0] RMENI[1] RMENI[2] mm16a05_u_hdsp_rm2to4_procom_change1_plus
XI123 VDDPI VSS VBP VBN DEF_PROGB DEF_PROG mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI57 VDDP VBP VBN WT[0] WT[1] WT[2] WT[3] VDDPI VDDPI VDDPI VDDPI VDDMINB
+ mm16a05_u_rm4to1_pmos
XI52 VDDP VBP VBN RT[0] RT[1] RT[2] RT[3] VDDPI VDDPI VDDPI VDDPI VDDMINB
+ mm16a05_u_rm4to1_pmos
.ends

.subckt mm16a05_u_hdsp_plus_rm_wm_ctrl_base VDDP VDDPI VDDMINB VSS VBP VBN DEF1
+ DEF1B DEF2 DEF2B DEF_MODE FAST1_MODE FAST2_MODE RMT[0] RMT[1] RMT[2] RMT[3]
+ WMT[0] WMT[1] WMT[2] WMT[3] LOG0 LOG1 DEF12B_PROG DEF12_PROG DEF_PROG FLOAT
+ RM[0] RM[1] RM[2] RMDEF1[0] RMDEF1[1] RMDEF1[2] RMDEF1[3] RMDEF2[0] RMDEF2[1]
+ RMDEF2[2] RMDEF2[3] RME RMENI[0] RMENI[1] RMENI[2] RMSLOW[0] RMSLOW[1]
+ RMSLOW[2] RMSLOW[3] WMDEF1[0] WMDEF1[1] WMDEF1[2] WMDEF1[3] WMDEF2[0]
+ WMDEF2[1] WMDEF2[2] WMDEF2[3] WMSLOW[0] WMSLOW[1] WMSLOW[2] WMSLOW[3]
XRM VDDP VDDPI VDDMINB VSS VBP VBN DEF1 DEF1B DEF2 DEF2B DEF_MODE FAST1_MODE
+ FAST2_MODE RMB[0] RMB[1] RMB[2] RMB[3] WMB[0] WMB[1] WMB[2] WMB[3] LOG0 LOG1
+ DEF12B_PROG DEF12_PROG DEF_PROG LCLKB LCLKT RM[0] RM[1] RM[2] RMDEF1[0]
+ RMDEF1[1] RMDEF1[2] RMDEF1[3] RMDEF2[0] RMDEF2[1] RMDEF2[2] RMDEF2[3] RME
+ RMENI[0] RMENI[1] RMENI[2] RMSLOW[0] RMSLOW[1] RMSLOW[2] RMSLOW[3] WMDEF1[0]
+ WMDEF1[1] WMDEF1[2] WMDEF1[3] WMDEF2[0] WMDEF2[1] WMDEF2[2] WMDEF2[3]
+ WMSLOW[0] WMSLOW[1] WMSLOW[2] WMSLOW[3]
+ mm16a05_u_hdsp_plus_rm_wm_ctrl_procom_change
XRMT3 VDDPI VSS VBP VBN LCLKB LCLKT mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI63[0] VDDPI VSS VBP VBN WMT[0] WMB[0] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI63[1] VDDPI VSS VBP VBN WMT[1] WMB[1] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI63[2] VDDPI VSS VBP VBN WMT[2] WMB[2] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI63[3] VDDPI VSS VBP VBN WMT[3] WMB[3] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XRMB3 VDDPI VSS VBP VBN LCLKT FLOAT mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI58[0] VDDPI VSS VBP VBN RMT[0] RMB[0] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI58[1] VDDPI VSS VBP VBN RMT[1] RMB[1] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI58[2] VDDPI VSS VBP VBN RMT[2] RMB[2] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI58[3] VDDPI VSS VBP VBN RMT[3] RMB[3] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=160n
+ wp=160n
.ends

.subckt mm16a05_u_hdsp_plus_rmctrl VDDP VDDPI VDDMINB VSS VBP VBN DEF1 DEF1B
+ DEF2 DEF2B DEF_MODE FAST1_MODE FAST2_MODE RM3_CORE_CNT RMT[0] RMT[1] RMT[2]
+ RMT[3] WMT[0] WMT[1] WMT[2] WMT[3] LOG0 LOG1 LOG1_RM BC0 DEF12B_PROG
+ DEF12_PROG DEF_PROG FLOAT LSDB RM[0] RM[1] RM[2] RM[3] RMDEF1[0] RMDEF1[1]
+ RMDEF1[2] RMDEF1[3] RMDEF2[0] RMDEF2[1] RMDEF2[2] RMDEF2[3] RME RMENI[0]
+ RMENI[1] RMENI[2] RMSLOW[0] RMSLOW[1] RMSLOW[2] RMSLOW[3] WMDEF1[0] WMDEF1[1]
+ WMDEF1[2] WMDEF1[3] WMDEF2[0] WMDEF2[1] WMDEF2[2] WMDEF2[3] WMSLOW[0]
+ WMSLOW[1] WMSLOW[2] WMSLOW[3]
XI43 VDDP VSS VBP VBN RM3_CORE_CNT net39 mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI53 VDDP VSS VBP VBN net39 BC0 LSDB
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=240n
+ wp2=240n
XRM net181 VDDPI VDDMINB VSS VBP VBN DEF1 DEF1B DEF2 DEF2B DEF_MODE FAST1_MODE
+ FAST2_MODE RMT[0] RMT[1] RMT[2] RMT[3] WMT[0] WMT[1] WMT[2] WMT[3] LOG0 LOG1
+ DEF12B_PROG DEF12_PROG DEF_PROG FLOAT RM[0] RM[1] RM[2] RMDEF1[0] RMDEF1[1]
+ RMDEF1[2] RMDEF1[3] RMDEF2[0] RMDEF2[1] RMDEF2[2] RMDEF2[3] RME RMENI[0]
+ RMENI[1] RMENI[2] RMSLOW[0] RMSLOW[1] RMSLOW[2] RMSLOW[3] WMDEF1[0] WMDEF1[1]
+ WMDEF1[2] WMDEF1[3] WMDEF2[0] WMDEF2[1] WMDEF2[2] WMDEF2[3] WMSLOW[0]
+ WMSLOW[1] WMSLOW[2] WMSLOW[3] mm16a05_u_hdsp_plus_rm_wm_ctrl_base
MI87 VDDP LOG0 LOG1_RM VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=360n
+ m=2
.ends

.subckt mm16a05_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=120n wn2=120n wp1=360n wp2=360n
MNA1 X A1 VSS VBN lvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 X A2 VSS VBN lvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MPA2 net10 A2 VDD VBP lvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
MPA1 X A1 net10 VBP lvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
.ends

.subckt mm16a05_u_inv_bulk_n_vt1_p_vt1 VDD VSS VBP VBN X A CPP=104n P_LA_n=4n
+ P_LA_p=4n ULP=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=758n wp=1092n
MNA X A VSS VBN lvtnfet cpp=cpp p_la=p_la_n ulp=ulp nf=nf_n l=ln w=wn m=m_n
MPA X A VDD VBP lvtpfet cpp=cpp p_la=p_la_p ulp=ulp nf=nf_p l=lp w=wp m=m_p
.ends

.subckt mm16a05_u_bc_control_hdsp VDDP VSS VBP VBN LSDB LSDB_BC1 LSDB_BC2 LOG1
+ BC1 BC2 SD
XI0[0] VDDP VSS VBP VBN LSDB_BC2 BC2B SD
+ mm16a05_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI0[1] VDDP VSS VBP VBN LSDB_BC2 BC2B SD
+ mm16a05_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI1[0] VDDP VSS VBP VBN LSDB_BC1 BC1B SD
+ mm16a05_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI1[1] VDDP VSS VBP VBN LSDB_BC1 BC1B SD
+ mm16a05_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI22 VDDP_SD VSS VBP VBN BC1B BC1 BCB12
+ mm16a05_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=240n
+ wp2=240n
XI20 VDDP_SD VSS VBP VBN BCB12 BC1 BC2
+ mm16a05_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=240n
+ wp2=240n
XI21 VDDP_SD VSS VBP VBN BC2B LOG1 BCB12
+ mm16a05_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=240n
+ wp2=240n
XI18 VDDP VSS VBP VBN LSDB SD mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
M9 VDDP SD VDDP_SD VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=2
.ends

.subckt mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 VDD VSS VBP VBN X A S0
+ S1 CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=120n wn2=120n wp1=120n wp2=120n
MNA net020 A VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MNS0 X S0 net020 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MPA net16 A VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MPS1 X S1 net16 VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
.ends

.subckt mm16a05_u_hdsp_plus_blatch_addr_vt2 VDDPI VSS VBP VBN OUT OUTB CB CT IN
*XI5 VBP VBN OUTB mm16a05_u_init0
XI2 VDDPI VSS VBP VBN OUT OUTB mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=0
+ p_la_p=0 ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1 wn=283n wp=283n
*XI6 OUTB mm16a05_u_lat_int_node
*XI8 VBP VBN OUTB VDDPI mm16a05_u_lat_set_op_pfv
XI17 VDDPI VSS VBP VBN OUTB IN CB CT
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=0 p_la_n2=0
+ p_la_p1=0 p_la_p2=0 ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=174n wn2=174n wp1=174n
+ wp2=174n
XI1 VDDPI VSS VBP VBN OUTB OUT CT CB
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=0 p_la_n2=0
+ p_la_p1=0 p_la_p2=0 ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=174n wn2=174n wp1=174n
+ wp2=174n
XI0 VDDPI VSS VBP VBN OUTB IN CB CT
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=0 p_la_n2=0
+ p_la_p1=0 p_la_p2=0 ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=174n wn2=174n wp1=174n
+ wp2=174n
.ends

.subckt mm16a05_u_hdsp_plus_blatch_addr_vt4 VDDP VDDPI VSS VBP VBN OUT OUTB CB
+ CT IN
*XI5 VBP VBN OUTB mm16a05_u_init0
XI2 VDDPI VSS VBP VBN OUT OUTB mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=0
+ p_la_p=0 ulp=0 ln=20n lp=20n m_n=5 m_p=5 nf_n=1 nf_p=1 wn=283n wp=283n
*XI6 OUTB mm16a05_u_lat_int_node
*XI8 VBP VBN OUTB VDDPI mm16a05_u_lat_set_op_pfv
XI0_1 VDDPI VSS VBP VBN OUTB IN CB CT
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=0 p_la_n2=0
+ p_la_p1=0 p_la_p2=0 ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=174n wn2=174n wp1=174n
+ wp2=174n
XI0 VDDPI VSS VBP VBN OUTB IN CB CT
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=0 p_la_n2=0
+ p_la_p1=0 p_la_p2=0 ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=174n wn2=174n wp1=174n
+ wp2=174n
XI11 VDDPI VSS VBP VBN OUTB OUT CT CB
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=0 p_la_n2=0
+ p_la_p1=0 p_la_p2=0 ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=174n wn2=174n wp1=174n
+ wp2=174n
.ends

.subckt mm16a05_u_hdsp_plus_adr_latches_cm16bk8 VDDP VDDPI VSS VBP VBN
+ LBKADR[0] LBKADR[1] LBKADR[2] LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+ LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] LYADR[2] LYADR[3] LYADRB[2]
+ LYADRB[3] BKADRA[0] BKADRA[1] BKADRA[2] CLKB CLKI XADRA[0] XADRA[1] XADRA[2]
+ XADRA[3] XADRA[4] XADRA[5] XADRA[6] XADRA[7] YADRA[0] YADRA[1] YADRA[2]
+ YADRA[3]
XYADR[2] VDDPI VSS VBP VBN LYADR[2] LYADRB[2] CLKB CLKI YADRA[2]
+ mm16a05_u_hdsp_plus_blatch_addr_vt2
XYADR[3] VDDPI VSS VBP VBN LYADR[3] LYADRB[3] CLKB CLKI YADRA[3]
+ mm16a05_u_hdsp_plus_blatch_addr_vt2
XBKADDR[0] VDDP VDDPI VSS VBP VBN LBKADR[0] LBKADRQB[0] CLKB CLKI BKADRA[0]
+ mm16a05_u_hdsp_plus_blatch_addr_vt4
XBKADDR[1] VDDP VDDPI VSS VBP VBN LBKADR[1] LBKADRQB[1] CLKB CLKI BKADRA[1]
+ mm16a05_u_hdsp_plus_blatch_addr_vt4
XRADR[0] VDDP VDDPI VSS VBP VBN LXADR[0] LXADRQB[0] CLKB CLKI XADRA[0]
+ mm16a05_u_hdsp_plus_blatch_addr_vt4
XRADR[1] VDDP VDDPI VSS VBP VBN LXADR[1] LXADRQB[1] CLKB CLKI XADRA[1]
+ mm16a05_u_hdsp_plus_blatch_addr_vt4
XRADR[2] VDDP VDDPI VSS VBP VBN LXADR[2] LXADRQB[2] CLKB CLKI XADRA[2]
+ mm16a05_u_hdsp_plus_blatch_addr_vt4
XRADR[3] VDDP VDDPI VSS VBP VBN LXADR[3] LXADRQB[3] CLKB CLKI XADRA[3]
+ mm16a05_u_hdsp_plus_blatch_addr_vt4
XRADR[4] VDDP VDDPI VSS VBP VBN LXADR[4] LXADRQB[4] CLKB CLKI XADRA[4]
+ mm16a05_u_hdsp_plus_blatch_addr_vt4
XRADR[5] VDDP VDDPI VSS VBP VBN LXADR[5] LXADRQB[5] CLKB CLKI XADRA[5]
+ mm16a05_u_hdsp_plus_blatch_addr_vt4
XRADR[6] VDDP VDDPI VSS VBP VBN LXADR[6] LXADRQB[6] CLKB CLKI XADRA[6]
+ mm16a05_u_hdsp_plus_blatch_addr_vt4
XRADR[7] VDDP VDDPI VSS VBP VBN LXADR[7] LXADRQB[7] CLKB CLKI XADRA[7]
+ mm16a05_u_hdsp_plus_blatch_addr_vt4
XYADR[0] VDDP VDDPI VSS VBP VBN LYADR[0] LYADRQB[0] CLKB CLKI YADRA[0]
+ mm16a05_u_hdsp_plus_blatch_addr_vt4
XYADR[1] VDDP VDDPI VSS VBP VBN LYADR[1] LYADRQB[1] CLKB CLKI YADRA[1]
+ mm16a05_u_hdsp_plus_blatch_addr_vt4
XI17 VDDP VDDPI VSS VBP VBN LBKADR[2] LBKADRQB[2] CLKB CLKI BKADRA[2]
+ mm16a05_u_hdsp_plus_blatch_addr_vt4
.ends

.subckt mm16a05_u_hdsp_plus_tclk VDDP VDDPI VSS VBP VBN FLOAT T1T TCLKB
Xinv_tckrd[0] VDDPI VSS VBP VBN TCK TCLKB T1T
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=240n
+ wp2=240n
Xinv_tckrd[1] VDDPI VSS VBP VBN TCK TCLKB T1T
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=240n
+ wp2=240n
M8 net33 TCK FLOAT VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=200n m=4
M7 net29 T1T net33 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=400n m=2
M6 VSS net28 net29 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=400n m=2
MP_trd VDDP TCK FLOAT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=960n m=4
XI5 VDDPI VSS VBP VBN net28 FLOAT mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=240n
.ends

.subckt mm16a05_u_latch_pass VDDP VDDPI VSS VBP VBN Q QB A CB CT
Xinv_lat1 VDDPI VSS VBP VBN QB Q mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
Xinv_feed VDDPI VSS VBP VBN Q QB CT CB
+ mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XI3 VBP VBN A Q CB CT mm16a05_u_tg_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n wp=120n
.ends

.subckt mm16a05_u_lat_pass_new_me VDDP VDDPI VSS VBP VBN Q QB A CB CT
XI3 VBP VBN A Q CB CT mm16a05_u_tg_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n wp=120n
Xinv_lat1 VDDPI VSS VBP VBN QB Q mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
*XI8 Q mm16a05_u_lat_int_node
*XI9 VBP VBN QB VDDPI mm16a05_u_lat_set_op_pfv
Xinv_feed VDDPI VSS VBP VBN Q QB CT CB
+ mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
.ends

.subckt mm16a05_u_hdsp_control_dft VDDP VDDPI VSS VBP VBN CLKB LME LMEWRB LWE
+ LWE_DFT MCLKB MCLKT MEB_LT MEORDFTCLKEN T1T DFTCLKENB CLK DFTCLKEN LCLKB
+ LCLKT LDFTX ME MEB_I TEST1 WE
XI27 VDDPI VSS VBP VBN MEB_LT ME mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=160n
Xinv_web VDDPI VSS VBP VBN WEB WE mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=140n
Xinv_test1 VDDPI VSS VBP VBN TEST1B TEST1 mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=120n wp=180n
Xinv_tclkb VDDPI VSS VBP VBN CLKB CLK mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
Xinv_mclk VDDPI VSS VBP VBN MCLKT MCLKB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1 wn=215n
+ wp=215n
Xinv_mclkb VDDPI VSS VBP VBN MCLKB CLK mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1 wn=215n
+ wp=215n
Xinv_swt VDDPI VSS VBP VBN DFTCLKENB DFTCLKEN mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=160n wp=160n
XI35 VDDPI VSS VBP VBN LWE LWEB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=200n
+ wp=280n
Xnd2_lmewr VDDPI VSS VBP VBN MEORDFTCLKEN DFTCLKENB MEB_I
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=240n
+ wp2=240n
XI20[0] VDDPI VSS VBP VBN LWE_DFT LWEB LDFTX
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=200n
+ wp2=200n
XI20[1] VDDPI VSS VBP VBN LWE_DFT LWEB LDFTX
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=200n
+ wp2=200n
XI20[2] VDDPI VSS VBP VBN LWE_DFT LWEB LDFTX
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=200n
+ wp2=200n
XI20[3] VDDPI VSS VBP VBN LWE_DFT LWEB LDFTX
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=200n
+ wp2=200n
XI15[0] VDDPI VSS VBP VBN T1T TEST1B LDFTX
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=200n
+ wp2=200n
XI15[1] VDDPI VSS VBP VBN T1T TEST1B LDFTX
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=200n
+ wp2=200n
XI15[2] VDDPI VSS VBP VBN T1T TEST1B LDFTX
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=200n
+ wp2=200n
XI15[3] VDDPI VSS VBP VBN T1T TEST1B LDFTX
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=200n
+ wp2=200n
Xlat_wr VDDP VDDPI VSS VBP VBN LWEB net63 WEB LCLKB LCLKT mm16a05_u_latch_pass
Xlat_mewr VDDP VDDPI VSS VBP VBN LMEWRB LME MEB_I MCLKB MCLKT
+ mm16a05_u_lat_pass_new_me
.ends

.subckt mm16a05_u_nr3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 VDD VSS
+ VBP VBN X A1 A2 A3 CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_n3=4n P_LA_p1=4n
+ P_LA_p2=4n P_LA_p3=4n ULP=0 ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n
+ m_n1=1 m_n2=1 m_n3=1 m_p1=1 m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1
+ nf_p2=1 nf_p3=1 wn1=120n wn2=120n wn3=120n wp1=240n wp2=240n wp3=240n
MNA1 X A1 VSS VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA3 X A3 VSS VBN slvtnfet cpp=cpp p_la=p_la_n3 ulp=ulp nf=nf_n3 l=ln3 w=wn3
+ m=m_n3
MNA2 X A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MPA3 net10 A3 VDD VBP slvtpfet cpp=cpp p_la=p_la_p3 ulp=ulp nf=nf_p3 l=lp3
+ w=wp3 m=m_p3
MPA2 net029 A2 net10 VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2
+ w=wp2 m=m_p2
MPA1 X A1 net029 VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
.ends

.subckt mm16a05_u_hdsp_plus_pw_gen VDDP VDDPI VSS VBP VBN PW CLKFLT CLPSEBUF
+ DFTMASK DLYPW FLOAT_RET LS SE_IN
Xnr2_clmp VDDPI VSS VBP VBN LSORDLTPWB DLYPW net313 LS
+ mm16a05_u_nr3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=120n
+ wn2=120n wn3=120n wp1=200n wp2=200n wp3=200n
M12 PW PWB1 CKGDN VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n m=2
M0 net267 CLKFLT net268 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n
+ m=2
M65 net268 FLTBAR net267 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n
+ m=3
M8 VDDPI CLMP net267 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
XI82 VDDPI VSS VBP VBN net313 DFTMASK net310
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=200n wn2=200n wp1=200n
+ wp2=200n
Xnr2_ckdel1 VDDPI VSS VBP VBN CLKDELB CLKFLT CLMP
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=240n
+ wp2=240n
XI73 VDDPI_PWGEN VSS VBP VBN net284 CLPSEBUF mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=160n wp=160n
XI84 VDDPI VSS VBP VBN net310 SE_IN mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
Xinv_ckdel2 VDDP VSS VBP VBN CLKDEL CLKDELB mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=200n
XI40 VDDPI VSS VBP VBN FLTBAR FLOAT_RET mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=240n
Xinv_clmp VDDP VSS VBP VBN CLMP LSORDLTPWB mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XFWD VDDPI VSS VBP VBN PWB1 PW net284
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
*XI38 VBP VBN PW mm16a05_u_init1
MI72 PW CLPSEBUF VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n m=2
Mckdrv pwsvs CLKFLT VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n
+ m=2
M11 PW CLMP VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
Mxback1ck CKGDN CLKDEL VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=160n m=2
MN3 pwsvs FLTBAR PW VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n m=3
M9 net268 PWB1 PW VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n m=2
Mclkpull VDDPI_PWGEN CLKDEL PW VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=160n m=2
MI70 VDDPI CLPSEBUF VDDPI_PWGEN VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=160n m=2
.ends

.subckt mm16a05_u_nd3_bulk_n1_vt4_n2_vt4_n3_vt4_p1_vt4_p2_vt4_p3_vt4 VDD VSS
+ VBP VBN X A1 A2 A3 CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_n3=4n P_LA_p1=4n
+ P_LA_p2=4n P_LA_p3=4n ULP=0 ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n
+ m_n1=1 m_n2=1 m_n3=1 m_p1=1 m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1
+ nf_p2=1 nf_p3=1 wn1=120n wn2=120n wn3=120n wp1=120n wp2=120n wp3=120n
MNA1 X A1 net19 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 net19 A2 net018 VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2
+ w=wn2 m=m_n2
MNA3 net018 A3 VSS VBN slvtnfet cpp=cpp p_la=p_la_n3 ulp=ulp nf=nf_n3 l=ln3
+ w=wn3 m=m_n3
MPA1 X A1 VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MPA3 X A3 VDD VBP slvtpfet cpp=cpp p_la=p_la_p3 ulp=ulp nf=nf_p3 l=lp3 w=wp3
+ m=m_p3
MPA2 X A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
.ends

.subckt mm16a05_u_hdsp_data_latch_clock_gen VDDP VDDPI VSS VBP VBN FLTIO
+ LCLKBIO FLOATBD LS_INT OUT_2INV OUT_4INV OUT_6INV CLKB_LATCH FLOAT IN_2INV
+ IN_4INV IN_6INV LS WE_GATE_CLK
Xnr2_ls VDDPI VSS VBP VBN FLTIO FLOATBD LS_INT
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI42[0] VDDPI VSS VBP VBN LCLKBIO CLKB_LATCH FLOAT FLTIO
+ mm16a05_u_nd3_bulk_n1_vt4_n2_vt4_n3_vt4_p1_vt4_p2_vt4_p3_vt4 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=120n
+ wn2=120n wn3=120n wp1=240n wp2=240n wp3=240n
XI42[1] VDDPI VSS VBP VBN LCLKBIO CLKB_LATCH FLOAT FLTIO
+ mm16a05_u_nd3_bulk_n1_vt4_n2_vt4_n3_vt4_p1_vt4_p2_vt4_p3_vt4 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=120n
+ wn2=120n wn3=120n wp1=240n wp2=240n wp3=240n
.ends

.subckt mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=600n wn2=600n wp1=450n wp2=450n
MPA2 X A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
MPA1 X A1 VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MNA1 X A1 net22 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 net22 A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2
+ w=wn2 m=m_n2
.ends

.subckt mm16a05_u_hdsp_plus_float_gen VDDP VDDPI VSS VBP VBN CKGATE FLOAT CLKB
+ CLPSEBUF DLYPW LDFTX LMEB PW
*XI39 VBP VBN FLOAT mm16a05_u_init1
MI84 LDFTXB LDFTX VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=2
M73 CKGATE PWB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=210n m=4
M58 CKGATE CLKB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=210n m=4
MLPCPLP FLOATB DLYPW VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
MNgate FLOAT CKGATE VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=1680n
+ m=4
MI89 FLOATB FLOAT VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=200n m=1
MI82 FLOATB FLOAT VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=440n m=1
MI78 FLOATB CLPSEBUF VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
M64 NET_B FLOATB VDDP VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=280n m=4
M50 FLOAT CKGATE NET_B VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=280n
+ m=4
MI81 FLOATB FLOAT VDDPI VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=210n
+ m=2
MI85 LDFTXB LDFTX VDDPI VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=560n
+ m=2
M72 NET_A CLKB CKGATE VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=420n m=4
M52 VDDPI PWB NET_A VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=168n m=10
XI74[0] VDDPI VSS VBP VBN MEDFT LDFTXB LMEB
+ mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=160n
+ wp2=160n
XI74[1] VDDPI VSS VBP VBN MEDFT LDFTXB LMEB
+ mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=160n
+ wp2=160n
XI61[0] VDDP VSS VBP VBN PWB PW MEDFT
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=270n wn2=270n wp1=220n
+ wp2=220n
XI61[1] VDDP VSS VBP VBN PWB PW MEDFT
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=270n wn2=270n wp1=220n
+ wp2=220n
XI61[2] VDDP VSS VBP VBN PWB PW MEDFT
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=270n wn2=270n wp1=220n
+ wp2=220n
.ends

.subckt mm16a05_u_nd3_bulk_n1_vt3_n2_vt3_n3_vt3_p1_vt3_p2_vt3_p3_vt3 VDD VSS
+ VBP VBN X A1 A2 A3 CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_n3=4n P_LA_p1=4n
+ P_LA_p2=4n P_LA_p3=4n ULP=0 ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n
+ m_n1=1 m_n2=1 m_n3=1 m_p1=1 m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1
+ nf_p2=1 nf_p3=1 wn1=120n wn2=120n wn3=120n wp1=120n wp2=120n wp3=120n
MNA1 X A1 net19 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 net19 A2 net018 VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2
+ w=wn2 m=m_n2
MNA3 net018 A3 VSS VBN slvtnfet cpp=cpp p_la=p_la_n3 ulp=ulp nf=nf_n3 l=ln3
+ w=wn3 m=m_n3
MPA1 X A1 VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MPA3 X A3 VDD VBP slvtpfet cpp=cpp p_la=p_la_p3 ulp=ulp nf=nf_p3 l=lp3 w=wp3
+ m=m_p3
MPA2 X A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
.ends

.subckt mm16a05_u_hdsp_add_we_latch_clk_gen VDDPI VSS VBP VBN CLKB_LATCH FLTBL
+ LCLKB LCLKT LSB CLKFLT DFTCLKEN FLOAT FLOATB LS
XLSB VDDPI VSS VBP VBN LSB FLOATB LS
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160.0n wn2=160.0n
+ wp1=160.0n wp2=160.0n
Xinv_lclk VDDPI VSS VBP VBN FLT FLTBL mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=280n
+ wp=280n
Xinv_lclkb VDDPI VSS VBP VBN LCLKB FLTBL mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=14 m_p=7 nf_n=1 nf_p=1
+ wn=200n wp=400n
Xinv_lclkt VDDPI VSS VBP VBN LCLKT FLT mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=0 p_la_p=4n ulp=0 ln=20n lp=20n m_n=11 m_p=10 nf_n=1 nf_p=1 wn=280n
+ wp=280n
Xnd2_clkenab VDDPI VSS VBP VBN CLKB_LATCH CLKFLT DFTCLKEN
+ mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=440n wn2=440n wp1=240n
+ wp2=240n
Xnd3_lclk[0] VDDPI VSS VBP VBN FLTBL LSB CLKB_LATCH FLOAT
+ mm16a05_u_nd3_bulk_n1_vt3_n2_vt3_n3_vt3_p1_vt3_p2_vt3_p3_vt3 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=120n
+ wn2=120n wn3=120n wp1=240n wp2=240n wp3=240n
Xnd3_lclk[1] VDDPI VSS VBP VBN FLTBL LSB CLKB_LATCH FLOAT
+ mm16a05_u_nd3_bulk_n1_vt3_n2_vt3_n3_vt3_p1_vt3_p2_vt3_p3_vt3 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=120n
+ wn2=120n wn3=120n wp1=240n wp2=240n wp3=240n
.ends

.subckt mm16a05_u_hdsp_plus_cenclock_dft VDDP VDDPI VSS VBP VBN FLOAT FLOATT
+ FLTBL LCLKB LCLKBIO LCLKT CKGATE FLOATB FLOATBD IN_2INV IN_2INV_ADDR IN_4INV
+ IN_6INV LS_INT OUT_2INV OUT_4INV OUT_6INV CLKB CLKFLT CLPSEBUF DFTCLKEN DLYPW
+ FLOAT_RET LDFTX LMEB LS LS_ONLY SE_IN
Xinv_fltt VDDP VSS VBP VBN FLOATT FLOATB mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=240n wp=120n
XI63 VDDPI VSS VBP VBN FLOATB FLOAT mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XPWGEN VDDP VDDPI VSS VBP VBN PW CLKFLT CLPSEBUF LDFTX DLYPW FLOAT_RET LS_ONLY
+ SE_IN mm16a05_u_hdsp_plus_pw_gen
XIDCLK_GEN VDDP VDDPI VSS VBP VBN FLTIO LCLKBIO FLOATBD LS_INT OUT_2INV
+ OUT_4INV OUT_6INV CLKB_LATCH FLOAT IN_2INV IN_4INV IN_6INV LS net471
+ mm16a05_u_hdsp_data_latch_clock_gen
XIFLOAT_GEN VDDP VDDPI VSS VBP VBN CKGATE FLOAT CLKB CLPSEBUF DLYPW LDFTX LMEB
+ PW mm16a05_u_hdsp_plus_float_gen
XADDR_LATCH_GEN VDDPI VSS VBP VBN CLKB_LATCH FLTBL LCLKB LCLKT net475 CLKFLT
+ DFTCLKEN FLOAT FLOATB LS mm16a05_u_hdsp_add_we_latch_clk_gen
.ends

.subckt mm16a05_u_hdsp_plus_gcen_base VDDP VDDPI VSS VBP VBN CLKB CLKDEL FLOAT
+ FLOATT LBKADR[0] LBKADR[1] LBKADR[2] LCLKB LCLKBIO LCLKT LME LWE LWE_DFT
+ LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+ LYADR[0] LYADR[1] LYADR[2] LYADR[3] MCLKB MCLKT MEB_LT T1T CKGATE DFTCLKEN
+ LDFTX LOG1 MEORDFTCLKEN BKADR[0] BKADR[1] BKADR[2] CLK CLKFLT CLK_MUXB
+ CLPSEBUF DLYPW FLOAT_RET LS ME MEB_I MEORDFTCLKEN_IN SE_IN TEST1 WE XADR[0]
+ XADR[1] XADR[2] XADR[3] XADR[4] XADR[5] XADR[6] XADR[7] YADR[0] YADR[1]
+ YADR[2] YADR[3]
XADDR_LATCH VDDP VDDPI VSS VBP VBN LBKADR[0] LBKADR[1] LBKADR[2] LXADR[0]
+ LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+ LYADR[1] LYADR[2] LYADR[3] LYADRB[2] LYADRB[3] BKADR[0] BKADR[1] BKADR[2]
+ LCLKB LCLKT XADR[0] XADR[1] XADR[2] XADR[3] XADR[4] XADR[5] XADR[6] XADR[7]
+ YADR[0] YADR[1] YADR[2] YADR[3] mm16a05_u_hdsp_plus_adr_latches_cm16bk8
XTCLK_GEN VDDP VDDPI VSS VBP VBN FLOAT T1T TCLKB mm16a05_u_hdsp_plus_tclk
XI108[0] VDDPI VSS VBP VBN LSORMEORDFTCLKEN net190 MEORDFTCLKEN_IN
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160.0n wn2=160.0n
+ wp1=160.0n wp2=160.0n
XI108[1] VDDPI VSS VBP VBN LSORMEORDFTCLKEN net190 MEORDFTCLKEN_IN
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160.0n wn2=160.0n
+ wp1=160.0n wp2=160.0n
XCONTROL VDDP VDDPI VSS VBP VBN TCLKB LME LMEWRB LWE LWE_DFT MCLKB MCLKT MEB_LT
+ MEORDFTCLKEN T1T DFTCLKENB CLKFLT DFTCLKEN LCLKB LCLKT LDFTX ME MEB_I TEST1
+ WE mm16a05_u_hdsp_control_dft
XCLOCK VDDP VDDPI VSS VBP VBN FLOAT FLOATT FLTBL LCLKB LCLKBIO LCLKT CKGATE
+ FLOATB FLOATB FLOATB LOG1 LOG1 LOG1 LSORMEORDFTCLKEN LSORMEORDFTCLKEN net212
+ net211 CLK_MUXB CLKFLT CLPSEBUF DFTCLKEN DLYPW FLOAT_RET LDFTX LMEWRB
+ LSORMEORDFTCLKEN LS SE_IN mm16a05_u_hdsp_plus_cenclock_dft
Xinv_clk VDDPI VSS VBP VBN CLKB CLK mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1 wn=160n
+ wp=240n
Xinv_clkb VDDPI VSS VBP VBN CLKDEL CLKB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=8 nf_n=1 nf_p=1 wn=160n
+ wp=240n
XI106 VDDPI VSS VBP VBN net190 LS mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=200n
+ wp=200n
.ends

.subckt mm16a05_u_hdsp_plus_gcen VDDA VDDF VDDP VDDPI VDDMINB VSS VBP VBN
+ ARYSDB ARYSDB_BC1 ARYSDB_BC2 CLKDEL DEF1 DEF1B DEF2 DEF2B DEF_MODE FAST1_MODE
+ FAST2_MODE LBKADR[0] LBKADR[1] LBKADR[2] LCLKB LCLKBIO LCLKT LITESLP LME LSDB
+ LSDB_BC1 LSDB_BC2 LWE LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+ LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] LYADR[2] LYADR[3] MCLKB MCLKT
+ MEB_LT RAB[0] RAB[1] RM3_CORE_CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLCKB T1T
+ TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0]
+ WPBUF[1] WPBUF[2] CLKB CLPSEBUF FISO FLOAT FLOATT LOG0 LOG1 LOG1_RM
+ MEORDFTCLKEN MEORDFTCLKEN_IN RM3CLPSB RSCEN RSCIN RSCLK RSCOUT RSCRST SDCLPSB
+ WFLOAT BC0 BC1 BC2 BKADR[0] BKADR[1] BKADR[2] CENDP CLK CLKFLT CLK_MUXB
+ DEF12B_PROG DEF12_PROG DEF_PROG DFTCLKEN DISCHG DLYPW FLOAT_RET LDFTX LS ME
+ MEB_I RA[0] RA[1] RM[0] RM[1] RM[2] RM[3] RMDEF1[0] RMDEF1[1] RMDEF1[2]
+ RMDEF1[3] RMDEF2[0] RMDEF2[1] RMDEF2[2] RMDEF2[3] RME RMENI[0] RMENI[1]
+ RMENI[2] RMSLOW[0] RMSLOW[1] RMSLOW[2] RMSLOW[3] SD SE_IN TEST1 TEST_RNM
+ WA[0] WA[1] WE WMDEF1[0] WMDEF1[1] WMDEF1[2] WMDEF1[3] WMDEF2[0] WMDEF2[1]
+ WMDEF2[2] WMDEF2[3] WMSLOW[0] WMSLOW[1] WMSLOW[2] WMSLOW[3] WPULSE[0]
+ WPULSE[1] WPULSE[2] XADR[0] XADR[1] XADR[2] XADR[3] XADR[4] XADR[5] XADR[6]
+ XADR[7] YADR[0] YADR[1] YADR[2] YADR[3]
XI126[0] VDDPI VSS VBP VBN WABUF[0] WA[0] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=400n wp=400n
XI126[1] VDDPI VSS VBP VBN WABUF[1] WA[1] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=400n wp=400n
XI122[0] VDDPI VSS VBP VBN RAB[0] RA[0] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=400n
+ wp=400n
XI122[1] VDDPI VSS VBP VBN RAB[1] RA[1] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=400n
+ wp=400n
XI127[0] VDDPI VSS VBP VBN WPBUF[0] WPULSE[0] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=400n wp=400n
XI127[1] VDDPI VSS VBP VBN WPBUF[1] WPULSE[1] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=400n wp=400n
XI127[2] VDDPI VSS VBP VBN WPBUF[2] WPULSE[2] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=400n wp=400n
Xinv_testrnm VDDPI VSS VBP VBN TEST_RNMB TEST_RNM
+ mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=400n wp=400n
XINV_WE1 VDDPI VSS VBP VBN LWEIB LWE_DFT mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1
+ wn=400n wp=400n
XLSLTCH VDDP VDDPI VSS VBP VBN LITESLP RWLCKB LS FLOAT WFLOAT
+ mm16a05_u_pg_lsltch_sp
XRMCTRL VDDP VDDPI VDDMINB VSS VBP VBN DEF1 DEF1B DEF2 DEF2B DEF_MODE
+ FAST1_MODE FAST2_MODE RM3_CORE_CNT RMT[0] RMT[1] RMT[2] RMT[3] WMT[0] WMT[1]
+ WMT[2] WMT[3] LOG0 LOG1 LOG1_RM BC0 DEF12B_PROG DEF12_PROG DEF_PROG FLOAT
+ LSDB RM[0] RM[1] RM[2] RM[3] RMDEF1[0] RMDEF1[1] RMDEF1[2] RMDEF1[3]
+ RMDEF2[0] RMDEF2[1] RMDEF2[2] RMDEF2[3] RME RMENI[0] RMENI[1] RMENI[2]
+ RMSLOW[0] RMSLOW[1] RMSLOW[2] RMSLOW[3] WMDEF1[0] WMDEF1[1] WMDEF1[2]
+ WMDEF1[3] WMDEF2[0] WMDEF2[1] WMDEF2[2] WMDEF2[3] WMSLOW[0] WMSLOW[1]
+ WMSLOW[2] WMSLOW[3] mm16a05_u_hdsp_plus_rmctrl
XI203 VDDPI VSS VBP VBN WABUF[2] WA[0] WA[1]
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=380.0n wn2=380.0n
+ wp1=600.0n wp2=600.0n
XI205 VDDPI VSS VBP VBN WABUF[2] WA[0] WA[1]
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=220.0n wn2=220.0n
+ wp1=600.0n wp2=600.0n
XLSDB_BC_CTRL VDDP VSS VBP VBN LSDB LSDB_BC1 LSDB_BC2 LOG1 BC1 BC2 SD
+ mm16a05_u_bc_control_hdsp
XCTRLWR VDDP VDDPI VSS VBP VBN CLKB CLKDEL FLOAT FLOATT LBKADR[0] LBKADR[1]
+ LBKADR[2] LCLKB LCLKBIO LCLKT LME LWE LWE_DFT LXADR[0] LXADR[1] LXADR[2]
+ LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] LYADR[2]
+ LYADR[3] MCLKB MCLKT MEB_LT T1T CKGATE DFTCLKEN LDFTX LOG1 MEORDFTCLKEN
+ BKADR[0] BKADR[1] BKADR[2] CLK CLKFLT CLK_MUXB CLPSEBUF DLYPW FLOAT_RET LS ME
+ MEB_I MEORDFTCLKEN_IN SE_IN TEST1 WE XADR[0] XADR[1] XADR[2] XADR[3] XADR[4]
+ XADR[5] XADR[6] XADR[7] YADR[0] YADR[1] YADR[2] YADR[3]
+ mm16a05_u_hdsp_plus_gcen_base
.ends

.subckt mm16a05_u_pg_arysd_buf VDDA VSS VBP VBN ARYSD ARYSD_BC1 ARYSD_BC2
+ ARYSDB ARYSDB_BC1 ARYSDB_BC2 SDCLPSB
XI12 VDDA VSS VBP VBN ARYSD ARYSDB_SDCLPSB mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=320n wp=320n
XI9 VDDA VSS VBP VBN ARYSD_BC1 ARYSDB_BC1 mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=320n wp=320n
XI11 VDDA VSS VBP VBN ARYSD_BC2 ARYSDB_BC2 mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=320n wp=320n
XI17 VDDA VSS VBP VBN ARYSDB_SDCLPSB ARYSDB SDCLPSB
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=320n
+ wp2=320n
.ends

.subckt mm16a05_u_hdsp_plus_gcenbuf VDDA VDDP VDDPI VSS VBP VBN DCLKT LYB[0]
+ LYB[1] RASSIST[0] RASSIST[1] ARYSD ARYSDB ARYSDB_BC1 ARYSDB_BC2 ARYSD_BC1
+ ARYSD_BC2 DLYPDB GSE_DB GSE_DT LDFTYBUF LOG0 LOG1 LCLKBIO LY[0] LY[1]
+ LYADR[2] LYADR[3] RAB[0] RAB[1] SDCLPSB
XDCLKT VDDPI VSS VBP VBN net126 LCLKBIO mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=200n
+ wp=200n
XDCLK VDDPI VSS VBP VBN DCLKT net126 mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=12 m_p=12 nf_n=1 nf_p=1 wn=200n
+ wp=300n
XINV_LY[0] VDDPI VSS VBP VBN LYB[0] LY[0] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=5 m_p=5 nf_n=1 nf_p=1
+ wn=400n wp=600n
XINV_LY[1] VDDPI VSS VBP VBN LYB[1] LY[1] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=5 m_p=5 nf_n=1 nf_p=1
+ wn=400n wp=600n
XIRA[0] VDDPI VSS VBP VBN RASSIST[0] RAB[0] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=200.0n wp=200.0n
XIRA[1] VDDPI VSS VBP VBN RASSIST[1] RAB[1] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=200.0n wp=200.0n
XIPG_ARYSD_BUF VDDP VSS VBP VBN ARYSD ARYSD_BC1 ARYSD_BC2 ARYSDB ARYSDB_BC1
+ ARYSDB_BC2 SDCLPSB mm16a05_u_pg_arysd_buf
.ends

.subckt mm16a05_u_ram6t_corner_hs1prf VSS VBA
MNPD_corner noconnect1 noconnect_gate1 VSS VBA spjnfetpd cpp=110n p_la=0 ulp=0
+ nf=1 l=30n w=100n m=1
.ends

.subckt mm16a05_u_hdsp_plus_pg_pwedge VDDA VDDP VDDPI VSS VBP VBN LOG0 LOG1
+ PGIOI PO SDOR_OUT TOPEDGE VBA VEDGE SDOR_IN
XI17 VDDA VSS VBP VBN SDOR_OUT net20 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI13 VDDA VSS VBP VBN net20 SDOR_IN mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XDUMMY0 VSS VBA mm16a05_u_ram6t_corner_hs1prf
.ends

.subckt mm16a05_u_strap_x1_hc_gf22 VDDA VDDAI VSS VBP VBN VBA bb diff_nc1
+ strap_diff strap_gate
MPPU_strap VDDAI netg1 nocon VBA spjpfetpu cpp=110n p_la=0 ulp=0 nf=1 l=30n
+ w=50n m=1
MNPD_strap VSS netg1 net6 VBA spjnfetpd cpp=110n p_la=0 ulp=0 nf=1 l=30n w=100n
+ m=1
MNPG_strap bb VSS net7 VBA spjnfetwl cpp=110n p_la=0 ulp=0 nf=1 l=30n w=96n m=1
.ends

.subckt mm16a05_u_ram6t_strapx4_hc VDDA VDDAI VSS VBP VBN BB[0] BB[1] BB[2]
+ BB[3] VBA strap_diff_left strap_diff_right strap_gate_left strap_gate_right
Xtr1 VDDA VDDAI VSS VBP VBN VBA BB[1] net3 net2 net1 mm16a05_u_strap_x1_hc_gf22
Xtr2 VDDA VDDAI VSS VBP VBN VBA BB[2] net4 net2 net1 mm16a05_u_strap_x1_hc_gf22
Xtr3 VDDA VDDAI VSS VBP VBN VBA BB[3] net4 strap_diff_right strap_gate_right
+ mm16a05_u_strap_x1_hc_gf22
Xtr0 VDDA VDDAI VSS VBP VBN VBA BB[0] net3 strap_diff_left strap_gate_left
+ mm16a05_u_strap_x1_hc_gf22
.ends

.subckt mm16a05_u_corebias_gf22 VDDA VDDAI VBP VBN SDBD1 SDBD2 LLSB SDB_BC1T
+ SDB_BC2T
M0 VDDAI LLSB VDDA VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=200n m=4
M2 SDBD1 SDB_BC1T VDDAI VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=155n
+ m=2
M3 SDBD1 SDBD1 VDDA VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=210n m=5
M7 SDBD2 SDB_BC2T VDDAI VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=155n
+ m=1
M1 SDBD2 SDBD2 VDDA VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=155n m=2
.ends

.subckt mm16a05_u_hdsp_plus_rar4x1_wk_bk2 VDDA VDDAI VDDP VDDPI VSS VBP VBN
+ BB[0] BB[1] BB[2] BB[3] LOG0 LOG1 QB QT SDOR SDOR_RET SEL VBA WBI WTI LLSB
+ SDB_BC1T SDB_BC2T
XDUMMY VDDA VDDAI VSS VBP VBN BB[0] BB[1] BB[2] BB[3] VBA net120 net121 net122
+ net123 mm16a05_u_ram6t_strapx4_hc
XCOREBIAS VDDA VDDAI VBP VBN net124 net125 LLSB SDB_BC1T SDB_BC2T
+ mm16a05_u_corebias_gf22
.ends

.subckt mm16a05_u_pg_wlstkrw_plus_wk_bk2_buf VDDA VDDWL VSS VBP VBN LCGTHB
+ LCGTH
MI11 VDDWL VDDWL VDDA VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=150n m=2
MI10 VDDA LCGTH VDDWL VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=360n
+ m=10
M0 VDDA LCGTH VDDWL VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=840n m=10
M1 VDDA VDDWL VDDWL VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=150n m=2
XI15 VDDA VSS VBP VBN LCGTHB LCGTH mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=2 nf_p=2 wn=240.0n
+ wp=240.0n
.ends

.subckt mm16a05_u_arysd_dly_hdsp_wk_bk2 VDDA VDDAI VSS VBP VBN OUT OUTB IN
XI12 VDDAI VSS VBP VBN net169 IN net49
+ mm16a05_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
MI15_N OUT net169 VSS VBN lvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=2
MI20 net157 net110 VSS VBN lvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI19 net155 IN VSS VBN lvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI15_P VDDA net169 OUT VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n m=4
MPA VDDAI IN net153 VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI18 VDDA net110 net104 VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
XI13 net153 net155 VBP VBN net110 IN mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
Xinv_0 net104 net157 VBP VBN inb net110 mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI10 VDDA VSS VBP VBN net49 outt mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI11 VDDAI VSS VBP VBN outt inb mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI14 VDDA VSS VBP VBN OUTB OUT mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=160n
.ends

.subckt mm16a05_u_hdsp_plus_pg_aryslpbuf_wk_bk2 VDDA VSS VBP VBN ARYSDB_BC1
+ ARYSDB_BC2 ARYSD_DELAY LLSB RESDOR_RET ARYSD_BC1 ARYSD_BC2 ARYSD_IN LCGTH
+ SDOR_RETI
XI22 VDDA VSS VBP VBN net78 LCGTH ARYSD_DELAY
+ mm16a05_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=400n
+ wp2=400n
XI24 VDDAI_R VSS VBP VBN net74 ARYSD_BC1 ARYSD_DELAY
+ mm16a05_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=400n wn2=400n wp1=480n
+ wp2=480n
XI10 VDDAI_R VSS VBP VBN net72 ARYSD_BC2 ARYSD_DELAY
+ mm16a05_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=400n wn2=400n wp1=480n
+ wp2=480n
XI17 VDDA VDDA VSS VBP VBN ARYSD_DELAY net82 ARYSD_INT
+ mm16a05_u_arysd_dly_hdsp_wk_bk2
XI30 VDDA VSS VBP VBN ARYSDB_BC1 net74 mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=420n
+ wp=420n
XI25 VDDA VSS VBP VBN ARYSD_INT ARYSD_IN mm16a05_u_inv_bulk_n_vt1_p_vt1
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=320n wp=400n
XI28 VDDA VSS VBP VBN ARYSDB_BC2 net72 mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=321n
+ wp=201n
XI21 VDDA VSS VBP VBN RESDOR_RET SDOR_RETI mm16a05_u_inv_bulk_n_vt1_p_vt1
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=320n wp=400n
XI34 VDDA VSS VBP VBN LLSB net78 mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=641n
+ wp=401n
MPA VDDA ARYSD_INT VDDAI_R VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=4
.ends

.subckt mm16a05_u_hdsp_plus_rwbuf_wk_bk2_left VDDA VDDP VDDPI VDDWL VSS VBP VBN
+ ARYSDB_BC1 ARYSDB_BC2 ARYSD_TOP LLSB RWL_RD RWL_WR ARYSD_OUT LOG0 LOG1 PO
+ RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] RWLD_RD RWLD_WR TOPEDGE VBA
+ ARYSD_BC1 ARYSD_BC2 ARYSD_IN LCGTH RWLB_RD RWLB_WR SDOR_RETI
XWLSTACK VDDA VDDWL VSS VBP VBN net123 LCGTH
+ mm16a05_u_pg_wlstkrw_plus_wk_bk2_buf
XI25 VDDA VSS VBP VBN ARYSDB_BC1 ARYSDB_BC2 ARYSD_OUT LLSB ARYSD_TOP ARYSD_BC1
+ ARYSD_BC2 ARYSD_IN LCGTH SDOR_RETI mm16a05_u_hdsp_plus_pg_aryslpbuf_wk_bk2
XDUMMY VSS VBA mm16a05_u_ram6t_corner_hs1prf
.ends

.subckt mm16a05_u_logrepw VDDP VSS VBP VBN LOG0 LOG1
M0 LOG0 LOG1 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=300n m=2
MPLOG VDDP LOG0 LOG1 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=300n m=2
.ends

.subckt mm16a05_u_hdsp_plus_rw_wk_bk2 VDDA VDDMINB VDDP VDDPI VSS VBP VBN
+ RWLB_RD RWLB_WR CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT_RET LBKADR[0]
+ LBKADR[1] LBKADR[2] LDFTX LITESLP LLBKADRB[1] LLBKADRB[2] LMATCHB LMATCHB_I
+ LOG0 LOG1 LWEIB_HV LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+ LXADR[6] LXADR[7] LYADR[0] LYADR[1] PLBKADR[1] PLBKADR[2] RBLRD RBLWA RBLWR
+ RM3CNT RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WPBUF[0] WPBUF[1]
+ WPBUF[2] FLOAT FLOATT LWEIB RMT[0] RMT[1] RMT[2] RMT[3] RWLD_RD RWLD_WR
+ WMT[0] WMT[1] WMT[2] WMT[3]
XI11 VDDP VSS VBP VBN LOG0 LOG1 mm16a05_u_logrepw
.ends

.subckt mm16a05_u_hdsp_plus_rwbuf_wk_bk2 VDDA VDDP VDDPI VDDWL VSS VBP VBN
+ ARYSDB_BC1 ARYSDB_BC2 ARYSD_TOP LCGTHB LLSB RWL_RD RWL_WR ARYSD_IN ARYSD_OUT
+ LOG0 LOG1 PO RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] RWLD_RD RWLD_WR
+ TOPEDGE VBA ARYSD_BC1 ARYSD_BC2 LCGTH RWLB_RD RWLB_WR SDOR_RETI
XDUMMY VSS VBA mm16a05_u_ram6t_corner_hs1prf
XWLSTACK VDDA VDDWL VSS VBP VBN LCGTHB LCGTH
+ mm16a05_u_pg_wlstkrw_plus_wk_bk2_buf
XI25 VDDA VSS VBP VBN ARYSDB_BC1 ARYSDB_BC2 ARYSD_OUT LLSB ARYSD_TOP ARYSD_BC1
+ ARYSD_BC2 ARYSD_IN LCGTH SDOR_RETI mm16a05_u_hdsp_plus_pg_aryslpbuf_wk_bk2
.ends

.subckt mm16a05_u_edge1_hc VSS VBP VBN VBA WL edge_bot edge_top
MNPG_edge netnc1 WL edge_top VBA spjnfetwl cpp=110n p_la=0 ulp=0 nf=1 l=30n
+ w=96n m=1
MNPD_edge edge_bot noconn netnc1 VBA spjnfetpd cpp=110n p_la=0 ulp=0 nf=1 l=30n
+ w=100n m=1
.ends

.subckt mm16a05_u_edge4_hc VSS VBP VBN VBA WL[0] WL[1] WL[2] WL[3]
Xedge3 VSS VBP VBN VBA WL[3] VSS VSS mm16a05_u_edge1_hc
Xedge2 VSS VBP VBN VBA WL[2] VSS VSS mm16a05_u_edge1_hc
Xedge1 VSS VBP VBN VBA WL[1] VSS VSS mm16a05_u_edge1_hc
Xedge0 VSS VBP VBN VBA WL[0] VSS VSS mm16a05_u_edge1_hc
.ends

.subckt mm16a05_u_hdsp_plus_edge4 VDDA VDDP VDDPI VSS VBP VBN EDGEB EDGET LOG0
+ LOG1 PGIOI VBA VEDGE WL[0] WL[1] WL[2] WL[3]
XDUMMY0 VSS VBP VBN VBA WL[0] WL[1] WL[2] WL[3] mm16a05_u_edge4_hc
.ends

.subckt mm16a05_u_ram6x_base VDDA_RB VDDA_RT VNWA VSSC_RB VSS VBP VBN BB BT RB
+ RT VBA VSCS_RT WL_RB WL_RT
MPPU_T VDDA_RT RB RT VBA spjpfetpu cpp=110n p_la=0 ulp=0 nf=1 l=30n w=50n m=1
MPPU_B VDDA_RB RT RB VBA spjpfetpu cpp=110n p_la=0 ulp=0 nf=1 l=30n w=50n m=1
MNPG_B BB WL_RB RB VBA spjnfetwl cpp=110n p_la=0 ulp=0 nf=1 l=30n w=96n m=1
MNPD_T VSCS_RT RB RT VBA spjnfetpd cpp=110n p_la=0 ulp=0 nf=1 l=30n w=100n m=1
MNPG_T BT WL_RT RT VBA spjnfetwl cpp=110n p_la=0 ulp=0 nf=1 l=30n w=96n m=1
MNPD_B VSSC_RB RT RB VBA spjnfetpd cpp=110n p_la=0 ulp=0 nf=1 l=30n w=100n m=1
.ends

.subckt mm16a05_u_ram6x VDDA_RB VDDA_RT VNWA VSS VSSC_RB VBP VBN BB BT RB RT
+ VBA VSCS_RT WL_RB WL_RT
XBASE VDDA_RB VDDA_RT VNWA VSSC_RB VSS VBP VBN BB BT RB RT VBA VSCS_RT WL_RB
+ WL_RT mm16a05_u_ram6x_base
.ends

.subckt mm16a05_u_ram6t VDDA VNWA VSS VSSC VBP VBN BB BT VBA WL
XRAM VDDA VDDA VNWA VSS VSSC VBP VBN BB BT RB RT VBA VSSC WL WL mm16a05_u_ram6x
.ends

.subckt mm16a05_u_hd1p_bar4x4m4 VDDA VDDAI VDDP VSS VBP VBN BB[0] BB[1] BB[2]
+ BB[3] BT[0] BT[1] BT[2] BT[3] QBB QTB SEL VBA WBI WTI WL[0] WL[1] WL[2] WL[3]
XA00 VDDAI VDDA VSS VSS VBP VBN BB[0] BT[0] VBA WL[0] mm16a05_u_ram6t
XA01 VDDAI VDDA VSS VSS VBP VBN BB[1] BT[1] VBA WL[0] mm16a05_u_ram6t
XA02 VDDAI VDDA VSS VSS VBP VBN BB[2] BT[2] VBA WL[0] mm16a05_u_ram6t
XAFF VDDAI VDDA VSS VSS VBP VBN BB[3] BT[3] VBA WL[0] mm16a05_u_ram6t
XC00 VDDAI VDDA VSS VSS VBP VBN BB[0] BT[0] VBA WL[2] mm16a05_u_ram6t
XCFF VDDAI VDDA VSS VSS VBP VBN BB[3] BT[3] VBA WL[2] mm16a05_u_ram6t
XC01 VDDAI VDDA VSS VSS VBP VBN BB[1] BT[1] VBA WL[2] mm16a05_u_ram6t
XBFF VDDAI VDDA VSS VSS VBP VBN BB[3] BT[3] VBA WL[1] mm16a05_u_ram6t
XB02 VDDAI VDDA VSS VSS VBP VBN BB[2] BT[2] VBA WL[1] mm16a05_u_ram6t
XB01 VDDAI VDDA VSS VSS VBP VBN BB[1] BT[1] VBA WL[1] mm16a05_u_ram6t
XB00 VDDAI VDDA VSS VSS VBP VBN BB[0] BT[0] VBA WL[1] mm16a05_u_ram6t
XD02 VDDAI VDDA VSS VSS VBP VBN BB[2] BT[2] VBA WL[3] mm16a05_u_ram6t
XC02 VDDAI VDDA VSS VSS VBP VBN BB[2] BT[2] VBA WL[2] mm16a05_u_ram6t
XD01 VDDAI VDDA VSS VSS VBP VBN BB[1] BT[1] VBA WL[3] mm16a05_u_ram6t
XD00 VDDAI VDDA VSS VSS VBP VBN BB[0] BT[0] VBA WL[3] mm16a05_u_ram6t
XDFF VDDAI VDDA VSS VSS VBP VBN BB[3] BT[3] VBA WL[3] mm16a05_u_ram6t
.ends

.subckt mm16a05_u_hdsp_plus_ar4x4m4 VDDA VDDAI VDDP VDDPI VSS VBP VBN BB[0]
+ BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3] QB QT SEL VBA WBI WTI WL[0] WL[1]
+ WL[2] WL[3]
XBAR4 VDDA VDDAI VDDP VSS VBP VBN BB[0] BB[1] BB[2] BB[3] BT[0] BT[1] BT[2]
+ BT[3] QB QT SEL VBA WBI WTI WL[0] WL[1] WL[2] WL[3] mm16a05_u_hd1p_bar4x4m4
.ends

.subckt mm16a05_u_hd1p_xbuf1_gf VDDWL VDD_BK VSS VBP VBN WL WLB
MI6 VDDWL WLB WL VBP lvtpfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=1420.0n m=4
M17 WL WLB VSS VBN lvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=760.0n m=4
.ends

.subckt mm16a05_u_read_assist VDD_BULK VSS VBP VBN RD_ASSIST_BIAS[0]
+ RD_ASSIST_BIAS[1] WL
M0 WL RD_ASSIST_BIAS[0] VSS VBP lvtpfet cpp=110n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=4
M1 WL RD_ASSIST_BIAS[1] VSS VBP lvtpfet cpp=110n p_la=4n ulp=0 nf=1 l=20n
+ w=180n m=4
.ends

.subckt mm16a05_u_xbuf4_plus VDDWL VDD_BK VSS VBP VBN WL[0] WL[1] WL[2] WL[3]
+ RD_ASSIST_BIAS[0] RD_ASSIST_BIAS[1] WLB[0] WLB[1] WLB[2] WLB[3]
XWL3 VDDWL VDD_BK VSS VBP VBN WL[3] WLB[3] mm16a05_u_hd1p_xbuf1_gf
XWL2 VDDWL VDD_BK VSS VBP VBN WL[2] WLB[2] mm16a05_u_hd1p_xbuf1_gf
XWL0 VDDWL VDD_BK VSS VBP VBN WL[0] WLB[0] mm16a05_u_hd1p_xbuf1_gf
XWL1 VDDWL VDD_BK VSS VBP VBN WL[1] WLB[1] mm16a05_u_hd1p_xbuf1_gf
XI21 VDD_BK VSS VBP VBN RD_ASSIST_BIAS[0] RD_ASSIST_BIAS[1] WL[2]
+ mm16a05_u_read_assist
XI20 VDD_BK VSS VBP VBN RD_ASSIST_BIAS[0] RD_ASSIST_BIAS[1] WL[3]
+ mm16a05_u_read_assist
XI22 VDD_BK VSS VBP VBN RD_ASSIST_BIAS[0] RD_ASSIST_BIAS[1] WL[1]
+ mm16a05_u_read_assist
XI23 VDD_BK VSS VBP VBN RD_ASSIST_BIAS[0] RD_ASSIST_BIAS[1] WL[0]
+ mm16a05_u_read_assist
.ends

.subckt mm16a05_u_x4buf_base_plus VDDWL VDDA VSS VBP VBN WL[0] WL[1] WL[2]
+ WL[3] RD_ASSIST_BIAS[0] RD_ASSIST_BIAS[1] WLB[0] WLB[1] WLB[2] WLB[3]
XDEC VDDWL VDDA VSS VBP VBN WL[0] WL[1] WL[2] WL[3] RD_ASSIST_BIAS[0]
+ RD_ASSIST_BIAS[1] WLB[0] WLB[1] WLB[2] WLB[3] mm16a05_u_xbuf4_plus
.ends

.subckt mm16a05_u_hdsp_plus_x4buf VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[0] WL[1]
+ WL[2] WL[3] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB EDGET LCGTH LOG0 LOG1 RASSIST[0]
+ RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[0] WLB[1] WLB[2] WLB[3]
XBUF VDDWL VDDA VSS VBP VBN WL[0] WL[1] WL[2] WL[3] RASSISTB[0] RASSISTB[1]
+ WLB[0] WLB[1] WLB[2] WLB[3] mm16a05_u_x4buf_base_plus
XDUMMY VSS VBP VBN VBA WL[0] WL[1] WL[2] WL[3] mm16a05_u_edge4_hc
.ends

.subckt mm16a05_u_hd1p_rbl_load VSS VBP VBN LOG0 RBLRD RBLWA RBLWR RBLWR_LOAD
M0 X1 LOG0 RBLRD VBN lvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
MI16 X3 LOG0 RBLWA VBN lvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI15 X2 LOG0 RBLWA VBN lvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI14 X1 LOG0 RBLWA VBN lvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M13 X4 LOG0 RBLWR_LOAD VBN lvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M12 X4 LOG0 net52 VBN lvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
M11 X3 LOG0 RBLWR_LOAD VBN lvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M10 X3 LOG0 net52 VBN lvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
M9 X2 LOG0 RBLWR_LOAD VBN lvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI17 X4 LOG0 RBLWA VBN lvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M8 X2 LOG0 RBLRD VBN lvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
M1 X1 LOG0 RBLWR_LOAD VBN lvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
.ends

.subckt mm16a05_u_xdec_nr2_plus VDDA VSS VBP VBN WLBB SOFTVDDA DEC WCLKB
M17 WLBB WCLKB VSS VBN slvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=240n m=2
MI39 WLBB DEC VSS VBN slvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
M33 SOFTVDDA WCLKB WLBB VBP slvtpfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=240n
+ m=2
MI43 SOFTVDDA VDDA VDDA VBP slvtpfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=240n
+ m=1
.ends

.subckt mm16a05_u_xdec_base_plus VDDA VDDP VDDPI VSS VBP VBN DEC_LV WLBB[0]
+ WLBB[1] WLBB[2] WLBB[3] LOG1 B C DEC_HV WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
XDEC_ND2 VDDPI VSS VBP VBN DEC_LV B C
+ mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=110n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=244n wn2=244n wp1=268n
+ wp2=268n
M33 VDDA DEC_HV net264 VBP slvtpfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=240n
+ m=4
XDEC_NR2[3] VDDA VSS VBP VBN WLBB[3] net264 DEC_HV WCLKB[3]
+ mm16a05_u_xdec_nr2_plus
XDEC_NR2[0] VDDA VSS VBP VBN WLBB[0] net264 DEC_HV WCLKB[0]
+ mm16a05_u_xdec_nr2_plus
XDEC_NR2[1] VDDA VSS VBP VBN WLBB[1] net264 DEC_HV WCLKB[1]
+ mm16a05_u_xdec_nr2_plus
XDEC_NR2[2] VDDA VSS VBP VBN WLBB[2] net264 DEC_HV WCLKB[2]
+ mm16a05_u_xdec_nr2_plus
.ends

.subckt mm16a05_u_hdsp_plus_x4dec VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R
+ VSS VBP VBN DECL WLBH[0] WLBH[1] WLBH[2] WLBH[3] WLBL[0] WLBL[1] WLBL[2]
+ WLBL[3] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET LDFTX
+ LMATCH LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT RMT[0]
+ RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WMT[0]
+ WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] B C CENDP DECH FLOAT
+ LBKADR[0] LBKADR[1] LBKADR[2] LITESLP LXADR[0] LXADR[1] LXADR[2] LXADR[3]
+ LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2]
+ PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5]
+ PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
XREFBL VSS VBP VBN LOG0 RBLRD RBLWA RBLWR RBLWR_LOAD mm16a05_u_hd1p_rbl_load
XINV_WLBB[0] VDDA VSSC_WL_R VBP VBN WLBH[0] WLBB[0]
+ mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=110n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=490n wp=310n
XINV_WLBB[1] VDDA VSSC_WL_R VBP VBN WLBH[1] WLBB[1]
+ mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=110n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=490n wp=310n
XINV_WLBB[2] VDDA VSSC_WL_R VBP VBN WLBH[2] WLBB[2]
+ mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=110n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=490n wp=310n
XINV_WLBB[3] VDDA VSSC_WL_R VBP VBN WLBH[3] WLBB[3]
+ mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=110n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=490n wp=310n
XI104[0] VDDA VSSC_WL_L VBP VBN WLBL[0] WLBB[0] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=110n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=490n wp=310n
XI104[1] VDDA VSSC_WL_L VBP VBN WLBL[1] WLBB[1] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=110n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=490n wp=310n
XI104[2] VDDA VSSC_WL_L VBP VBN WLBL[2] WLBB[2] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=110n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=490n wp=310n
XI104[3] VDDA VSSC_WL_L VBP VBN WLBL[3] WLBB[3] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=110n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=490n wp=310n
XDECWR VDDA VDDP VDDPI VSS VBP VBN DECL WLBB[0] WLBB[1] WLBB[2] WLBB[3] LOG1 B
+ C DECH WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] mm16a05_u_xdec_base_plus
.ends

.subckt mm16a05_u_hdsp_plus_capmux VDDA VDDP VDDPI VSS VBP VBN BOTEDGE LOG0
+ LOG1 PGIOI PO VBA VEDGE
XDUMMY0 VSS VBA mm16a05_u_ram6t_corner_hs1prf
XI8 VDDP VSS VBP VBN LOG0 LOG1 mm16a05_u_logrepedge
.ends

.subckt mm16a05_u_ram6t_strapx4_hc_gf22 VDDA VDDAI VSS VBP VBN BB[0] BB[1]
+ BB[2] BB[3] VBA strap_diff_left strap_diff_right strap_gate_left
+ strap_gate_right
Xtr1 VDDA VDDAI VSS VBP VBN VBA BB[1] net3 net2 net1 mm16a05_u_strap_x1_hc_gf22
Xtr2 VDDA VDDAI VSS VBP VBN VBA BB[2] net4ab net2 net1
+ mm16a05_u_strap_x1_hc_gf22
Xtr3 VDDA VDDAI VSS VBP VBN VBA BB[3] net4 strap_diff_right strap_gate_right
+ mm16a05_u_strap_x1_hc_gf22
Xtr0 VDDA VDDAI VSS VBP VBN VBA BB[0] net3ab strap_diff_left strap_gate_left
+ mm16a05_u_strap_x1_hc_gf22
.ends

.subckt mm16a05_u_hc_cmux_ckprchb VDDP VDDPI VSS VBP VBN PRCHB BADB CKPRCHB
Xckprchb VDDPI VSS VBP VBN PRCHB CKPRCHB mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=120.0n wp=240.0n
.ends

.subckt mm16a05_u_hc_cmux_pg_hdsp VDDP VSS VBP VBN BB BT LOG1 RB RT WB WT RPASS
+ WPASS
MPRT BT RPASS RT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=383n m=1
MPRB BB RPASS RB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=383n m=1
MI42 BB LOG1 RT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=383n m=1
MNWT BT WPASS WT VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=350n m=3
MNWB BB WPASS WB VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=350n m=3
.ends

.subckt mm16a05_u_hc_cmux_pch VDDPI VBP VBN BB BT PRCHB
MBB_PCH VDDPI PRCHB BB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=383.0n
+ m=1
M_EQU BT PRCHB BB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=383.0n m=1
MBT_PCH VDDPI PRCHB BT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=383.0n
+ m=1
.ends

.subckt mm16a05_u_hc_cmux_plus VDDA VDDAI VDDP VDDPI VSS VBP VBN BB BT LOG1 RB
+ RT WB WT PCWRX PRCHB RPASS
XWPASS VDDA VSS VBP VBN WPASS PCWRX mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=2 nf_p=2 wn=240.0n
+ wp=330n
XPG VDDP VSS VBP VBN BB BT LOG1 RB RT WB WT RPASS WPASS
+ mm16a05_u_hc_cmux_pg_hdsp
XPCH VDDPI VBP VBN BB BT PRCHB mm16a05_u_hc_cmux_pch
.ends

.subckt mm16a05_u_hc_cmux2_plus VDDA VDDAI VDDP VDDPI VSS VBP VBN BB[0] BB[1]
+ BT[0] BT[1] LOG1 RB[0] RB[1] RT[0] RT[1] WB[0] WB[1] WT[0] WT[1] PRCHB
+ PRCHWRB[0] PRCHWRB[1] RPASS[0] RPASS[1]
X[0] VDDA VDDAI VDDP VDDPI VSS VBP VBN BB[0] BT[0] LOG1 RB[0] RT[0] WB[0] WT[0]
+ PRCHWRB[0] PRCHB RPASS[0] mm16a05_u_hc_cmux_plus
X[1] VDDA VDDAI VDDP VDDPI VSS VBP VBN BB[1] BT[1] LOG1 RB[1] RT[1] WB[1] WT[1]
+ PRCHWRB[1] PRCHB RPASS[1] mm16a05_u_hc_cmux_plus
.ends

.subckt mm16a05_u_hdsp_plus_hc_cmux4x1 VDDA VDDAI VDDP VDDPI VSS VBP VBN BB[0]
+ BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3] LOG0 LOG1 PO[0] PO[1] POWINT[0]
+ POWINT[1] QB QT RB RT VBA WB WBI WT WTI CKPRCH PRCHRDB[0] PRCHRDB[1]
+ PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] SEL
XDUMMY VDDA VDDAI VSS VBP VBN BB[0] BB[1] BB[2] BB[3] VBA net146 net147 net148
+ net149 mm16a05_u_ram6t_strapx4_hc_gf22
XINV_RD[0] VDDPI VSS VBP VBN RPASS[0] SEL PRCHRDB[0]
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=165.0n
+ wp2=165.0n
XINV_RD[1] VDDPI VSS VBP VBN RPASS[1] SEL PRCHRDB[1]
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=165.0n
+ wp2=165.0n
XINV_RD[2] VDDPI VSS VBP VBN RPASS[2] SEL PRCHRDB[2]
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=165.0n
+ wp2=165.0n
XINV_RD[3] VDDPI VSS VBP VBN RPASS[3] SEL PRCHRDB[3]
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=165.0n
+ wp2=165.0n
XICKPRCHB VDDP VDDPI VSS VBP VBN PRCHB net150 CKPRCH mm16a05_u_hc_cmux_ckprchb
XMX00 VDDA VDDA VDDP VDDPI VSS VBP VBN BB[0] BB[1] BT[0] BT[1] LOG1 RB RB RT RT
+ WB WB WT WT PRCHB PRCHWRB[0] PRCHWRB[1] RPASS[0] RPASS[1]
+ mm16a05_u_hc_cmux2_plus
XMXFF VDDA VDDA VDDP VDDPI VSS VBP VBN BB[2] BB[3] BT[2] BT[3] LOG1 RB RB RT RT
+ WB WB WT WT PRCHB PRCHWRB[2] PRCHWRB[3] RPASS[2] RPASS[3]
+ mm16a05_u_hc_cmux2_plus
.ends

.subckt mm16a05_u_pg_wlstkrw_plus1 VDDA VDDWL VSS VBP VBN LCGTHB LCGTH
MI11 VDDWL VDDWL VDDA VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=300n m=1
MI10 VDDA LCGTH VDDWL VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=345n
+ m=10
M0 VDDA LCGTH VDDWL VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=345n m=20
M1 VDDA VDDWL VDDWL VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=300n m=1
XI15 VDDA VSS VBP VBN LCGTHB LCGTH mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240.0n
+ wp=240.0n
.ends

.subckt mm16a05_u_hdsp_plus_lcenbuf_int VDDA VDDP VDDPI VDDWL VNWP VSS VBP VBN
+ LCGTHB PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+ PRCHWRB[2] PRCHWRB[3] RASSISTB[0] RASSISTB[1] LCGTH PRCHRD[0] PRCHRD[1]
+ PRCHRD[2] PRCHRD[3] PRCHWR[0] PRCHWR[1] PRCHWR[2] PRCHWR[3] PROCOML
+ RASSIST[0] RASSIST[1]
XI22 VDDA VDDWL VSS VBP VBN LCGTHB LCGTH mm16a05_u_pg_wlstkrw_plus1
XI78[0] VDDPI VSS VBP VBN RASSISTB[0] RASSIST[0] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI78[1] VDDPI VSS VBP VBN RASSISTB[1] RASSIST[1] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI6[0] VDDPI VSS VBP VBN PRCHRDB[0] PRCHRD[0] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=750n wp=950n
XI6[1] VDDPI VSS VBP VBN PRCHRDB[1] PRCHRD[1] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=750n wp=950n
XI6[2] VDDPI VSS VBP VBN PRCHRDB[2] PRCHRD[2] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=750n wp=950n
XI6[3] VDDPI VSS VBP VBN PRCHRDB[3] PRCHRD[3] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=750n wp=950n
XI12[0] VDDA VSS VBP VBN PRCHWRB[0] PRCHWR[0] mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1
+ wn=640n wp=500n
XI12[1] VDDA VSS VBP VBN PRCHWRB[1] PRCHWR[1] mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1
+ wn=640n wp=500n
XI12[2] VDDA VSS VBP VBN PRCHWRB[2] PRCHWR[2] mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1
+ wn=640n wp=500n
XI12[3] VDDA VSS VBP VBN PRCHWRB[3] PRCHWR[3] mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1
+ wn=640n wp=500n
.ends

.subckt mm16a05_u_hdsp_plus_lcenbuf_base VDDA VDDP VDDPI VDDWL VSS VBP VBN
+ CKPRCH LCGTHB PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0]
+ PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] RASSISTB[0] RASSISTB[1] CKPRCHB LCGTH
+ PRCHRD[0] PRCHRD[1] PRCHRD[2] PRCHRD[3] PRCHWR[0] PRCHWR[1] PRCHWR[2]
+ PRCHWR[3] RASSIST[0] RASSIST[1]
XI126[0] VDDPI VSS VBP VBN PRCHRD_INT[0] net244[0]
+ mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=350n wp=350n
XI126[1] VDDPI VSS VBP VBN PRCHRD_INT[1] net244[1]
+ mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=350n wp=350n
XI126[2] VDDPI VSS VBP VBN PRCHRD_INT[2] net244[2]
+ mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=350n wp=350n
XI126[3] VDDPI VSS VBP VBN PRCHRD_INT[3] net244[3]
+ mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=350n wp=350n
XI129 VDDPI VSS VBP VBN CKPRCHBB CKPRCHB mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=2 nf_p=2
+ wn=350n wp=700n
XI127[0] VDDPI VSS VBP VBN net244[0] PRCHRD[0] mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=240n
XI127[1] VDDPI VSS VBP VBN net244[1] PRCHRD[1] mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=240n
XI127[2] VDDPI VSS VBP VBN net244[2] PRCHRD[2] mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=240n
XI127[3] VDDPI VSS VBP VBN net244[3] PRCHRD[3] mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=240n
XINV_PRCH VDDPI VSS VBP VBN CKPRCH CKPRCHBB mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=12 m_p=12 nf_n=1 nf_p=1
+ wn=460n wp=300n
Xinv_prckwr[0] VDDA VSS VBP VBN net276[0] PRCHWR[0]
+ mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=500n wp=700n
Xinv_prckwr[1] VDDA VSS VBP VBN net276[1] PRCHWR[1]
+ mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=500n wp=700n
Xinv_prckwr[2] VDDA VSS VBP VBN net276[2] PRCHWR[2]
+ mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=500n wp=700n
Xinv_prckwr[3] VDDA VSS VBP VBN net276[3] PRCHWR[3]
+ mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=500n wp=700n
Xprch VDDA VDDP VDDPI VDDWL VDDP VSS VBP VBN LCGTHB PRCHRDB[0] PRCHRDB[1]
+ PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] RASSISTB[0]
+ RASSISTB[1] LCGTH PRCHRD_INT[0] PRCHRD_INT[1] PRCHRD_INT[2] PRCHRD_INT[3]
+ net276[0] net276[1] net276[2] net276[3] LCGTH RASSIST[0] RASSIST[1]
+ mm16a05_u_hdsp_plus_lcenbuf_int
.ends

.subckt mm16a05_u_hdsp_plus_lcenbuf VDDA VDDP VDDPI VDDWL VSS VBP VBN CKPRCH
+ LCGTHB PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+ PRCHWRB[2] PRCHWRB[3] RASSISTB[0] RASSISTB[1] ARYSD ARYSD_BC1 ARYSD_BC2
+ BOTEDGE PO VBA CKPRCHB LCGTH LOG0 LOG1 PRCHRD[0] PRCHRD[1] PRCHRD[2]
+ PRCHRD[3] PRCHWRH[0] PRCHWRH[1] PRCHWRH[2] PRCHWRH[3] RASSIST[0] RASSIST[1]
Xlcbuf VDDA VDDP VDDPI VDDWL VSS VBP VBN CKPRCH LCGTHB PRCHRDB[0] PRCHRDB[1]
+ PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] RASSISTB[0]
+ RASSISTB[1] CKPRCHB LCGTH PRCHRD[0] PRCHRD[1] PRCHRD[2] PRCHRD[3] PRCHWRH[0]
+ PRCHWRH[1] PRCHWRH[2] PRCHWRH[3] RASSIST[0] RASSIST[1]
+ mm16a05_u_hdsp_plus_lcenbuf_base
XDUMMY0 VSS VBA mm16a05_u_ram6t_corner_hs1prf
.ends

.subckt mm16a05_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=120n wn2=120n wp1=360n wp2=360n
MNA1 X A1 VSS VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 X A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MPA2 net10 A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2
+ w=wp2 m=m_p2
MPA1 X A1 net10 VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
.ends

.subckt mm16a05_u_aoi21_bulk_local_lcen VDD VSS VBP VBN X A1 A2 B
MNA1 X A1 net13 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=300n m=1
MNA2 net13 A2 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=300n m=1
MNB X B VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=200n m=1
MPA2 XP A2 X VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=500n m=1
M4 XP A1 X VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=250n m=1
M0 VDD B XP VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=500n m=1
.ends

.subckt mm16a05_u_hs1prf_cdec_nd3_rd VDDPI VNWP VSS VBP VBN PRCH DECB_CMN A
+ CMUX_CLK LLWE
M31 VDDPI LLWE PRCH VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
M20 VDDPI CMUX_CLK PRCH VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n
+ m=1
M18 VDDPI A PRCH VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
M17 PRCH A DECB_CMN VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=3
.ends

.subckt mm16a05_u_cdec VDDP VDDPI VSS VBP VBN PRCH[0] PRCH[1] PRCH[2] PRCH[3]
+ A[0] A[1] A[2] A[3] CMUX_CLK LLWE
M17 CMN_LLWE LLWE VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=3
M27 CMUX_CLKB CMUX_CLK CMN_LLWE VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=3
XI26 VDDPI VDDP VSS VBP VBN PRCH[0] CMUX_CLKB A[0] CMUX_CLK LLWE
+ mm16a05_u_hs1prf_cdec_nd3_rd
XI25 VDDPI VDDP VSS VBP VBN PRCH[1] CMUX_CLKB A[1] CMUX_CLK LLWE
+ mm16a05_u_hs1prf_cdec_nd3_rd
XI24 VDDPI VDDP VSS VBP VBN PRCH[2] CMUX_CLKB A[2] CMUX_CLK LLWE
+ mm16a05_u_hs1prf_cdec_nd3_rd
XI23 VDDPI VDDP VSS VBP VBN PRCH[3] CMUX_CLKB A[3] CMUX_CLK LLWE
+ mm16a05_u_hs1prf_cdec_nd3_rd
.ends

.subckt mm16a05_u_xpredec_3to8 VDDP VDDPI VSS VBP VBN POUT[0] POUT[1] POUT[2]
+ POUT[3] POUT[4] POUT[5] POUT[6] POUT[7] PD A[0] A[1] A[2]
XI86 VDDPI PD VBP VBN POUT[7] A[0] A[1] A[2]
+ mm16a05_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=640n
+ wn2=640n wn3=640n wp1=240n wp2=240n wp3=240n
XI85 VDDPI PD VBP VBN POUT[6] AB[0] A[1] A[2]
+ mm16a05_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=640n
+ wn2=640n wn3=640n wp1=240n wp2=240n wp3=240n
XI84 VDDPI PD VBP VBN POUT[5] A[0] AB[1] A[2]
+ mm16a05_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=640n
+ wn2=640n wn3=640n wp1=240n wp2=240n wp3=240n
XI95 VDDPI PD VBP VBN POUT[1] A[0] AB[1] AB[2]
+ mm16a05_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=640n
+ wn2=640n wn3=640n wp1=240n wp2=240n wp3=240n
XI96 VDDPI PD VBP VBN POUT[2] AB[0] A[1] AB[2]
+ mm16a05_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=640n
+ wn2=640n wn3=640n wp1=240n wp2=240n wp3=240n
XI94 VDDPI PD VBP VBN POUT[0] AB[0] AB[1] AB[2]
+ mm16a05_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=640n
+ wn2=640n wn3=640n wp1=240n wp2=240n wp3=240n
XI97 VDDPI PD VBP VBN POUT[3] A[0] A[1] AB[2]
+ mm16a05_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=640n
+ wn2=640n wn3=640n wp1=240n wp2=240n wp3=240n
XI60 VDDPI PD VBP VBN POUT[4] AB[0] AB[1] A[2]
+ mm16a05_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=640n
+ wn2=640n wn3=640n wp1=240n wp2=240n wp3=240n
XINV_ADD[0] VDDPI VSS VBP VBN AB[0] A[0] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=160n wp=240n
XINV_ADD[1] VDDPI VSS VBP VBN AB[1] A[1] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=160n wp=240n
XINV_ADD[2] VDDPI VSS VBP VBN AB[2] A[2] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=160n wp=240n
.ends

.subckt mm16a05_u_predec_2to4_bk VDDP VDDPI VSS VBP VBN PMB[0] PMB[1] PMB[2]
+ PMB[3] A[0] A[1]
Xinv_adr[0] VDDPI VSS VBP VBN AB[0] A[0] mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
Xinv_adr[1] VDDPI VSS VBP VBN AB[1] A[1] mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI72 VDDPI VSS VBP VBN PMB[1] AB[1] A[0]
+ mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=120n
+ wp2=120n
XI74 VDDPI VSS VBP VBN PMB[0] AB[1] AB[0]
+ mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=120n
+ wp2=120n
XI71 VDDPI VSS VBP VBN PMB[3] A[0] A[1]
+ mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=120n
+ wp2=120n
XI69 VDDPI VSS VBP VBN PMB[2] AB[0] A[1]
+ mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=120n
+ wp2=120n
.ends

.subckt mm16a05_u_pdec_nr2 VDDA VSS VBP VBN WCLK DECB_CMN CLK_WL XPRB
XI27 VDDA VSS VBP VBN WCLK WCLKB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=10 m_p=10 nf_n=1 nf_p=1 wn=520n
+ wp=225n
M17 WCLKB XPRB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=450n m=1
MI34 WCLKB CLK_WL VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=450n m=2
M31 DECB_CMN XPRB WCLKB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=624n
+ m=3
.ends

.subckt mm16a05_u_predec_2to4_ckb VDDA VSS VBP VBN WCLKB[0] WCLKB[1] WCLKB[2]
+ WCLKB[3] CLK_WLB XPRB[0] XPRB[1] XPRB[2] XPRB[3]
M31 VDDA CLK_WLB DECB_CMN VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=1087n m=4
XI28 VDDA VSS VBP VBN WCLKB[0] DECB_CMN CLK_WLB XPRB[0] mm16a05_u_pdec_nr2
XI27 VDDA VSS VBP VBN WCLKB[3] DECB_CMN CLK_WLB XPRB[3] mm16a05_u_pdec_nr2
XI26 VDDA VSS VBP VBN WCLKB[2] DECB_CMN CLK_WLB XPRB[2] mm16a05_u_pdec_nr2
XI25 VDDA VSS VBP VBN WCLKB[1] DECB_CMN CLK_WLB XPRB[1] mm16a05_u_pdec_nr2
.ends

.subckt mm16a05_u_xpred VDDA VDDP VDDPI VSS VBP VBN PBB[0] PBB[1] PBB[2] PBB[3]
+ PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6]
+ PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] LOG1 XPRBH[0] XPRBH[1] XPRBH[2]
+ XPRBH[3] XPRBL[0] XPRBL[1] XPRBL[2] XPRBL[3] CLK_WLB LDFTX LMATCHB XADR[0]
+ XADR[1] XADR[2] XADR[3] XADR[4] XADR[5] XADR[6] XADR[7]
XI62 VDDP VDDPI VSS VBP VBN PC[0] PC[1] PC[2] PC[3] PC[4] PC[5] PC[6] PC[7] VSS
+ XADR[5] XADR[6] XADR[7] mm16a05_u_xpredec_3to8
XI61 VDDP VDDPI VSS VBP VBN PB[0] PB[1] PB[2] PB[3] PB[4] PB[5] PB[6] PB[7]
+ net134 XADR[2] XADR[3] XADR[4] mm16a05_u_xpredec_3to8
XI63[0] VDDPI VSS VBP VBN PCB[0] PC[0] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=320n
XI63[1] VDDPI VSS VBP VBN PCB[1] PC[1] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=320n
XI63[2] VDDPI VSS VBP VBN PCB[2] PC[2] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=320n
XI63[3] VDDPI VSS VBP VBN PCB[3] PC[3] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=320n
XI63[4] VDDPI VSS VBP VBN PCB[4] PC[4] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=320n
XI63[5] VDDPI VSS VBP VBN PCB[5] PC[5] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=320n
XI63[6] VDDPI VSS VBP VBN PCB[6] PC[6] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=320n
XI63[7] VDDPI VSS VBP VBN PCB[7] PC[7] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=320n
XI59[0] VDDPI VSS VBP VBN PBB[0] PB[0] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=500n
+ wp=640n
XI59[1] VDDPI VSS VBP VBN PBB[1] PB[1] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=500n
+ wp=640n
XI59[2] VDDPI VSS VBP VBN PBB[2] PB[2] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=500n
+ wp=640n
XI59[3] VDDPI VSS VBP VBN PBB[3] PB[3] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=500n
+ wp=640n
XI59[4] VDDPI VSS VBP VBN PBB[4] PB[4] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=500n
+ wp=640n
XI59[5] VDDPI VSS VBP VBN PBB[5] PB[5] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=500n
+ wp=640n
XI59[6] VDDPI VSS VBP VBN PBB[6] PB[6] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=500n
+ wp=640n
XI59[7] VDDPI VSS VBP VBN PBB[7] PB[7] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=500n
+ wp=640n
MI64 net134 LMATCHB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=640n
+ m=2
XI53 VDDP VDDPI VSS VBP VBN XPRBL[0] XPRBL[1] XPRBL[2] XPRBL[3] XADR[0] XADR[1]
+ mm16a05_u_predec_2to4_bk
XI52 VDDA VSS VBP VBN WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] CLK_WLB XPRBH[0]
+ XPRBH[1] XPRBH[2] XPRBH[3] mm16a05_u_predec_2to4_ckb
MI60[0] VDDPI LMATCHB PB[0] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=620n m=1
MI60[1] VDDPI LMATCHB PB[1] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=620n m=1
MI60[2] VDDPI LMATCHB PB[2] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=620n m=1
MI60[3] VDDPI LMATCHB PB[3] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=620n m=1
MI60[4] VDDPI LMATCHB PB[4] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=620n m=1
MI60[5] VDDPI LMATCHB PB[5] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=620n m=1
MI60[6] VDDPI LMATCHB PB[6] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=620n m=1
MI60[7] VDDPI LMATCHB PB[7] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=620n m=1
.ends

.subckt mm16a05_u_cen_delay VDDP VDDPI VSS VBP VBN DLY_4 IN
XI12 VDDPI VSS VBP VBN net99 IN mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI31 VDDPI VSS VBP VBN net101 net106 mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI22 VDDPI VSS VBP VBN net106 net99 mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI30 VDDPI VSS VBP VBN DLY_4 net101 mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
.ends

.subckt mm16a05_u_hd1p_cdec_nd3_wr VDDPI VNWP VSS VBP VBN PRCH DECB_CMN A
+ CMUX_CLK LLWE
M31 VDDPI LLWE PRCH VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
M20 VDDPI CMUX_CLK PRCH VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n
+ m=1
M18 VDDPI A PRCH VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
M17 PRCH A DECB_CMN VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=3
.ends

.subckt mm16a05_u_hdsp_cdec_wr VDDP VDDPI VSS VBP VBN PRCH[0] PRCH[1] PRCH[2]
+ PRCH[3] A[0] A[1] A[2] A[3] CMUX_CLK LLWE
XI26 VDDPI VDDP VSS VBP VBN PRCH[0] CMUX_CLKB A[0] CMUX_CLK LLWE
+ mm16a05_u_hd1p_cdec_nd3_wr
XI25 VDDPI VDDP VSS VBP VBN PRCH[1] CMUX_CLKB A[1] CMUX_CLK LLWE
+ mm16a05_u_hd1p_cdec_nd3_wr
XI24 VDDPI VDDP VSS VBP VBN PRCH[2] CMUX_CLKB A[2] CMUX_CLK LLWE
+ mm16a05_u_hd1p_cdec_nd3_wr
XI23 VDDPI VDDP VSS VBP VBN PRCH[3] CMUX_CLKB A[3] CMUX_CLK LLWE
+ mm16a05_u_hd1p_cdec_nd3_wr
M17 CMN_LLWE LLWE VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=3
M27 CMUX_CLKB CMUX_CLK CMN_LLWE VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=3
.ends

.subckt mm16a05_u_hdsp_plus_lcen VDDA VDDMINB VDDP VDDPI VSS VSSC_WL_L
+ VSSC_WL_R VBP VBN CKPRCHB LMATCH PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5]
+ PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7]
+ PRCHRD[0] PRCHRD[1] PRCHRD[2] PRCHRD[3] PRCHWR[0] PRCHWR[1] PRCHWR[2]
+ PRCHWR[3] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] BYP_VLOAD CENDP CLK_WLBH
+ CLK_WLBL DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LDFTX LITESLP
+ LOG0 LOG1 LWEIB LWERD LWEWR PRCHWRH[0] PRCHWRH[1] PRCHWRH[2] PRCHWRH[3] RBLRD
+ RBLWA RBLWR RWLB_SAC WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3]
+ WPBUF[0] WPBUF[1] WPBUF[2] XPRBH[0] XPRBH[1] XPRBH[2] XPRBH[3] XPRBL[0]
+ XPRBL[1] XPRBL[2] XPRBL[3] LBKADR[0] LBKADR[1] LBKADR[2] LCGTHB LCGTH_PCHG
+ LMATCHB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6]
+ LXADR[7] LYADR[0] LYADR[1] PM[0] PM[1] PM[2] PM[3] PRCKE RM3CNT RMT[0] RMT[1]
+ RMT[2] RMT[3] T1T TEST_RNMB
XI145 VDDPI VSS VBP VBN TEST_RNM TEST_RNMB mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI153 VDDP VSS VBP VBN CLK_WLBL CLK_WL mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=730n
+ wp=300n
XI162 VDDPI VSS VBP VBN LDFTXB LDFTX mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI135 VDDPI VSS VBP VBN LMATCH LMATCHB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI166 VDDPI VSS VBP VBN PRCKEB PRCKE mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI149 VDDPI VSS VBP VBN PRCKE_RNMB PRCKE_RNM mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=240n wp=120n
XI147 VDDPI VSS VBP VBN PRCKE_RNM PRCKE TEST_RNM
+ mm16a05_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=600n wn2=600n wp1=900n
+ wp2=900n
XI160 VDDPI VSS VBP VBN CLK_WL net246 FLOAT
+ mm16a05_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=720n
+ wp2=720n
XI150 VDDPI VSS VBP VBN PRCLK PRCKE_RNMB FLOAT
+ mm16a05_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=640n
+ wp2=640n
XI139 VDDPI VSS VBP VBN PRCK_FLT net247 FLOAT PRCKE
+ mm16a05_u_aoi21_bulk_local_lcen
XI152 VDDP VDDPI VSS VBP VBN PRCHRD[0] PRCHRD[1] PRCHRD[2] PRCHRD[3] PM[0]
+ PM[1] PM[2] PM[3] PRCLK LWERD mm16a05_u_cdec
MI188 VSSC_WL_L LCGTHB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=480.0n m=2
MI187 VSSC_WL_R LCGTHB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=480.0n m=2
Mndmy2 CKPRCHB LCGTH_PCHG VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=1
Xpredec VDDA VDDP VDDPI VSS VBP VBN PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5]
+ PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7]
+ WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] LOG1 XPRBH[0] XPRBH[1] XPRBH[2] XPRBH[3]
+ XPRBL[0] XPRBL[1] XPRBL[2] XPRBL[3] CLK_WLBH LDFTX LMATCHB LXADR[0] LXADR[1]
+ LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] mm16a05_u_xpred
XI141 VDDP VDDPI VSS VBP VBN net247 FLOAT mm16a05_u_cen_delay
XI151 VDDP VDDP VSS VBP VBN PRCHWR[0] PRCHWR[1] PRCHWR[2] PRCHWR[3] PM[0] PM[1]
+ PM[2] PM[3] PRCLK LWEWR mm16a05_u_hdsp_cdec_wr
XI146 net244 VSS VBP VBN CKPRCHB PRCK_FLT PRCKE_RNM
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=8 m_n2=8
+ m_p1=4 m_p2=4 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=200n wn2=200n wp1=150n
+ wp2=150n
XI161 VDDPI VSS VBP VBN net246 PRCKEB LDFTXB
+ mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=120n
+ wp2=120n
Mpdmy2 VDDPI LCGTH_PCHG net244 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=430n m=3
.ends

.subckt mm16a05_u_hdsp_plus_capsac_wa VDDP VDDPI VSS VBP VBN LOG0 LOG1 PWDO
+ VEDGE WAPRCLKBUF WAPRCLKBUFB_RET
XIWR_RETURN VDDPI VSS VBP VBN WAPRCLKBUFB_RET WAPRCLKBUF
+ mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=16 m_p=16 nf_n=1 nf_p=1 wn=120n wp=120n
.ends

.subckt mm16a05_u_WA_CAP_NMOSPD_RPB256 VSS VSS_WA VBP VBN CC_0 CC_1 PRCHBWA
MI232 CC_0 VSS_WA CC_0 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=800n
+ m=10
MI233 CC_1 VSS_WA CC_1 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=1200n
+ m=10
MI230 VSS_WA PRCHBWA VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=450n
+ m=9
.ends

.subckt mm16a05_u_WA_CELL_RPB256_CM4 VDDP VDDPI VSS VSS_WA VBP VBN WA[0] WA[1]
+ WAPRCLK
XI81 VDDPI VSS VBP VBN PRCHB_WA WAPRCLK mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI80 VDDPI VSS VBP VBN net599 PRCHB_WA mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=160.0n
+ wp=160n
XI78 VDDPI VSS VBP VBN CC_1 net599 WA[1]
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=400n wn2=400n wp1=160n
+ wp2=160n
XI79 VDDPI VSS VBP VBN CC_0 net599 WA[0]
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=533n wn2=533n wp1=160n
+ wp2=160n
XI76 VSS VSS_WA VBP VBN CC_0 CC_1 PRCHB_WA mm16a05_u_WA_CAP_NMOSPD_RPB256
.ends

.subckt mm16a05_u_hdsp_plus_hs_sacm4x1_wa_256 VDDP VDDPI VSS VSS_WA VBP VBN QB
+ QT RB RT SEL WA[0] WA[1] WAPRCLKBUF WAPRCLKBUFB_RET WB WB_IN WT WT_IN
XSFF_WA VDDP VDDPI VSS VSS_WA VBP VBN WA[0] WA[1] WAPRCLKBUF_INT
+ mm16a05_u_WA_CELL_RPB256_CM4
XI204 VDDPI VSS VBP VBN WAPRCLKBUFB_INT WAPRCLKBUF SEL
+ mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI219 VDDPI VSS VBP VBN WAPRCLKBUF_INT WAPRCLKBUFB_INT
+ mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
.ends

.subckt mm16a05_u_hdsp_plus_sacbuf_wa VDDA VDDP VDDPI VSS VBP VBN WA[0] WA[1]
+ WAPRCLKBUF ARYSD ARYSD_BC1 ARYSD_BC2 LCGTH RASSIST[0] RASSIST[1]
+ WAPRCLKBUFB_RET WAB[0] WAB[1] WAPRCLK
XI119[0] VDDPI VSS VBP VBN WAB_INT[0] WAB[0] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=160n wp=160n
XI119[1] VDDPI VSS VBP VBN WAB_INT[1] WAB[1] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=160n wp=160n
XIWA_DR[0] VDDPI VSS VBP VBN WA[0] WAB_INT[0] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=320n wp=320n
XIWA_DR[1] VDDPI VSS VBP VBN WA[1] WAB_INT[1] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=320n wp=320n
XIWAPRCLK_DR VDDPI VSS VBP VBN WAPRCLKBUF WAPRCLK
+ mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=8 m_p=8 nf_n=1 nf_p=1 wn=253n wp=320n
.ends

.subckt mm16a05_u_hdsp_WACLK_PG_DELAY VDDP VDDPI VSS VBP VBN TAP1 TAP2 TAP3
+ LOG0 LOG1 TAP0
XITAP2_DR1 VDDPI VSS VBP VBN net214 TAP1 TAP1 TAP1
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XITAP3_DR2 VDDPI VSS VBP VBN TAP3 net221 net221 net221
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XITAP1_DR1 VDDPI VSS VBP VBN net213 TAP0 TAP0 TAP0
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XITAP3_DR1 VDDPI VSS VBP VBN net221 TAP2 TAP2 TAP2
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XITAP_DR2 VDDPI VSS VBP VBN TAP1 net213 net213 net213
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XITAP2_DR2 VDDPI VSS VBP VBN TAP2 net214 net214 net214
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
.ends

.subckt mm16a05_u_tg_bulk_n_vt3_p_vt3 VBP VBN A B S SB CPP=104n P_LA_n=4n
+ P_LA_p=4n ULP=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=320n wp=320n
MNS A S B VBN slvtnfet cpp=cpp p_la=p_la_n ulp=ulp nf=nf_n l=ln w=wn m=m_n
MPSB A SB B VBP slvtpfet cpp=cpp p_la=p_la_p ulp=ulp nf=nf_p l=lp w=wp m=m_p
.ends

.subckt mm16a05_u_WACLK_DELAY VDDP VDDPI VSS VBP VBN WAPRCLK_OUT WAPRCLK_IN
+ WPBUFB[0] WPBUFB[1]
XI10_NAND VDDPI VSS VBP VBN CB WPBUFB[0] WP[1]
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI00_NAND VDDPI VSS VBP VBN AB WPBUFB[0] WPBUFB[1]
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI11_NAND VDDPI VSS VBP VBN DB WP[0] WP[1]
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI01_NAND VDDPI VSS VBP VBN BB WP[0] WPBUFB[1]
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XIWP_INV[0] VDDPI VSS VBP VBN WP[0] WPBUFB[0] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XIWP_INV[1] VDDPI VSS VBP VBN WP[1] WPBUFB[1] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI11_DR1 VDDPI VSS VBP VBN net76 net77 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI11_DR2 VDDPI VSS VBP VBN net74 net76 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI10_DR1 VDDPI VSS VBP VBN net72 net73 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI01_DR1 VDDPI VSS VBP VBN net68 WAPRCLK_IN mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI01_DR2 VDDPI VSS VBP VBN net73 net68 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI10_DR2 VDDPI VSS VBP VBN net77 net72 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI01_INV VDDPI VSS VBP VBN B BB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI10_INV VDDPI VSS VBP VBN C CB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI11_INV VDDPI VSS VBP VBN D DB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI00_INV VDDPI VSS VBP VBN A AB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI11_TR VBP VBN net74 WAPRCLK_OUT D DB mm16a05_u_tg_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI10_TR VBP VBN net77 WAPRCLK_OUT C CB mm16a05_u_tg_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI01_TR VBP VBN net73 WAPRCLK_OUT B BB mm16a05_u_tg_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI00_TR VBP VBN WAPRCLK_IN WAPRCLK_OUT A AB mm16a05_u_tg_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=120n wp=120n
.ends

.subckt mm16a05_u_nd2_bulk_n1_vt4_n2_vt4_p1_vt4_p2_vt4 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=600n wn2=600n wp1=450n wp2=450n
MPA2 X A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
MPA1 X A1 VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MNA1 X A1 net22 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 net22 A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2
+ w=wn2 m=m_n2
.ends

.subckt mm16a05_u_nr3_bulk_n1_vt4_n2_vt4_n3_vt4_p1_vt4_p2_vt4_p3_vt4 VDD VSS
+ VBP VBN X A1 A2 A3 CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_n3=4n P_LA_p1=4n
+ P_LA_p2=4n P_LA_p3=4n ULP=0 ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n
+ m_n1=1 m_n2=1 m_n3=1 m_p1=1 m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1
+ nf_p2=1 nf_p3=1 wn1=120n wn2=120n wn3=120n wp1=240n wp2=240n wp3=240n
MNA1 X A1 VSS VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA3 X A3 VSS VBN slvtnfet cpp=cpp p_la=p_la_n3 ulp=ulp nf=nf_n3 l=ln3 w=wn3
+ m=m_n3
MNA2 X A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MPA3 net10 A3 VDD VBP slvtpfet cpp=cpp p_la=p_la_p3 ulp=ulp nf=nf_p3 l=lp3
+ w=wp3 m=m_p3
MPA2 net029 A2 net10 VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2
+ w=wp2 m=m_p2
MPA1 X A1 net029 VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
.ends

.subckt mm16a05_u_hdsp_plus_wa_cntrl VDDP VDDPI VSS VBP VBN TAP0 TAP1 TAP2 TAP3
+ WAPRCLK LOG0 LOG1 RBLWA TEST_RNMB WABUF[2] WPBUF[0] WPBUF[1] WPBUF[2]
+ FLOAT_RET LWEIB PRCKDLY
XI41 VDDP VDDPI VSS VBP VBN TAP1 TAP2 TAP3 LOG0 LOG1 TAP0
+ mm16a05_u_hdsp_WACLK_PG_DELAY
XI47 VDDP VDDPI VSS VBP VBN PRCKDLY_INT PRCKDLY WPBUF[0] WPBUF[1]
+ mm16a05_u_WACLK_DELAY
XI77 VDDPI VSS VBP VBN WAPRCLK TAP0 PRCKDLY_INT
+ mm16a05_u_nd2_bulk_n1_vt4_n2_vt4_p1_vt4_p2_vt4 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=4 m_n2=4
+ m_p1=4 m_p2=4 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=120n
+ wp2=120n
XI64 VDDPI VSS VBP VBN net187 net188 WABUF[2] LWEIB
+ mm16a05_u_nr3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=120n
+ wn2=120n wn3=120n wp1=480n wp2=480n wp3=480n
XI92 VDDPI VSS VBP VBN TAP0 RBLWA net312 FLOAT_RET
+ mm16a05_u_nr3_bulk_n1_vt4_n2_vt4_n3_vt4_p1_vt4_p2_vt4_p3_vt4 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=120n
+ wn2=120n wn3=120n wp1=600n wp2=600n wp3=600n
XI65 VDDPI VSS VBP VBN net188 TEST_RNMB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI63 VDDPI VSS VBP VBN net312 net187 mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
.ends

.subckt mm16a05_u_hdsp_plus_sactrl_wa VDDA VDDMINB VDDP VDDPI VSS VBP VBN TAP0
+ TAP1 TAP2 TAP3 WAPRCLK DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOAT_RET
+ LBKADR[0] LBKADR[1] LBKADR[2] LCGTH_PCHG LMATCHB LOG0 LOG1 LWERD LWEWR PM[0]
+ PM[1] PM[2] PM[3] PRCKE RBLWA RM3CNT TEST_RNMB WABUF[0] WABUF[1] WABUF[2]
+ WAPRCLKBUFB_RET WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] CENDP
+ FLOATT LDFTX LITESLP LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+ LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PRCKDLY RMT[0] RMT[1] RMT[2]
+ RMT[3] T1T
XWACTRL VDDP VDDPI VSS VBP VBN TAP0 TAP1 TAP2 TAP3 WAPRCLK LOG0 LOG1 RBLWA
+ TEST_RNMB WABUF[2] WPBUF[0] WPBUF[1] WPBUF[2] FLOAT_RET LWEIB PRCKDLY
+ mm16a05_u_hdsp_plus_wa_cntrl
XITAP3_DR1 VDDPI VSS VBP VBN net440 net442 net442 net442
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XITAP2_DR2 VDDPI VSS VBP VBN net442 net441 net441 net441
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XI237 VDDPI VSS VBP VBN net448 net445 net445 net445
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XITAP3_DR2 VDDPI VSS VBP VBN net446 net440 net440 net440
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XITAP2_DR1 VDDPI VSS VBP VBN net441 LOG0 LOG0 LOG0
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XI236 VDDPI VSS VBP VBN net445 net446 net446 net446
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
.ends

.subckt mm16a05_u_hdsp_plus_capsac VDDP VDDPI VSS VBP VBN SAED LOG0 LOG1 PWDO
+ VEDGE SAEB
MI18 VDDPI SAEB SAED VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120.0n
+ m=17
MI21 SAED SAEB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120.0n m=7
.ends

.subckt mm16a05_u_wrdrv VDDP VDDPI VSS VSS_WA VBP VBN WB WT RB RT WB_IN WT_IN
XWB VDDPI VSS_WA VBP VBN WB WB_IN mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=360n
+ wp=240n
XWT VDDPI VSS_WA VBP VBN WT WT_IN mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=360n
+ wp=240n
.ends

.subckt mm16a05_u_blatch_scan VDDP VDDPI VSS VBP VBN OUT OUTB CB CT IN
XI2 VDDPI VSS VBP VBN OUT OUTB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
*XI8 VBP VBN OUTB mm16a05_u_init1
XI0 VDDPI VSS VBP VBN OUTB IN CB CT
+ mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XI1 VDDPI VSS VBP VBN OUTB OUT CT CB
+ mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
.ends

.subckt mm16a05_u_lsa_gf22_hd1p VDDP VDDPI VSS VBP VBN XB XT LOG0 LOG1 RB RT
+ SAEN SAEP SAPR
M7_OFF XT LOG0 net60 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=780n m=1
M6_OFF XB LOG0 net60 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=780n m=1
M9 net60 SAEN VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=800n m=2
M7 XT XB net60 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n w=780n m=6
M6 XB XT net60 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n w=780n m=6
M2_OFF XB LOG1 XT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=375.0n m=1
M4 XT SAEP RT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=375n m=2
M3 XB SAEP RB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=375n m=2
M2 XB SAPR XT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=375.0n m=1
M0 VDDPI SAPR XB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=140n m=2
M1 VDDPI SAPR XT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=140n m=2
M5 VDDPI XT XB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=375n m=2
M11 VDDPI XB XT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=375n m=2
.ends

.subckt mm16a05_u_sac_st_base_plus VDDP VDDPI VSS VBP VBN LOG0 LOG1 RB RT XB XT
+ SAEB SAPRB SEL
XSAEB VDDPI VSS VBP VBN SAEBAR SAET LSEL
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=2 nf_p2=2 wn1=220n wn2=220n wp1=260n
+ wp2=260n
XSAPR VDDPI VSS VBP VBN SAPR SAPRB SAEBAR
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=130n
+ wp2=130n
XLSEL VDDP VDDPI VSS VBP VBN LSEL net45 CKSAEB CKSAET SEL mm16a05_u_blatch_scan
XSAE VDDPI VSS VBP VBN SAE SAEBAR mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=150n
+ wp=260n
XCKSAEB VDDPI VSS VBP VBN CKSAEB SAET mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XSAET VDDPI VSS VBP VBN SAET SAEB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=130n
+ wp=260n
XCKSAET VDDPI VSS VBP VBN CKSAET CKSAEB mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XLSA VDDP VDDPI VSS VBP VBN XB XT LOG0 LOG1 RB RT SAE SAE SAPR
+ mm16a05_u_lsa_gf22_hd1p
M0 VDDPI LSEL XB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=140n m=1
M1 VDDPI LSEL XT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=140n m=1
.ends

.subckt mm16a05_u_sac_base_nor VDDP VDDPI VSS VBP VBN QBOUT QTOUT LOG0 QB_IN
+ QB_NORIN QT_IN QT_NORIN XB XT
XI73 VDDPI VSS VBP VBN QTOUT QT_NORIN QBI
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=3 m_n2=3
+ m_p1=3 m_p2=3 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=480n wn2=480n wp1=214n
+ wp2=214n
XI78 VDDPI VSS VBP VBN QBOUT QTI QB_NORIN
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=3 m_n2=3
+ m_p1=3 m_p2=3 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=480n wn2=480n wp1=214n
+ wp2=214n
XI76 VDDPI VSS VBP VBN QTI XB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=460n wp=234n
XSAE VDDPI VSS VBP VBN QBI XT mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=460n wp=234n
.ends

.subckt mm16a05_u_sac_nor_plus VDDP VDDPI VSS VSS_WA VBP VBN QBOUT QTOUT LOG0
+ LOG1 RB RT WB WT QB_IN QB_NORIN QT_IN QT_NORIN SAEB SAPRB SEL WB_IN WT_IN
XW VDDP VDDPI VSS VSS_WA VBP VBN WB WT RB RT WB_IN WT_IN mm16a05_u_wrdrv
XS VDDP VDDPI VSS VBP VBN LOG0 LOG1 RB RT XB XT SAEB SAPRB SEL
+ mm16a05_u_sac_st_base_plus
XI27 VDDP VDDPI VSS VBP VBN QBOUT QTOUT LOG0 QB_IN QB_NORIN QT_IN QT_NORIN XB
+ XT mm16a05_u_sac_base_nor
.ends

.subckt mm16a05_u_hdsp_plus_sacm4x1_nor VDDP VDDPI VSS VSS_WA VBP VBN QBOUT
+ QTOUT BYPASS BYPASS_RET LCGTH LOG0 LOG1 RASSISTT[0] RASSISTT[1] RB RT SAED WB
+ WB_IN WT WT_IN QB_IN QB_NORIN QT_IN QT_NORIN SAEB SAPRB SEL
XSFF VDDP VDDPI VSS VSS_WA VBP VBN QBOUT QTOUT LOG0 LOG1 RB RT WB WT QB_IN
+ QB_NORIN QT_IN QT_NORIN SAEB SAPRB SEL WB_IN WT_IN mm16a05_u_sac_nor_plus
.ends

.subckt mm16a05_u_hdsp_plus_sacbuf VDDA VDDP VDDPI VSS VBP VBN LCGTH SAEB SAPRB
+ ARYSD ARYSD_BC1 ARYSD_BC2 BYPASS BYPASS_RET LOG0 LOG1 RASSIST[0] RASSIST[1]
+ RASSISTT[0] RASSISTT[1] SAED LCGTHB LCGTHB_IN LCGTHHV SAET SAPRT
XI78[0] VDDPI VSS VBP VBN RASSISTT[0] RASSISTB[0]
+ mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=320n wp=320n
XI78[1] VDDPI VSS VBP VBN RASSISTT[1] RASSISTB[1]
+ mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=320n wp=320n
XI77[0] VDDPI VSS VBP VBN RASSISTB[0] RASSIST[0] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI77[1] VDDPI VSS VBP VBN RASSISTB[1] RASSIST[1] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=240n
XLCGTHB VDDA VSS VBP VBN LCGTH LCGTHB_IN mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=280n wp=335n
XI57 VDDPI VSS VBP VBN SAPRB SAPRT mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=8 m_p=8 nf_n=1 nf_p=1 wn=400n
+ wp=350n
MI2 VDDPI SAET SAEB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=300n m=10
MI1 SAEB SAET VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=400n m=10
.ends

.subckt mm16a05_u_inv_bulk_n_vt4_p_vt4 VDD VSS VBP VBN X A CPP=104n P_LA_n=4n
+ P_LA_p=4n ULP=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=758n wp=1092n
MNA X A VSS VBN slvtnfet cpp=cpp p_la=p_la_n ulp=ulp nf=nf_n l=ln w=wn m=m_n
MPA X A VDD VBP slvtpfet cpp=cpp p_la=p_la_p ulp=ulp nf=nf_p l=lp w=wp m=m_p
.ends

.subckt mm16a05_u_complex_nor_prclk_vt4_plus VDDP VSS VBP VBN OUT PULLUP BK
+ LMATCH LMATCHB
M36 net137 LMATCHB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
M37 OUT BK net137 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
MI72 OUT LMATCH net137 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
MI68 net127 BK OUT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
MI75 PULLUP LMATCHB OUT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
MI74 PULLUP LMATCH net127 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
.ends

.subckt mm16a05_u_bk_sel_dft_prclk_vt4_plus VDDP VDDPI VSS VBP VBN PRCKE_B
+ PRCKE_T LMATCH LMATCHB_I_BBK LMATCHB_I_TBK LOG1 BBKB LMATCHB TBKB
XPRCLKB VDDP VSS VBP VBN net106 VDDPI BBKB LMATCH LMATCHB_I_BBK
+ mm16a05_u_complex_nor_prclk_vt4_plus
XPRCLKT VDDP VSS VBP VBN net105 VDDPI TBKB LMATCH LMATCHB_I_TBK
+ mm16a05_u_complex_nor_prclk_vt4_plus
XI50 VDDPI VSS VBP VBN PRCKE_T net105 mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI54 VDDPI VSS VBP VBN PRCKE_B net106 mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=240n
+ wp=240n
.ends

.subckt mm16a05_u_hdsp_mux_2x1_hd VDDP VDDPI VSS VBP VBN OUT 0_1 1 SEL
XI34 VDDPI VSS VBP VBN SELB SEL mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI35 VBP VBN 1 OUT SEL SELB mm16a05_u_tg_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=300n wp=300n
XI29 VBP VBN 0_1 OUT SELB SEL mm16a05_u_tg_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=300n wp=300n
.ends

.subckt mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt4_p2_vt4 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=600n wn2=600n wp1=450n wp2=450n
MPA2 X A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
MPA1 X A1 VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MNA1 X A1 net22 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 net22 A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2
+ w=wn2 m=m_n2
.ends

.subckt mm16a05_u_nr2_bulk_n1_vt4_n2_vt4_p1_vt4_p2_vt4 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=120n wn2=120n wp1=360n wp2=360n
MNA1 X A1 VSS VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 X A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MPA2 net10 A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2
+ w=wp2 m=m_p2
MPA1 X A1 net10 VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
.ends

.subckt mm16a05_u_tinv_bulk_n1_vt4_n2_vt4_p1_vt4_p2_vt4 VDD VSS VBP VBN X A S0
+ S1 CPP=104n P_LA_n1=0 P_LA_n2=0 P_LA_p1=0 P_LA_p2=0 ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=240n wn2=240n wp1=960n wp2=960n
MNA net020 S0 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2
+ w=wn2 m=m_n2
MNS0 X A net020 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MPA net16 S1 VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MPS1 X A net16 VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
.ends

.subckt mm16a05_u_tg_bulk_n_vt4_p_vt4 VBP VBN A B S SB CPP=104n P_LA_n=4n
+ P_LA_p=4n ULP=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=320n wp=320n
MNS A S B VBN slvtnfet cpp=cpp p_la=p_la_n ulp=ulp nf=nf_n l=ln w=wn m=m_n
MPSB A SB B VBP slvtpfet cpp=cpp p_la=p_la_p ulp=ulp nf=nf_p l=lp w=wp m=m_p
.ends

.subckt mm16a05_u_hdsp_plus_timer_sactrl VDDP VDDPI VSS VBP VBN FAST1B STCLK
+ DEF FLOAT_RETB FLOAT_RET_TIMER_PROG FT1 FT2 REFBP REFST RMT3
XI119 VDDPI VSS VBP VBN STCLK FLOAT_RETB sactrl_rblwr_wa
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt4_p2_vt4 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=6 m_n2=6
+ m_p1=6 m_p2=6 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=120n
+ wp2=120n
XI137 VDDPI VSS VBP VBN FAST2 FAST1B FLOAT_RET_TIMER_PROG
+ mm16a05_u_nr2_bulk_n1_vt4_n2_vt4_p1_vt4_p2_vt4 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=0 p_la_p2=0 ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=130n
+ wp2=130n
MI99_P VDDPI net355 DEFAULT VBP slvtpfet cpp=104n p_la=0 ulp=0 nf=1 l=20n
+ w=160n m=4
MI98_2P VDDPI FAST1 FAST1B VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=1
XI123 VDDPI VSS VBP VBN FAST1 REFST RMT3B RMT3
+ mm16a05_u_tinv_bulk_n1_vt4_n2_vt4_p1_vt4_p2_vt4 cpp=104n p_la_n1=0 p_la_n2=0
+ p_la_p1=0 p_la_p2=0 ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=960n
+ wp2=960n
XI124 VDDPI VSS VBP VBN FAST1 REFBP RMT3 RMT3B
+ mm16a05_u_tinv_bulk_n1_vt4_n2_vt4_p1_vt4_p2_vt4 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n
+ wp1=960n wp2=960n
MI99_N DEFAULT net355 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n
+ m=2
MI98_2N FAST1B FAST1 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=2
XI127 VDDPI VSS VBP VBN RMT3B RMT3 mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI98 VDDPI VSS VBP VBN net355 FAST2 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI102 VDDPI VSS VBP VBN net211 DEF mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI105 VDDPI VSS VBP VBN net225 FT2 mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI104 VDDPI VSS VBP VBN net233 FT1 mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI103 VBP VBN FAST2 sactrl_rblwr_wa FT1 net233 mm16a05_u_tg_bulk_n_vt4_p_vt4
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI94 VBP VBN DEFAULT sactrl_rblwr_wa DEF net211 mm16a05_u_tg_bulk_n_vt4_p_vt4
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI106 VBP VBN FAST1 sactrl_rblwr_wa FT2 net225 mm16a05_u_tg_bulk_n_vt4_p_vt4
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=240n wp=240n
.ends

.subckt mm16a05_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt2_p2_vt2 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=120n wn2=120n wp1=360n wp2=360n
MNA1 X A1 VSS VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 X A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MPA2 net10 A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2
+ w=wp2 m=m_p2
MPA1 X A1 net10 VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
.ends

.subckt mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt3_p2_vt3 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=120n wn2=120n wp1=360n wp2=360n
MNA1 X A1 VSS VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 X A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MPA2 net10 A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2
+ w=wp2 m=m_p2
MPA1 X A1 net10 VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
.ends

.subckt mm16a05_u_mux_2x1_hdsp VDDP VDDPI VSS VBP VBN OUT 0_1 1 SEL
XI34 VDDPI VSS VBP VBN SELB SEL mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI35 VBP VBN 1 OUT SEL SELB mm16a05_u_tg_bulk_n_vt4_p_vt4 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
XI29 VBP VBN 0_1 OUT SELB SEL mm16a05_u_tg_bulk_n_vt4_p_vt4 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
.ends

.subckt mm16a05_u_inv_bulk_n_vt2_p_vt3 VDD VSS VBP VBN X A CPP=104n P_LA_n=4n
+ P_LA_p=4n ULP=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=758n wp=1092n
MNA X A VSS VBN slvtnfet cpp=cpp p_la=p_la_n ulp=ulp nf=nf_n l=ln w=wn m=m_n
MPA X A VDD VBP slvtpfet cpp=cpp p_la=p_la_p ulp=ulp nf=nf_p l=lp w=wp m=m_p
.ends

.subckt mm16a05_u_float_selftimed_wa_hdsp_plus VDDA VDDP VDDPI VSS VBP VBN
+ FAST1B FLOAT_RET FLTRET_1INV FLTRET_3INV RWLB RWLBLV STCLK DEF FLOAT FT1 FT2
+ RMT[2] RMT[3] WABUFB WAPRCLKBUFB_RET BKSA_T1TB FLOAT_RET_TIMER_PROG FLTRET
+ LWEIB RBL RWLBHV STCLK_RST_PGM TRNM
XTIMER VDDP VDDPI VSS VBP VBN FAST1B STCLK DEF float_retb_wa
+ FLOAT_RET_TIMER_PROG FT1 FT2 net280 RBL RMT[3]
+ mm16a05_u_hdsp_plus_timer_sactrl
XI55 VDDPI VSS VBP VBN net358 BKSA_T1TB FLOAT
+ mm16a05_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=360n wn2=360n wp1=200.0n
+ wp2=200.0n
XI54 VDDPI VSS VBP VBN net350 BKSA_T1TB FLOAT
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=24n ln2=24n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=720n
+ wp2=720n
XMUX VDDP VDDPI VSS VBP VBN net280 net205 RWLB RMT[2] mm16a05_u_mux_2x1_hdsp
MI53 VDDPI WAPRCLKBUFB_RET float_retb_wa VBP slvtpfet cpp=104n p_la=4n ulp=0
+ nf=1 l=20n w=240n m=1
MI67 FLOAT STCLK VDDP VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=570n
+ m=10
MI52 VDDPI net296 float_retb_wa VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=1
XI19 VDDP VSS VBP VBN RWLB net239 mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1 wn=270n
+ wp=270n
XI8 VDDP VSS VBP VBN net94 RWLB mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI7 VDDP VSS VBP VBN net205 net94 mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI94 VDDPI VSS VBP VBN net16 FLOAT mm16a05_u_inv_bulk_n_vt2_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=2 nf_n=1 nf_p=1 wn=200n
+ wp=360n
XI93 VDDP VSS VBP VBN FLOAT_RET net16 mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=8 m_p=8 nf_n=1 nf_p=1 wn=200.0n
+ wp=200.0n
XI39 VDDP VSS VBP VBN net239 RWLBHV mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=200n
XI40 VDDP VSS VBP VBN RWLBLV net350 mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=200n
MI50 float_retb_wa net296 net286 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=1
MI64 net14 net358 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=150n m=2
MI51 net286 WAPRCLKBUFB_RET VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=1
MI66 net14 STCLK FLOAT VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=150n
+ m=2
XI117 VDDPI VSS VBP VBN net296 WABUFB LWEIB TRNM
+ mm16a05_u_nr3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=3 m_n2=3 m_n3=3 m_p1=3
+ m_p2=3 m_p3=3 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=240n
+ wn2=240n wn3=240n wp1=400n wp2=400n wp3=400n
.ends

.subckt mm16a05_u_bk_sel_t1t_hdsp VDDP VDDPI VSS VBP VBN BBKB BKSA BKSA_T1TB
+ TBKB A0 A1 A2 AB0 PRCKE_B PRCKE_T T1T
XI44 VDDPI VSS VBP VBN BKSA_T1TB BKSA net96
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=640n wn2=640n wp1=400n
+ wp2=400n
XI16 VDDPI VSS VBP VBN BKSA PRCKE_T PRCKE_B
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=640n wn2=640n wp1=400n
+ wp2=400n
XI39 VDDPI VSS VBP VBN BBKB A2 A1 AB0
+ mm16a05_u_nd3_bulk_n1_vt4_n2_vt4_n3_vt4_p1_vt4_p2_vt4_p3_vt4 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=4 m_n2=4 m_n3=4 m_p1=4
+ m_p2=4 m_p3=4 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=640n
+ wn2=640n wn3=640n wp1=240n wp2=240n wp3=240n
Xnd3_cmuxt VDDPI VSS VBP VBN TBKB A2 A1 A0
+ mm16a05_u_nd3_bulk_n1_vt4_n2_vt4_n3_vt4_p1_vt4_p2_vt4_p3_vt4 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=4 m_n2=4 m_n3=4 m_p1=4
+ m_p2=4 m_p3=4 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=640n
+ wn2=640n wn3=640n wp1=240n wp2=240n wp3=240n
XI31 VDDPI VSS VBP VBN net96 T1T mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
.ends

.subckt mm16a05_u_log01_gen VDDP VNWP VSS VBP VBN LOG0
*XI11 VBP VBN always1 mm16a05_u_init1
XI10 VDDP VSS VBP VBN alway0 always1 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
Xinv_1 VDDP VSS VBP VBN always1 ST0 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
M0 LOG0 always1 VSS VBN lvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=2
M1 ST0 always1 VSS VBN lvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
M2 ST0 alway0 VSS VBN lvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
.ends

.subckt mm16a05_u_hdsp_predec_2to4 VDDP VDDPI VSS VBP VBN PM[0] PM[1] PM[2]
+ PM[3] AB[0] AB[1]
Xinv_adr1 VDDPI VSS VBP VBN A[1] AB[1] mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
Xinv_adr0 VDDPI VSS VBP VBN A[0] AB[0] mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI77 VDDPI VSS VBP VBN PM[2] AB[0] A[1]
+ mm16a05_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=240n
+ wp2=240n
XI78 VDDPI VSS VBP VBN PM[1] A[0] AB[1]
+ mm16a05_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=240n
+ wp2=240n
XI79 VDDPI VSS VBP VBN PM[0] AB[0] AB[1]
+ mm16a05_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=240n
+ wp2=240n
XI80 VDDPI VSS VBP VBN PM[3] A[0] A[1]
+ mm16a05_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=240n
+ wp2=240n
.ends

.subckt mm16a05_u_logrep VDDP VSS VBP VBN LOG0 LOG1
MPLOG VDDP LOG0 LOG1 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=200n m=4
M0 LOG0 LOG1 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=200n m=4
.ends

.subckt mm16a05_u_mux_2x1_modesel VDDP VDDPI VSS VBP VBN OUT 0_1 1 SEL SELB
XI35 VBP VBN 1 OUT SEL SELB mm16a05_u_tg_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
XI29 VBP VBN 0_1 OUT SELB SEL mm16a05_u_tg_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
.ends

.subckt mm16a05_u_sac_pwmg_hdsp VDDA VDDP VDDPI VSS VBP VBN LCGTB LCGTHB
+ LCGTHLV LCGTH_PCHG ENLPGB LCGTHHV LITESLP RM3CNT
XI16 VDDPI VSS VBP VBN LCGTH_PCHG LCGTB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160.0n
+ wp=160.0n
XI0 VDDP VSS VBP VBN LCGTHB LCGTHHV mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=240.0n
XI7 VDDP VSS VBP VBN LCGTB ENLPGB LITESLP
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI22 VDDP VSS VBP VBN LCGTHLV RM3CNT LCGTB
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
.ends

.subckt mm16a05_u_hdsp_plus_rdctrl VDDP VDDPI VSS VBP VBN LWERD LWEWR SAOFF
+ FLOAT FLOATT TEST_RNM BKSA LDFTX LWEIB
XI6 VDDPI VSS VBP VBN SAOFF LWERD BKSA CCLK
+ mm16a05_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=4 m_n2=4 m_n3=4 m_p1=4
+ m_p2=4 m_p3=4 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=400n
+ wn2=400n wn3=400n wp1=120n wp2=120n wp3=120n
XI16 VDDPI VSS VBP VBN LWEWR net57 LWEIB
+ mm16a05_u_nd2_bulk_n1_vt4_n2_vt4_p1_vt4_p2_vt4 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=4 m_n2=4
+ m_p1=4 m_p2=4 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=200n
+ wp2=200n
XI15 VDDPI VSS VBP VBN CCLK FLOAT FLOATT
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=4 m_n2=4
+ m_p1=4 m_p2=4 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=160n
+ wp2=160n
Xnr2_lwebk VDDPI VSS VBP VBN LWERD net38 TEST_RNM
+ mm16a05_u_nr2_bulk_n1_vt4_n2_vt4_p1_vt4_p2_vt4 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=4 m_n2=4
+ m_p1=4 m_p2=4 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=320n
+ wp2=320n
XI7 VDDPI VSS VBP VBN net38 LWEIB mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=200n
+ wp=160n
XI14 VDDPI VSS VBP VBN net57 LDFTX mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=200n
+ wp=160n
.ends

.subckt mm16a05_u_sacbuf_dly_hdsp_plus VDDP VDDPI VSS VBP VBN SAOFFOUT RDT1B
+ SAOFF
XI35 VDDPI VSS VBP VBN sadlyb0 SAOFF mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI34 VDDPI VSS VBP VBN sadlyt0 sadlyb0 mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI22 VDDPI VSS VBP VBN T1T RDT1B mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI30 VDDPI VSS VBP VBN sadlyt1 sadlyb1 mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI33 VDDPI VSS VBP VBN sadlyb1 sadlyt0 mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI28 VBP VBN SAOFFOUT sadlyt1 RDT1B T1T mm16a05_u_tg_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI29 VBP VBN SAOFFOUT SAOFF T1T RDT1B mm16a05_u_tg_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=160n
+ wp=160n
.ends

.subckt mm16a05_u_saetrack VDDPI VNWP VSS VBP VBN SAPRCH SAED SAOFF
*XI54 VBP VBN SAPRCH mm16a05_u_init0
M4 VDDPI SAOFF SAPRCH VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=2
M7 net0148 SAED SAPRCH VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
MPA VDDPI SAPRCHB net0148 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
XFWD VDDPI VSS VBP VBN SAPRCHB SAPRCH mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
M0 net047 SAED VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n m=2
M1 SAPRCH SAOFF net047 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n
+ m=2
M3 net0137 SAPRCHB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
M2 SAPRCH SAOFF net0137 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
.ends

.subckt mm16a05_u_sacbufctrl_hdsp_plus VDDP VDDPI VSS VBP VBN SAET SAPRT FLOAT
+ SAEDL SAEDR SAOFF STCLK
XI62 VDDPI VSS VBP VBN net81 FLOAT mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI50 VDDPI VSS VBP VBN SAPRCHB SAPRCHT mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI52 VDDPI VDDP VSS VBP VBN SAPRCHT SAEDR SAOFF mm16a05_u_saetrack
MI5 VDDPI STCLK XP VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=280n m=6
MI4 XP SAPRCHB SAET VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=280n m=6
MI173 VDDPI net81 XP VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=280n m=6
M92 SAET SAPRCHB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=6
MI6 SAET STCLK net78 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=6
MI7 net78 net81 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=6
XGPRCH VDDPI VSS VBP VBN SAPRT SAOFF SAPRCHB
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=8 m_n2=8
+ m_p1=4 m_p2=8 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=120n
+ wp2=200n
.ends

.subckt mm16a05_u_hdsp_plus_rdctrl_sa VDDP VDDPI VSS VBP VBN LWERD LWEWR SAET
+ SAPRT FLOAT FLOATT TEST_RNM BKSA LDFTX LWEIB SAEDL SAEDR STCLK T1T
XI17 VDDP VDDPI VSS VBP VBN LWERD LWEWR net81 FLOAT FLOATT TEST_RNM BKSA LDFTX
+ LWEIB mm16a05_u_hdsp_plus_rdctrl
XI69 VDDP VDDPI VSS VBP VBN net96 T1T net81 mm16a05_u_sacbuf_dly_hdsp_plus
XI15 VDDP VDDPI VSS VBP VBN SAET SAPRT FLOAT SAEDL SAEDR net96 STCLK
+ mm16a05_u_sacbufctrl_hdsp_plus
.ends

.subckt mm16a05_u_hdsp_plus_sactrl VDDA VDDMINB VDDP VDDPI VSS VBP VBN FAST1B
+ LCGTB LCGTHB LCGTHLV LCGTH_PCHG LLBKADRB[0] LLBKADRB[1] LLBKADRB[2]
+ LLBKADRT[0] LLBKADRT[1] LLBKADRT[2] LMATCH LWERD LWEWR PM[0] PM[1] PM[2]
+ PM[3] PRCKE_B PRCKE_T PRCLKB RWLBLV SAET SAPRT BYPASS BYP_VLOAD DEF_MODE
+ FAST1_MODE FAST2_MODE FLOAT FLOATT_PGM FLOAT_RET LOG0 LOG1 RBLRD RBLWA RBLWR
+ RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2]
+ WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] CENDP ENLPGB FLOATT
+ FLOAT_RET_TIMER_PROG LBKADR[0] LBKADR[1] LBKADR[2] LCGTHHV LDFTX LITESLP
+ LMATCHB LMATCHB_I_BBK LMATCHB_I_TBK LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3]
+ LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PLBKADR[0] PLBKADR[1]
+ PLBKADR[2] PLBKADRB[0] RM3CNT RWLBHV SAEDL SAEDR WAPRCLKBUFB_RET
XI74 VDDPI VSS VBP VBN LMATCH LMATCHB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=200n
+ wp=200n
XI122 VDDPI VSS VBP VBN TEST_RNM TEST_RNMB mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI48[0] VDDPI VSS VBP VBN LLBKADRT[0] LOG0 mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=480n wp=480n
XI48[1] VDDPI VSS VBP VBN LLBKADRT[1] LOG0 mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=480n wp=480n
XI48[2] VDDPI VSS VBP VBN LLBKADRT[2] LOG0 mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=480n wp=480n
Xinv_lbk[0] VDDPI VSS VBP VBN LLBKADRB[0] LBKADR[0]
+ mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=480n wp=480n
Xinv_lbk[1] VDDPI VSS VBP VBN LLBKADRB[1] LBKADR[1]
+ mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=480n wp=480n
Xinv_lbk[2] VDDPI VSS VBP VBN LLBKADRB[2] LBKADR[2]
+ mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=480n wp=480n
XI548 VDDPI VSS VBP VBN LWEIBB LWEIB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
Xbk_sel_prck VDDP VDDPI VSS VBP VBN PRCKE_B PRCKE_T LMATCH LMATCHB_I_BBK
+ LMATCHB_I_TBK LOG1 BBKB LMATCHB TBKB mm16a05_u_bk_sel_dft_prclk_vt4_plus
XI515 VDDP VDDPI VSS VBP VBN RBL RBLWR RBLRD LWEIB mm16a05_u_hdsp_mux_2x1_hd
XLCEN_SELFTIMED_WR VDDA VDDP VDDPI VSS VBP VBN FAST1B PRCLKB net1484 net1483
+ RWLB_SAC RWLBLV STCLK DEF_MODE FLOAT FAST1_MODE FAST2_MODE INT[2] INT[3]
+ WABUF[2] WAPRCLKBUFB_RET BKSA_T1TB FLOAT_RET_TIMER_PROG net1482 LWEIB RBL
+ RWLBHV net1484 TEST_RNM mm16a05_u_float_selftimed_wa_hdsp_plus
Xbk_sel VDDP VDDPI VSS VBP VBN BBKB BKSA BKSA_T1TB TBKB PLBKADR[0] PLBKADR[1]
+ PLBKADR[2] PLBKADRB[0] PRCKE_B PRCKE_T T1T mm16a05_u_bk_sel_t1t_hdsp
XI400 VDDP VDDP VSS VBP VBN LOG0 mm16a05_u_log01_gen
XI360 VDDP VDDPI VSS VBP VBN PM[0] PM[1] PM[2] PM[3] LYADR[0] LYADR[1]
+ mm16a05_u_hdsp_predec_2to4
XI401 VDDP VSS VBP VBN LOG0 LOG1 mm16a05_u_logrep
XRMWMSEL[0] VDDP VDDPI VSS VBP VBN INT[2] WMT[2] RMT[2] LWEIB LWEIBB
+ mm16a05_u_mux_2x1_modesel
XRMWMSEL[1] VDDP VDDPI VSS VBP VBN INT[3] WMT[3] RMT[3] LWEIB LWEIBB
+ mm16a05_u_mux_2x1_modesel
XI337 VDDA VDDP VDDPI VSS VBP VBN LCGTB LCGTHB LCGTHLV LCGTH_PCHG ENLPGB
+ LCGTHHV LITESLP RM3CNT mm16a05_u_sac_pwmg_hdsp
XRDCTRL VDDP VDDPI VSS VBP VBN LWERD LWEWR SAET SAPRT FLOAT FLOATT_PGM TEST_RNM
+ BKSA LDFTX LWEIB SAEDL SAEDR STCLK T1T mm16a05_u_hdsp_plus_rdctrl_sa
.ends

.subckt mm16a05_u_hc_wrwlload VDDA VBP VBN RT RWL RWLD
M3 RT RWL VDDA VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=128n m=3
M2 VDDA RWLD RT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=128n m=3
.ends

.subckt mm16a05_u_hdsp_plus_rar4x1 VDDA VDDAI VDDP VDDPI VSS VBP VBN BB[0]
+ BB[1] BB[2] BB[3] LOG0 LOG1 QB QT RWLD_RD RWLD_WR RWL_RD RWL_WR SDOR SDOR_RET
+ SEL VBA WBI WTI LLSB SDB_BC1T SDB_BC2T
XDUMMY VDDA VDDAI VSS VBP VBN BB[0] BB[1] BB[2] BB[3] VBA net120 net121 net122
+ net123 mm16a05_u_ram6t_strapx4_hc
XI64 VDDA VBP VBN net113 RWL_RD RWLD_RD mm16a05_u_hc_wrwlload
XI49[0] VDDA VBP VBN net112 RWL_WR RWLD_WR mm16a05_u_hc_wrwlload
XI49[1] VDDA VBP VBN net112 RWL_WR RWLD_WR mm16a05_u_hc_wrwlload
XI65[0] VDDA VBP VBN net113 RWL_RD RWLD_RD mm16a05_u_hc_wrwlload
XI65[1] VDDA VBP VBN net113 RWL_RD RWLD_RD mm16a05_u_hc_wrwlload
XI33 VDDA VBP VBN net112 RWL_WR RWLD_WR mm16a05_u_hc_wrwlload
XCOREBIAS VDDA VDDAI VBP VBN net88 net87 LLSB SDB_BC1T SDB_BC2T
+ mm16a05_u_corebias_gf22
.ends

.subckt mm16a05_u_arysd_dly_hdsp VDDA VDDAI VSS VBP VBN OUT OUTB IN
XI12 VDDAI VSS VBP VBN net59 IN net49
+ mm16a05_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
MI20 net157 net110 VSS VBN lvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI19 net155 IN VSS VBN lvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MPA VDDAI IN net153 VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI18 VDDA net110 net104 VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
XI15 VDDA VSS VBP VBN OUT net59 mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI13 net153 net155 VBP VBN net110 IN mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
Xinv_0 net104 net157 VBP VBN inb net110 mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI10 VDDA VSS VBP VBN net49 outt mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI11 VDDAI VSS VBP VBN outt inb mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI14 VDDA VSS VBP VBN OUTB OUT mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=160n
.ends

.subckt mm16a05_u_hdsp_plus_pg_aryslpbuf VDDA VSS VBP VBN ARYSDB_BC1 ARYSDB_BC2
+ ARYSD_DELAY LLSB RESDOR_RET ARYSD_BC1 ARYSD_BC2 ARYSD_IN LCGTH SDOR_RETI
XI22 VDDA VSS VBP VBN net78 LCGTH ARYSD_DELAY
+ mm16a05_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=400n
+ wp2=400n
XI24 VDDAI_R VSS VBP VBN net74 ARYSD_BC1 ARYSD_DELAY
+ mm16a05_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=400n wn2=400n wp1=480n
+ wp2=480n
XI10 VDDAI_R VSS VBP VBN net72 ARYSD_BC2 ARYSD_DELAY
+ mm16a05_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=400n wn2=400n wp1=480n
+ wp2=480n
XI17 VDDA VDDA VSS VBP VBN ARYSD_DELAY net82 ARYSD_INT mm16a05_u_arysd_dly_hdsp
XI30 VDDA VSS VBP VBN ARYSDB_BC1 net74 mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=5 m_p=5 nf_n=1 nf_p=1 wn=336n
+ wp=336n
XI25 VDDA VSS VBP VBN ARYSD_INT ARYSD_IN mm16a05_u_inv_bulk_n_vt1_p_vt1
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=320n wp=400n
XI28 VDDA VSS VBP VBN ARYSDB_BC2 net72 mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1 wn=427n
+ wp=267n
XI21 VDDA VSS VBP VBN RESDOR_RET SDOR_RETI mm16a05_u_inv_bulk_n_vt1_p_vt1
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=320n wp=400n
XI34 VDDA VSS VBP VBN LLSB net78 mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1 wn=427n
+ wp=267n
MPA VDDA ARYSD_INT VDDAI_R VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=4
.ends

.subckt mm16a05_u_pg_wlstkrw_plus VDDA VDDWL VSS VBP VBN LCGTHB LCGTH
MI11 VDDWL VDDWL VDDA VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=300n m=1
MI10 VDDA LCGTH VDDWL VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=225n
+ m=16
M0 VDDA LCGTH VDDWL VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=525n m=16
M1 VDDA VDDWL VDDWL VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=300n m=1
XI15 VDDA VSS VBP VBN LCGTHB LCGTH mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=2 nf_p=2 wn=240.0n
+ wp=240.0n
.ends

.subckt mm16a05_u_hdsp_plus_rwbuf_left VDDA VDDP VDDPI VDDWL VSS VBP VBN
+ ARYSDB_BC1 ARYSDB_BC2 ARYSD_TOP LLSB RWL_RD RWL_WR ARYSD_OUT LOG0 LOG1 PO
+ RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] RWLD_RD RWLD_WR TOPEDGE VBA
+ ARYSD_BC1 ARYSD_BC2 ARYSD_IN LCGTH RWLB_RD RWLB_WR SDOR_RETI
XDUMMY VSS VBA mm16a05_u_ram6t_corner_hs1prf
XI25 VDDA VSS VBP VBN ARYSDB_BC1 ARYSDB_BC2 ARYSD_OUT LLSB ARYSD_TOP ARYSD_BC1
+ ARYSD_BC2 ARYSD_IN LCGTH SDOR_RETI mm16a05_u_hdsp_plus_pg_aryslpbuf
XWLSTACK VDDA VDDWL VSS VBP VBN net112 LCGTH mm16a05_u_pg_wlstkrw_plus
.ends

.subckt mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt3_p2_vt3 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=600n wn2=600n wp1=450n wp2=450n
MPA2 X A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
MPA1 X A1 VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MNA1 X A1 net22 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 net22 A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2
+ w=wn2 m=m_n2
.ends

.subckt mm16a05_u_complex_nor_wk_rwl VDDPI VNWP VSS VBP VBN OUT BK LMATCH
+ LMATCHB T1T
M97 VDDPI T1T net189 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=480n m=1
M94 OUT LMATCHB net189 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=480n
+ m=1
M95 net187 BK OUT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=480n m=1
M96 net189 LMATCH net187 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=480n
+ m=1
M75 VSS T1T OUT VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
M36 VSS LMATCHB net193 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
M37 OUT LMATCH net193 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
M38 OUT BK net193 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
.ends

.subckt mm16a05_u_hdsp_plus_rwlgen_gf22 VDDA VDDP VDDPI VSS VBP VBN RWLB_RD
+ RWLB_WR RWL_DLY_0 RWL_DLY_2 RWL_DLY_4 BKSEL_RW FLOAT FLOAT_RET FLOAT_RET_PROG
+ LMATCH LMATCHB LWEIB_HV RWLB_SAC RWL_DLY_RD_PGM RWL_DLY_WR_PGM T1T
XI103 VDDP VSS VBP VBN net298 LWEI_BKSEL_T1T RWL_DLY_WR_PGM
+ mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=240n
+ wp2=240n
XI86 VDDP VSS VBP VBN RWLB_RD RWL_DLY_RD_PGM LWEIB_BKSEL_T1T
+ mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=640n wn2=640n wp1=320n
+ wp2=320n
XI98 VDDPI VSS VBP VBN RWL_DLY_0 FLOAT FLOAT_RET_PROG
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=180n
+ wp2=180n
XI115 VDDPI VSS VBP VBN BKSEL_RW_T1TB BKSEL_RW_T1T
+ mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n wp=240n
XI118 VDDP VSS VBP VBN RWLB_WR net309 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=320n
+ wp=640n
XI173 VDDPI VSS VBP VBN RWL_DLY_2 net349 mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI176 VDDPI VSS VBP VBN net351 RWL_DLY_2 mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI175 VDDPI VSS VBP VBN RWL_DLY_4 net351 mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI172 VDDPI VSS VBP VBN net349 RWL_DLY_0 mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI117 VDDP VSS VBP VBN net309 net298 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=640n
XI163 VDDPI VDDP VSS VBP VBN BKSEL_RW_T1T BKSEL_RW LMATCH LMATCHB T1T
+ mm16a05_u_complex_nor_wk_rwl
XI116 VDDPI VSS VBP VBN LWEIB_BKSEL_T1T LWEI_BKSEL_T1T BKSEL_RW_T1TB
+ mm16a05_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=320n
+ wp2=320n
XI113 VDDPI VSS VBP VBN LWEI_BKSEL_T1T LWEIB_HV BKSEL_RW_T1TB
+ mm16a05_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=320n
+ wp2=320n
.ends

.subckt mm16a05_u_wrtimer_logic_hdsp_plus VSS VBP VBN DBL LOG1 RMT[0] RMT[1]
+ RMT[2] RWL_AND_RWLD
MI18 net51 RWL_AND_RWLD net64 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=1
MI19 net101 RWL_AND_RWLD VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=1
M0 W0 RWL_AND_RWLD net48 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
M1 DBL RWL_AND_RWLD W0 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
M2 DBL RWL_AND_RWLD W3 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
M3 W3 RWL_AND_RWLD net51 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
M4 W4 RMT[1] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M5 DBL RWL_AND_RWLD W4 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
M6 DBL RWL_AND_RWLD W5 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=200n
+ m=2
M7 W5 RMT[2] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=180n m=2
MI16 net48 RWL_AND_RWLD net101 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=1
MI20 net64 RMT[0] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
.ends

.subckt mm16a05_u_rdtimer_logic_hdsp_plus VSS VBP VBN DBL LOG1 RMT[0] RMT[1]
+ RMT[2] RWL_AND_RWLD
MI31 net112 RWL_AND_RWLD VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n
+ w=120n m=1
MI20 net60 RMT[0] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n w=120n m=1
M0 W0 RWL_AND_RWLD net47 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
M1 DBL RWL_AND_RWLD W0 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
M2 DBL RWL_AND_RWLD W3 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n w=120n
+ m=1
M3 W3 RWL_AND_RWLD net60 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n w=120n
+ m=1
M4 W4 RMT[1] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n w=120n m=1
M5 DBL RWL_AND_RWLD W4 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n w=120n
+ m=1
M6 DBL RWL_AND_RWLD W5 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n w=240n
+ m=2
M7 W5 RMT[2] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n w=240n m=2
MI18 net115 RWL_AND_RWLD net56 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n
+ w=120n m=1
MI19 net56 RWL_AND_RWLD net112 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n
+ w=120n m=1
MI17 net47 RWL_AND_RWLD net115 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=1
.ends

.subckt mm16a05_u_rwl_and_rwld_hdsp_plus VDDA VSS VBP VBN RWL_AND_RWLD RWLB
+ RWLD
XI93 VBP VBN RWLD RWL_AND_RWLD RWLT RWLB mm16a05_u_tg_bulk_n_vt4_p_vt4 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=3 nf_n=1 nf_p=1 wn=300n
+ wp=400n
XI6 VDDA VSS VBP VBN RWLT RWLB mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
M3 RWL_AND_RWLD RWLB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n
+ m=2
.ends

.subckt mm16a05_u_write_delay_slow VDDP VDDPI VSS VBP VBN OUT IN RWLB WMT2
MI30 net114 INBB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI23 VDDPI INBB net113 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
XI36 VDDPI VSS VBP VBN DLY4B net213 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI34 VDDPI VSS VBP VBN WMSLOW WMT2 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI31 VDDPI VSS VBP VBN INBB INB mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI29 VDDPI VSS VBP VBN net217 net218 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI27 VDDPI VSS VBP VBN DLY4A net217 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI26 VDDPI VSS VBP VBN net213 net214 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI25 VDDPI VSS VBP VBN WMSLOWB WMSLOW mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI24 VDDPI VSS VBP VBN net218 net219 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI21 VDDPI VSS VBP VBN net214 DLY_ND1 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI18 VDDPI VSS VBP VBN INB IN mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
XI17 net113 net114 VBP VBN net219 INBB mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI37 VDDPI VSS VBP VBN DLY_ND2 INBB DLY4B
+ mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI39 VDDPI VSS VBP VBN DLY_ND1 INBB DLY4A
+ mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI33 VBP VBN INB DEF_BYPASS WMSLOWB WMSLOW mm16a05_u_tg_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI32 VBP VBN DLY_ND2 DEF_BYPASS WMSLOW WMSLOWB mm16a05_u_tg_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI22 VDDPI VSS VBP VBN OUT RWLB DEF_BYPASS
+ mm16a05_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=3 m_n2=3
+ m_p1=3 m_p2=3 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=374n
+ wp2=374n
.ends

.subckt mm16a05_u_hdsp_plus_rwtimer_gf22 VDDMINB VDDA VDDP VDDPI VSS VBP VBN
+ RWL_RWLD_AND RWL_RWLD_AND_WR LOG0 LOG1 RBL RWLB_RD RWLB_WR RWLD_RD RWLD_WR
+ WBL RMT[0] RMT[1] RMT[2] WMT[0] WMT[1] WMT[2] WMT[3]
XI175 VSS VBP VBN WBL LOG1 WMT[0] WMT[1] WMT[2] RWL_RWLD_AND_WR
+ mm16a05_u_wrtimer_logic_hdsp_plus
XI141 VSS VBP VBN RBL LOG1 RMT[0] RMT[1] RMT[2] RWL_RWLD_AND
+ mm16a05_u_rdtimer_logic_hdsp_plus
XI132 VDDA VSS VBP VBN RWLD_IN RWLB_RD RWLD_RD mm16a05_u_rwl_and_rwld_hdsp_plus
XI182 VDDPI net603 VBP VBN RWLD_OUT_SLOW net602 mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=24n lp=24n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI181 net597 VSS VBP VBN net602 net599 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=24n lp=24n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI183 net583 VSS VBP VBN net592 net585 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=24n lp=24n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI176 net567 VSS VBP VBN net572 RWLD_OUT mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=24n lp=24n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI184 VDDPI VSS VBP VBN RWLD_OUT RWLD_IN mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=120n
XI169 VDDPI net573 VBP VBN net585 net572 mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=24n lp=24n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI180 VDDPI net589 VBP VBN net599 net592 mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=24n lp=24n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI178 VDDPI VSS VBP VBN SEL_SLOWB SEL_SLOW mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI185 VDDPI VSS VBP VBN RWL_RWLD_AND MUX_OUT mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=240n
XI163 VDDP VDDPI VSS VBP VBN RWL_RWLD_AND_WR RWLD_WR RWLB_WR WMT[3]
+ mm16a05_u_write_delay_slow
MI190 net597 net599 VDDPI VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=24n w=120n
+ m=1
MI186 net567 RWLD_OUT VDDPI VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=24n
+ w=120n m=1
MI174 VDDPI RWL_RWLD_AND_WR WBL VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=400n m=3
MI140 VDDPI RWL_RWLD_AND RBL VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=400n m=3
MI188 net583 net585 VDDPI VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=24n w=120n
+ m=1
MI191 net603 net602 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n w=120n
+ m=1
MI189 net589 net592 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n w=120n
+ m=1
MI187 net573 net572 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n w=120n
+ m=1
XI33 VBP VBN RWLD_OUT_SLOW MUX_OUT SEL_SLOW SEL_SLOWB
+ mm16a05_u_tg_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
XI32 VBP VBN RWLD_OUT MUX_OUT SEL_SLOWB SEL_SLOW mm16a05_u_tg_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=480n wp=480n
XI22 VDDPI VSS VBP VBN SEL_SLOW RMT[2] RMT[1]
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=240n
+ wp2=240n
.ends

.subckt mm16a05_u_complex_nor_wk_rwl_wa VDDP VDDPI VSS VBP VBN OUT BK LMATCH
+ LMATCHB
M94 OUT LMATCHB VDDPI VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
M95 net187 BK OUT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
M96 VDDPI LMATCH net187 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
M36 VSS LMATCHB net193 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
M37 OUT LMATCH net193 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
M38 OUT BK net193 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
.ends

.subckt mm16a05_u_hdsp_plus_rw_gf22 VDDMINB VDDA VDDP VDDPI VSS VSSC_WL_L
+ VSSC_WL_R VBP VBN RWLB_RD RWLB_WR RWL_DLY_0 RWL_DLY_2 RWL_DLY_4 RWL_RWLD_AND
+ RWL_RWLD_AND_WR CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT_RET FLOAT_RET_PROG
+ LBKADR[0] LBKADR[1] LBKADR[2] LCGTHB LDFTX LITESLP LLBKADRB[1] LLBKADRB[2]
+ LMATCHB LMATCHB_I LOG0 LOG1 LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+ LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PLBKADR[1] PLBKADR[2] RBLRD
+ RBLWA RBLWR RM3CNT RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WPBUF[0]
+ WPBUF[1] WPBUF[2] FLOAT FLOATT LWEIB RMT[0] RMT[1] RMT[2] RMT[3] RWLD_RD
+ RWLD_WR RWLHVBRD RWLHVBWR RWL_DLY_RD_PGM RWL_DLY_WR_PGM WMT[0] WMT[1] WMT[2]
+ WMT[3]
XI101 VDDA VDDP VDDPI VSS VBP VBN RWLB_RD RWLB_WR RWL_DLY_0 RWL_DLY_2 RWL_DLY_4
+ BKSEL_RW FLOAT FLOAT_RET FLOAT_RET_PROG LMATCH LMATCHB_I LWEIB RWLB_SAC
+ RWL_DLY_RD_PGM RWL_DLY_WR_PGM T1T mm16a05_u_hdsp_plus_rwlgen_gf22
XI102 VDDMINB VDDA VDDP VDDPI VSS VBP VBN RWL_RWLD_AND RWL_RWLD_AND_WR LOG0
+ LOG1 RBLRD RWLHVBRD RWLHVBWR RWLD_RD RWLD_WR RBLWR RMT[0] RMT[1] RMT[2]
+ WMT[0] WMT[1] WMT[2] WMT[3] mm16a05_u_hdsp_plus_rwtimer_gf22
XI11 VDDP VSS VBP VBN LOG0 LOG1 mm16a05_u_logrepw
Xinv_lbk[1] VDDPI VSS VBP VBN LLBKADRB[1] LBKADR[1]
+ mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
Xinv_lbk[2] VDDPI VSS VBP VBN LLBKADRB[2] LBKADR[2]
+ mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
XI38 VDDPI VSS VBP VBN LMATCH LMATCHB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI163 VDDP VDDPI VSS VBP VBN BKSEL_RW_WA BKSEL_RW LMATCH LMATCHB_I
+ mm16a05_u_complex_nor_wk_rwl_wa
MI188 VSSC_WL_L LCGTHB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=320n m=3
MI187 VSSC_WL_R LCGTHB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=320n m=3
MI174 FLOATB_RBLWA FLOAT net634 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=200n m=1
MN1_RBLWA RBLWA FLOATB_RBLWA net612 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=240n m=4
MN2_RBLWA net612 BKSEL_RW_WA VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=4
M92 net634 FLOAT VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=200n m=1
MI173 VDDPI FLOAT FLOATB_RBLWA VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=180.0n m=2
MP1_RBLWA VDDPI FLOATB_RBLWA RBLWA VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=120n m=4
MP2_RBLWA VDDPI BKSEL_RW_WA RBLWA VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=120n m=4
Xnd2_sa VDDPI VSS VBP VBN BKSEL_RW PLBKADR[1] PLBKADR[2]
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=120n
+ wp2=120n
.ends

.subckt mm16a05_u_xbuf1_hd_rw_rd_plus VDDWL VDD_BK VSS VBP VBN WL WLB
MI6 VDDWL WLB WL VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=1136n m=5
M17 WL WLB VSS VBN lvtnfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=608n m=5
.ends

.subckt mm16a05_u_xbuf1_hd_rw_plus VDDWL VDD_BK VSS VBP VBN WL WLB
MI6 VDDWL WLB WL VBP lvtpfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=1136n m=5
M17 WL WLB VSS VBN lvtnfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=608n m=5
.ends

.subckt mm16a05_u_hdsp_plus_rwbuf VDDA VDDP VDDPI VDDWL VSS VBP VBN ARYSDB_BC1
+ ARYSDB_BC2 ARYSD_TOP LLSB RWL_RD RWL_WR ARYSD_OUT LCGTHB LOG0 LOG1 PO
+ RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] RWLD_RD RWLD_WR TOPEDGE VBA
+ ARYSD_BC1 ARYSD_BC2 ARYSD_IN LCGTH RWLB_RD RWLB_WR SDOR_RETI
XDUMMY VSS VBA mm16a05_u_ram6t_corner_hs1prf
XWLSTACK VDDA VDDWL VSS VBP VBN LCGTHB LCGTH mm16a05_u_pg_wlstkrw_plus
XI38 VDDA VDDA VSS VBP VBN RWL_RD RWLB_RD mm16a05_u_xbuf1_hd_rw_rd_plus
XI25 VDDA VSS VBP VBN ARYSDB_BC1 ARYSDB_BC2 ARYSD_OUT LLSB ARYSD_TOP ARYSD_BC1
+ ARYSD_BC2 ARYSD_IN LCGTH SDOR_RETI mm16a05_u_hdsp_plus_pg_aryslpbuf
XI34 VDDA VDDA VSS VBP VBN RWL_WR RWLB_WR mm16a05_u_xbuf1_hd_rw_plus
.ends

.subckt mm16a05_u_sac_base_nand_plus VDDP VDDPI VSS VBP VBN QBOUT QTOUT LOG1
+ QB_IN QB_NANDIN QT_IN QT_NANDIN XB XT
XI79 VDDPI VSS VBP VBN QBOUT XB QB_NANDIN
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=3 m_n2=3
+ m_p1=3 m_p2=3 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=214n wn2=214n wp1=480n
+ wp2=480n
XI77 VDDPI VSS VBP VBN QTOUT XT QT_NANDIN
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=3 m_n2=3
+ m_p1=3 m_p2=3 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=214n wn2=214n wp1=480n
+ wp2=480n
.ends

.subckt mm16a05_u_sac_nand_plus VDDP VDDPI VSS VSS_WA VBP VBN QBOUT QTOUT LOG0
+ LOG1 RB RT WB WT QB_IN QB_NANDIN QT_IN QT_NANDIN SAEB SAPRB SEL WB_IN WT_IN
XW VDDP VDDPI VSS VSS_WA VBP VBN WB WT RB RT WB_IN WT_IN mm16a05_u_wrdrv
XI27 VDDP VDDPI VSS VBP VBN QBOUT QTOUT LOG1 QB_IN QB_NANDIN QT_IN QT_NANDIN XB
+ XT mm16a05_u_sac_base_nand_plus
XS VDDP VDDPI VSS VBP VBN LOG0 LOG1 RB RT XB XT SAEB SAPRB SEL
+ mm16a05_u_sac_st_base_plus
.ends

.subckt mm16a05_u_hdsp_plus_sacm4x1_nand VDDP VDDPI VSS VSS_WA VBP VBN QBOUT
+ QTOUT BYPASS BYPASS_RET LCGTH LOG0 LOG1 RASSISTT[0] RASSISTT[1] RB RT SAED WB
+ WB_IN WT WT_IN QB_IN QB_NANDIN QT_IN QT_NANDIN SAEB SAPRB SEL
XSFF VDDP VDDPI VSS VSS_WA VBP VBN QBOUT QTOUT LOG0 LOG1 RB RT WB WT QB_IN
+ QB_NANDIN QT_IN QT_NANDIN SAEB SAPRB SEL WB_IN WT_IN mm16a05_u_sac_nand_plus
.ends

.SUBCKT SNPS_SP_HD_16Kx8_gio_lt_seg1 CB[0] CB[1] CB[2] CB[3] CT[0] CT[1] CT[2]
+       CT[3] D[0] D[1] D[2] D[3] DCLKT DIB[0] DIB[1] DIB[2] DIB[3] DINB[0]
+       DINB[1] DINB[2] DINB[3] DLYPDB D_AL[0] D_AL[1] D_AL[2] D_AL[3] GSE_DB
+       GSE_DT IV_SEL[0] IV_SEL[1] IV_SEL[2] IV_SEL[3] IV_SEL[4] IV_SEL[5]
+       IV_SEL[6] IV_SEL[7] IV_SEL[8] IV_SEL[9] IV_SEL[10] IV_SEL[11] IV_SEL[12]
+       IV_SEL[13] IV_SEL[14] IV_SEL[15] IV_WB[0] IV_WB[1] IV_WB[2] IV_WB[3]
+       IV_WB[4] IV_WB[5] IV_WB[6] IV_WB[7] IV_WB[8] IV_WB[9] IV_WB[10]
+       IV_WB[11] IV_WB[12] IV_WB[13] IV_WB[14] IV_WB[15] IV_WT[0] IV_WT[1]
+       IV_WT[2] IV_WT[3] IV_WT[4] IV_WT[5] IV_WT[6] IV_WT[7] IV_WT[8] IV_WT[9]
+       IV_WT[10] IV_WT[11] IV_WT[12] IV_WT[13] IV_WT[14] IV_WT[15] LDFTYBUF
+       LDIB[0] LDIB[1] LDIB[2] LDIB[3] LOG0 LOG1 LQB[0] LQB[1] LQB[2] LQB[3]
+       LWIB[0] LWIB[1] LWIB[2] LWIB[3] LYB[0] LYB[1] ND_SEL[0] ND_SEL[1]
+       ND_SEL[2] ND_SEL[3] ND_SEL[4] ND_SEL[5] ND_SEL[6] ND_SEL[7] ND_SEL[8]
+       ND_SEL[9] ND_SEL[10] ND_SEL[11] ND_SEL[12] ND_SEL[13] ND_SEL[14]
+       ND_SEL[15] ND_WB[0] ND_WB[1] ND_WB[2] ND_WB[3] ND_WB[4] ND_WB[5]
+       ND_WB[6] ND_WB[7] ND_WB[8] ND_WB[9] ND_WB[10] ND_WB[11] ND_WB[12]
+       ND_WB[13] ND_WB[14] ND_WB[15] ND_WT[0] ND_WT[1] ND_WT[2] ND_WT[3]
+       ND_WT[4] ND_WT[5] ND_WT[6] ND_WT[7] ND_WT[8] ND_WT[9] ND_WT[10]
+       ND_WT[11] ND_WT[12] ND_WT[13] ND_WT[14] ND_WT[15] Q[0] Q[1] Q[2] Q[3]
+       QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+       QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5]
+       QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0]
+       SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10]
+       SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] VBN[0] VBN[1] VBN[2] VBN[3]
+       VBP[0] VBP[1] VBP[2] VBP[3] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+       VDDP[5] VDDP[6] VDDP[7] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI_DR[0]
+       VDDPI_DR[1] VDDPI_DR[2] VDDPI_DR[3] VSS[0] VSS[1] VSS[2] VSS[3] WB_IN[0]
+       WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8]
+       WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15]
+       WEM[0] WEM[1] WEM[2] WEM[3] WEMB[0] WEMB[1] WEMB[2] WEMB[3] WEM_AL[0]
+       WEM_AL[1] WEM_AL[2] WEM_AL[3] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3]
+       WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10]
+       WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15]

*** Jumper Report ***
* Jumper: DINB[0] D_AL[0]
* Jumper: DINB[1] D_AL[1]
* Jumper: DINB[2] D_AL[2]
* Jumper: DINB[3] D_AL[3]
* Jumper: IV_SEL[0] ND_SEL[0]
* Jumper: IV_SEL[1] ND_SEL[1]
* Jumper: IV_SEL[2] ND_SEL[2]
* Jumper: IV_SEL[3] ND_SEL[3]
* Jumper: IV_SEL[4] ND_SEL[4]
* Jumper: IV_SEL[5] ND_SEL[5]
* Jumper: IV_SEL[6] ND_SEL[6]
* Jumper: IV_SEL[7] ND_SEL[7]
* Jumper: IV_SEL[8] ND_SEL[8]
* Jumper: IV_SEL[9] ND_SEL[9]
* Jumper: IV_SEL[10] ND_SEL[10]
* Jumper: IV_SEL[11] ND_SEL[11]
* Jumper: IV_SEL[12] ND_SEL[12]
* Jumper: IV_SEL[13] ND_SEL[13]
* Jumper: IV_SEL[14] ND_SEL[14]
* Jumper: IV_SEL[15] ND_SEL[15]
* Jumper: IV_WB[0] ND_WB[0]
* Jumper: IV_WB[1] ND_WB[1]
* Jumper: IV_WB[2] ND_WB[2]
* Jumper: IV_WB[3] ND_WB[3]
* Jumper: IV_WB[4] ND_WB[4]
* Jumper: IV_WB[5] ND_WB[5]
* Jumper: IV_WB[6] ND_WB[6]
* Jumper: IV_WB[7] ND_WB[7]
* Jumper: IV_WB[8] ND_WB[8]
* Jumper: IV_WB[9] ND_WB[9]
* Jumper: IV_WB[10] ND_WB[10]
* Jumper: IV_WB[11] ND_WB[11]
* Jumper: IV_WB[12] ND_WB[12]
* Jumper: IV_WB[13] ND_WB[13]
* Jumper: IV_WB[14] ND_WB[14]
* Jumper: IV_WB[15] ND_WB[15]
* Jumper: IV_WT[0] ND_WT[0]
* Jumper: IV_WT[1] ND_WT[1]
* Jumper: IV_WT[2] ND_WT[2]
* Jumper: IV_WT[3] ND_WT[3]
* Jumper: IV_WT[4] ND_WT[4]
* Jumper: IV_WT[5] ND_WT[5]
* Jumper: IV_WT[6] ND_WT[6]
* Jumper: IV_WT[7] ND_WT[7]
* Jumper: IV_WT[8] ND_WT[8]
* Jumper: IV_WT[9] ND_WT[9]
* Jumper: IV_WT[10] ND_WT[10]
* Jumper: IV_WT[11] ND_WT[11]
* Jumper: IV_WT[12] ND_WT[12]
* Jumper: IV_WT[13] ND_WT[13]
* Jumper: IV_WT[14] ND_WT[14]
* Jumper: IV_WT[15] ND_WT[15]
* Jumper: VDDP[0] VDDPI[0]
* Jumper: VDDP[2] VDDPI[1]
* Jumper: VDDP[4] VDDPI[2]
* Jumper: VDDP[6] VDDPI[3]
* Jumper: WEMB[0] WEM_AL[0]
* Jumper: WEMB[1] WEM_AL[1]
* Jumper: WEMB[2] WEM_AL[2]
* Jumper: WEMB[3] WEM_AL[3]

X_mm16a05_u_hdsp_plus_giom16x1_S0 VDDP[0] VDDPI[0] VDDPI_DR[0] VDDP[1] VSS[0]
+   VBP[0] VBN[0] CB[0] CT[0] D_AL[0] LDIB[0] LQB[0] LWIB[0] ND_SEL[0] ND_SEL[1]
+   ND_SEL[2] ND_SEL[3] ND_WB[0] ND_WB[1] ND_WB[2] ND_WB[3] ND_WT[0] ND_WT[1]
+   ND_WT[2] ND_WT[3] Q[0] SEL[0] SEL[1] SEL[2] SEL[3] WB_IN[0] WB_IN[1]
+   WB_IN[2] WB_IN[3] WEM_AL[0] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] DIB[0] LOG0
+   LOG1 LYB[0] LYB[1] QB[0] QB[1] QB[2] QB[3] QT[0] QT[1] QT[2] QT[3] D[0]
+   DCLKT DINB[0] DLYPDB IV_SEL[0] IV_SEL[1] IV_SEL[2] IV_SEL[3] IV_WB[0]
+   IV_WB[1] IV_WB[2] IV_WB[3] IV_WT[0] IV_WT[1] IV_WT[2] IV_WT[3] LDFTYBUF
+   GSE_DB GSE_DT WEM[0] WEMB[0] mm16a05_u_hdsp_plus_giom16x1
X_mm16a05_u_hdsp_plus_giom16x1_S1 VDDP[2] VDDPI[1] VDDPI_DR[1] VDDP[3] VSS[1]
+   VBP[1] VBN[1] CB[1] CT[1] D_AL[1] LDIB[1] LQB[1] LWIB[1] ND_SEL[4] ND_SEL[5]
+   ND_SEL[6] ND_SEL[7] ND_WB[4] ND_WB[5] ND_WB[6] ND_WB[7] ND_WT[4] ND_WT[5]
+   ND_WT[6] ND_WT[7] Q[1] SEL[4] SEL[5] SEL[6] SEL[7] WB_IN[4] WB_IN[5]
+   WB_IN[6] WB_IN[7] WEM_AL[1] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] DIB[1] LOG0
+   LOG1 LYB[0] LYB[1] QB[4] QB[5] QB[6] QB[7] QT[4] QT[5] QT[6] QT[7] D[1]
+   DCLKT DINB[1] DLYPDB IV_SEL[4] IV_SEL[5] IV_SEL[6] IV_SEL[7] IV_WB[4]
+   IV_WB[5] IV_WB[6] IV_WB[7] IV_WT[4] IV_WT[5] IV_WT[6] IV_WT[7] LDFTYBUF
+   GSE_DB GSE_DT WEM[1] WEMB[1] mm16a05_u_hdsp_plus_giom16x1
X_mm16a05_u_hdsp_plus_giom16x1_F1 VDDP[4] VDDPI[2] VDDPI_DR[2] VDDP[5] VSS[2]
+   VBP[2] VBN[2] CB[2] CT[2] D_AL[2] LDIB[2] LQB[2] LWIB[2] ND_SEL[8] ND_SEL[9]
+   ND_SEL[10] ND_SEL[11] ND_WB[8] ND_WB[9] ND_WB[10] ND_WB[11] ND_WT[8]
+   ND_WT[9] ND_WT[10] ND_WT[11] Q[2] SEL[8] SEL[9] SEL[10] SEL[11] WB_IN[8]
+   WB_IN[9] WB_IN[10] WB_IN[11] WEM_AL[2] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11]
+   DIB[2] LOG0 LOG1 LYB[0] LYB[1] QB[8] QB[9] QB[10] QB[11] QT[8] QT[9] QT[10]
+   QT[11] D[2] DCLKT DINB[2] DLYPDB IV_SEL[8] IV_SEL[9] IV_SEL[10] IV_SEL[11]
+   IV_WB[8] IV_WB[9] IV_WB[10] IV_WB[11] IV_WT[8] IV_WT[9] IV_WT[10] IV_WT[11]
+   LDFTYBUF GSE_DB GSE_DT WEM[2] WEMB[2] mm16a05_u_hdsp_plus_giom16x1
X_mm16a05_u_hdsp_plus_giom16x1_F0 VDDP[6] VDDPI[3] VDDPI_DR[3] VDDP[7] VSS[3]
+   VBP[3] VBN[3] CB[3] CT[3] D_AL[3] LDIB[3] LQB[3] LWIB[3] ND_SEL[12]
+   ND_SEL[13] ND_SEL[14] ND_SEL[15] ND_WB[12] ND_WB[13] ND_WB[14] ND_WB[15]
+   ND_WT[12] ND_WT[13] ND_WT[14] ND_WT[15] Q[3] SEL[12] SEL[13] SEL[14] SEL[15]
+   WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WEM_AL[3] WT_IN[12] WT_IN[13]
+   WT_IN[14] WT_IN[15] DIB[3] LOG0 LOG1 LYB[0] LYB[1] QB[12] QB[13] QB[14]
+   QB[15] QT[12] QT[13] QT[14] QT[15] D[3] DCLKT DINB[3] DLYPDB IV_SEL[12]
+   IV_SEL[13] IV_SEL[14] IV_SEL[15] IV_WB[12] IV_WB[13] IV_WB[14] IV_WB[15]
+   IV_WT[12] IV_WT[13] IV_WT[14] IV_WT[15] LDFTYBUF GSE_DB GSE_DT WEM[3]
+   WEMB[3] mm16a05_u_hdsp_plus_giom16x1
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_gio_lt CB[0] CB[1] CB[2] CB[3] CT[0] CT[1] CT[2] CT[3]
+       D[0] D[1] D[2] D[3] DCLKT DIB[0] DIB[1] DIB[2] DIB[3] DINB[0] DINB[1]
+       DINB[2] DINB[3] DLYPDBL D_AL[0] D_AL[1] D_AL[2] D_AL[3] GSE_DB GSE_DT
+       IV_SEL[0] IV_SEL[1] IV_SEL[2] IV_SEL[3] IV_SEL[4] IV_SEL[5] IV_SEL[6]
+       IV_SEL[7] IV_SEL[8] IV_SEL[9] IV_SEL[10] IV_SEL[11] IV_SEL[12]
+       IV_SEL[13] IV_SEL[14] IV_SEL[15] IV_WB[0] IV_WB[1] IV_WB[2] IV_WB[3]
+       IV_WB[4] IV_WB[5] IV_WB[6] IV_WB[7] IV_WB[8] IV_WB[9] IV_WB[10]
+       IV_WB[11] IV_WB[12] IV_WB[13] IV_WB[14] IV_WB[15] IV_WT[0] IV_WT[1]
+       IV_WT[2] IV_WT[3] IV_WT[4] IV_WT[5] IV_WT[6] IV_WT[7] IV_WT[8] IV_WT[9]
+       IV_WT[10] IV_WT[11] IV_WT[12] IV_WT[13] IV_WT[14] IV_WT[15] LDFTYBUF
+       LDIB[0] LDIB[1] LDIB[2] LDIB[3] LOG0 LOG1 LQB[0] LQB[1] LQB[2] LQB[3]
+       LWIB[0] LWIB[1] LWIB[2] LWIB[3] LYB[0] LYB[1] ND_SEL[0] ND_SEL[1]
+       ND_SEL[2] ND_SEL[3] ND_SEL[4] ND_SEL[5] ND_SEL[6] ND_SEL[7] ND_SEL[8]
+       ND_SEL[9] ND_SEL[10] ND_SEL[11] ND_SEL[12] ND_SEL[13] ND_SEL[14]
+       ND_SEL[15] ND_WB[0] ND_WB[1] ND_WB[2] ND_WB[3] ND_WB[4] ND_WB[5]
+       ND_WB[6] ND_WB[7] ND_WB[8] ND_WB[9] ND_WB[10] ND_WB[11] ND_WB[12]
+       ND_WB[13] ND_WB[14] ND_WB[15] ND_WT[0] ND_WT[1] ND_WT[2] ND_WT[3]
+       ND_WT[4] ND_WT[5] ND_WT[6] ND_WT[7] ND_WT[8] ND_WT[9] ND_WT[10]
+       ND_WT[11] ND_WT[12] ND_WT[13] ND_WT[14] ND_WT[15] PWDO Q[0] Q[1] Q[2]
+       Q[3] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+       QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5]
+       QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0]
+       SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10]
+       SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] VBN[0] VBN[1] VBN[2] VBN[3]
+       VBN[4] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VDDP[0] VDDP[1] VDDP[2]
+       VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0] VDDPI[1]
+       VDDPI[2] VDDPI[3] VDDPI[4] VDDPI_DR[0] VDDPI_DR[1] VDDPI_DR[2]
+       VDDPI_DR[3] VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] WB_IN[0] WB_IN[1]
+       WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9]
+       WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WEM[0]
+       WEM[1] WEM[2] WEM[3] WEMB[0] WEMB[1] WEMB[2] WEMB[3] WEM_AL[0] WEM_AL[1]
+       WEM_AL[2] WEM_AL[3] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4]
+       WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11]
+       WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15]
X_mm16a05_u_hdsp_plus_capgio VDDP[0] VDDPI[0] VSS[0] VBP[0] VBN[0] LOG0 LOG1
+   PWDO VEDGE mm16a05_u_hdsp_plus_capgio
X_gio_lt_seg1 CB[0] CB[1] CB[2] CB[3] CT[0] CT[1] CT[2] CT[3] D[0] D[1] D[2]
+   D[3] DCLKT DIB[0] DIB[1] DIB[2] DIB[3] DINB[0] DINB[1] DINB[2] DINB[3]
+   DLYPDBL D_AL[0] D_AL[1] D_AL[2] D_AL[3] GSE_DB GSE_DT IV_SEL[0] IV_SEL[1]
+   IV_SEL[2] IV_SEL[3] IV_SEL[4] IV_SEL[5] IV_SEL[6] IV_SEL[7] IV_SEL[8]
+   IV_SEL[9] IV_SEL[10] IV_SEL[11] IV_SEL[12] IV_SEL[13] IV_SEL[14] IV_SEL[15]
+   IV_WB[0] IV_WB[1] IV_WB[2] IV_WB[3] IV_WB[4] IV_WB[5] IV_WB[6] IV_WB[7]
+   IV_WB[8] IV_WB[9] IV_WB[10] IV_WB[11] IV_WB[12] IV_WB[13] IV_WB[14]
+   IV_WB[15] IV_WT[0] IV_WT[1] IV_WT[2] IV_WT[3] IV_WT[4] IV_WT[5] IV_WT[6]
+   IV_WT[7] IV_WT[8] IV_WT[9] IV_WT[10] IV_WT[11] IV_WT[12] IV_WT[13] IV_WT[14]
+   IV_WT[15] LDFTYBUF LDIB[0] LDIB[1] LDIB[2] LDIB[3] LOG0 LOG1 LQB[0] LQB[1]
+   LQB[2] LQB[3] LWIB[0] LWIB[1] LWIB[2] LWIB[3] LYB[0] LYB[1] ND_SEL[0]
+   ND_SEL[1] ND_SEL[2] ND_SEL[3] ND_SEL[4] ND_SEL[5] ND_SEL[6] ND_SEL[7]
+   ND_SEL[8] ND_SEL[9] ND_SEL[10] ND_SEL[11] ND_SEL[12] ND_SEL[13] ND_SEL[14]
+   ND_SEL[15] ND_WB[0] ND_WB[1] ND_WB[2] ND_WB[3] ND_WB[4] ND_WB[5] ND_WB[6]
+   ND_WB[7] ND_WB[8] ND_WB[9] ND_WB[10] ND_WB[11] ND_WB[12] ND_WB[13] ND_WB[14]
+   ND_WB[15] ND_WT[0] ND_WT[1] ND_WT[2] ND_WT[3] ND_WT[4] ND_WT[5] ND_WT[6]
+   ND_WT[7] ND_WT[8] ND_WT[9] ND_WT[10] ND_WT[11] ND_WT[12] ND_WT[13] ND_WT[14]
+   ND_WT[15] Q[0] Q[1] Q[2] Q[3] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6]
+   QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13]
+   QT[14] QT[15] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8]
+   SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] VBN[1] VBN[2] VBN[3]
+   VBN[4] VBP[1] VBP[2] VBP[3] VBP[4] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5]
+   VDDP[6] VDDP[7] VDDP[8] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI_DR[0]
+   VDDPI_DR[1] VDDPI_DR[2] VDDPI_DR[3] VSS[1] VSS[2] VSS[3] VSS[4] WB_IN[0]
+   WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8]
+   WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WEM[0]
+   WEM[1] WEM[2] WEM[3] WEMB[0] WEMB[1] WEMB[2] WEMB[3] WEM_AL[0] WEM_AL[1]
+   WEM_AL[2] WEM_AL[3] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5]
+   WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13]
+   WT_IN[14] WT_IN[15] SNPS_SP_HD_16Kx8_gio_lt_seg1
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_gio_cnt ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1]
+       ARYSD_BC2[0] ARYSD_BC2[1] BC0 BC1 BC2 CENDP CLK CLKB CLKDEL CLKFLT
+       CLK_MUXB DCLKT[0] DCLKT[1] DEF1 DEF12B_PROG DEF12_PROG DEF1B DEF2 DEF2B
+       DEF_MODE DEF_PROG DFTCLKEN DISCHG DLYPDBL DLYPDBR DLYPW FAST1_MODE
+       FAST2_MODE FISO FLOAT FLOATT FLOAT_RET GSE_DB[0] GSE_DB[1] GSE_DT[0]
+       GSE_DT[1] LBKADR0 LBKADR1 LBKADR2 LCLKB LCLKT LDFTX LDFTYBUF[0]
+       LDFTYBUF[1] LITESLP LME LOG0 LOG1 LOG1_RM LS LWE LWEIB LXADR[0] LXADR[1]
+       LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+       LYBH[0] LYBH[1] LYBL[0] LYBL[1] LY_ONE LY_TWO MCLKB MCLKT ME MEB_I
+       MEB_LT MEORDFTCLKEN MEORDFTCLKEN_IN RA[0] RA[1] RASSIST[0] RASSIST[1]
+       RASSIST[2] RASSIST[3] RM[0] RM[1] RM[2] RM[3] RM3CNT RMDEF1[0] RMDEF1[1]
+       RMDEF1[2] RMDEF1[3] RMDEF2[0] RMDEF2[1] RMDEF2[2] RMDEF2[3] RME RMENI[0]
+       RMENI[1] RMENI[2] RMSLOW[0] RMSLOW[1] RMSLOW[2] RMSLOW[3] RMT[0] RMT[1]
+       RMT[2] RMT[3] RSCEN RSCIN RSCLK RSCOUT RSCRST RWLCKB SD SE_IN T1T TEST1
+       TEST_RNM TEST_RNMB VBN[0] VBN[1] VBN[2] VBP[0] VBP[1] VBP[2] VDDA[0]
+       VDDA[1] VDDA[2] VDDF VDDMINB VDDP[0] VDDP[1] VDDP[2] VDDPI[0] VDDPI[1]
+       VDDPI[2] VSS[0] VSS[1] VSS[2] WA[0] WA[1] WABUF[0] WABUF[1] WABUF[2] WE
+       WFLOAT WMDEF1[0] WMDEF1[1] WMDEF1[2] WMDEF1[3] WMDEF2[0] WMDEF2[1]
+       WMDEF2[2] WMDEF2[3] WMSLOW[0] WMSLOW[1] WMSLOW[2] WMSLOW[3] WMT[0]
+       WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WPULSE[0] WPULSE[1]
+       WPULSE[2] XADR[0] XADR[1] XADR[2] XADR[3] XADR[4] XADR[5] XADR[6]
+       XADR[7] XBKADR[0] XBKADR[1] XBKADR[2] YADR[0] YADR[1] YADR[2] YADR[3]

*** Jumper Report ***
* Jumper: CLKB CLK_MUXB
* Jumper: CLKDEL CLKFLT
* Jumper: DEF1 DEF_PROG
* Jumper: DEF12B_PROG DEF2B
* Jumper: DEF12_PROG DEF2
* Jumper: LOG0 CENDP DFTCLKEN DLYPW FISO GSE_DT[0] GSE_DT[1] LDFTX LDFTYBUF[0] LDFTYBUF[1] RA[0] RA[1] RMENI[2] RSCEN RSCIN RSCLK RSCRST SD SE_IN XBKADR[2] CLPSEBUF
* Jumper: LOG1 DLYPDBL DLYPDBR GSE_DB[0] GSE_DB[1] MEORDFTCLKEN_IN RMENI[0] RMENI[1] SDCLPSB
* Jumper: LOG1_RM RMDEF1[2] RMDEF1[3] RMDEF2[1] RMDEF2[2] RMDEF2[3] RMSLOW[0] RMSLOW[1] RMSLOW[2] RMSLOW[3] WMDEF1[0] WMDEF1[1] WMDEF1[2] WMDEF2[1] WMDEF2[3] WMSLOW[0] WMSLOW[2] WMSLOW[3]
* Jumper: LY_ONE LY[0] LY[2]
* Jumper: LY_TWO LY[1] LY[3]
* Jumper: MEB_I MEB_LT
* Jumper: RMDEF1[0] RMDEF1[1] RMDEF2[0] VSS[1] WMDEF1[3] WMDEF2[0] WMDEF2[2] WMSLOW[1]
* Jumper: VDDA[0] VDDP[0] VDDPI[0]
* Jumper: VDDA[1] VDDP[1] VDDPI[1]
* Jumper: VDDA[2] VDDP[2] VDDPI[2]

X_mm16a05_u_hdsp_plus_gcenbuf_left VDDA[0] VDDP[0] VDDPI[0] VSS[0] VBP[0] VBN[0]
+   DCLKT[0] LYBL[0] LYBL[1] RASSIST[0] RASSIST[1] ARYSD[0] LSDB LSDB_BC1
+   LSDB_BC2 ARYSD_BC1[0] ARYSD_BC2[0] DLYPDBL GSE_DB[0] GSE_DT[0] LDFTYBUF[0]
+   LOG0 LOG1 LCLKBIO LY_ONE LY_TWO LY_ONE LY_TWO RAB[0] RAB[1] LOG1
+   mm16a05_u_hdsp_plus_gcenbuf_dr
X_mm16a05_u_hdsp_plus_gcen VDDA[1] VDDF VDDP[1] VDDPI[1] VDDMINB VSS[1] VBP[1]
+   VBN[1] ARYSDB ARYSDB_BC1 ARYSDB_BC2 CLKDEL DEF1 DEF1B DEF2 DEF2B DEF_MODE
+   FAST1_MODE FAST2_MODE LBKADR0 LBKADR1 LBKADR2 LCLKB LCLKBIO LCLKT LITESLP
+   LME LSDB LSDB_BC1 LSDB_BC2 LWE LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3]
+   LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] LY_ONE LY_TWO MCLKB
+   MCLKT MEB_LT RAB[0] RAB[1] RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLCKB T1T
+   TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0]
+   WPBUF[1] WPBUF[2] CLKB LOG0 FISO FLOAT FLOATT LOG0 LOG1 LOG1_RM MEORDFTCLKEN
+   MEORDFTCLKEN_IN RM3CLPSB RSCEN RSCIN RSCLK RSCOUT RSCRST LOG1 WFLOAT BC0 BC1
+   BC2 XBKADR[0] XBKADR[1] XBKADR[2] CENDP CLK CLKFLT CLK_MUXB DEF12B_PROG
+   DEF12_PROG DEF_PROG DFTCLKEN DISCHG DLYPW FLOAT_RET LDFTX LS ME MEB_I RA[0]
+   RA[1] RM[0] RM[1] RM[2] RM[3] RMDEF1[0] RMDEF1[1] RMDEF1[2] RMDEF1[3]
+   RMDEF2[0] RMDEF2[1] RMDEF2[2] RMDEF2[3] RME RMENI[0] RMENI[1] RMENI[2]
+   RMSLOW[0] RMSLOW[1] RMSLOW[2] RMSLOW[3] SD SE_IN TEST1 TEST_RNM WA[0] WA[1]
+   WE WMDEF1[0] WMDEF1[1] WMDEF1[2] WMDEF1[3] WMDEF2[0] WMDEF2[1] WMDEF2[2]
+   WMDEF2[3] WMSLOW[0] WMSLOW[1] WMSLOW[2] WMSLOW[3] WPULSE[0] WPULSE[1]
+   WPULSE[2] XADR[0] XADR[1] XADR[2] XADR[3] XADR[4] XADR[5] XADR[6] XADR[7]
+   YADR[0] YADR[1] YADR[2] YADR[3] mm16a05_u_hdsp_plus_gcen
X_mm16a05_u_hdsp_plus_gcenbuf VDDA[2] VDDP[2] VDDPI[2] VSS[2] VBP[2] VBN[2]
+   DCLKT[1] LYBH[0] LYBH[1] RASSIST[2] RASSIST[3] ARYSD[1] LSDB LSDB_BC1
+   LSDB_BC2 ARYSD_BC1[1] ARYSD_BC2[1] DLYPDBR GSE_DB[1] GSE_DT[1] LDFTYBUF[1]
+   LOG0 LOG1 LCLKBIO LY_ONE LY_TWO LY_ONE LY_TWO RAB[0] RAB[1] LOG1
+   mm16a05_u_hdsp_plus_gcenbuf
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_gio_rt CB[0] CB[1] CB[2] CB[3] CT[0] CT[1] CT[2] CT[3]
+       D[0] D[1] D[2] D[3] DCLKT DIB[0] DIB[1] DIB[2] DIB[3] DINB[0] DINB[1]
+       DINB[2] DINB[3] DLYPDBR D_AL[0] D_AL[1] D_AL[2] D_AL[3] GSE_DB GSE_DT
+       IV_SEL[0] IV_SEL[1] IV_SEL[2] IV_SEL[3] IV_SEL[4] IV_SEL[5] IV_SEL[6]
+       IV_SEL[7] IV_SEL[8] IV_SEL[9] IV_SEL[10] IV_SEL[11] IV_SEL[12]
+       IV_SEL[13] IV_SEL[14] IV_SEL[15] IV_WB[0] IV_WB[1] IV_WB[2] IV_WB[3]
+       IV_WB[4] IV_WB[5] IV_WB[6] IV_WB[7] IV_WB[8] IV_WB[9] IV_WB[10]
+       IV_WB[11] IV_WB[12] IV_WB[13] IV_WB[14] IV_WB[15] IV_WT[0] IV_WT[1]
+       IV_WT[2] IV_WT[3] IV_WT[4] IV_WT[5] IV_WT[6] IV_WT[7] IV_WT[8] IV_WT[9]
+       IV_WT[10] IV_WT[11] IV_WT[12] IV_WT[13] IV_WT[14] IV_WT[15] LDFTYBUF
+       LDIB[0] LDIB[1] LDIB[2] LDIB[3] LOG0 LOG1 LQB[0] LQB[1] LQB[2] LQB[3]
+       LWIB[0] LWIB[1] LWIB[2] LWIB[3] LYB[0] LYB[1] ND_SEL[0] ND_SEL[1]
+       ND_SEL[2] ND_SEL[3] ND_SEL[4] ND_SEL[5] ND_SEL[6] ND_SEL[7] ND_SEL[8]
+       ND_SEL[9] ND_SEL[10] ND_SEL[11] ND_SEL[12] ND_SEL[13] ND_SEL[14]
+       ND_SEL[15] ND_WB[0] ND_WB[1] ND_WB[2] ND_WB[3] ND_WB[4] ND_WB[5]
+       ND_WB[6] ND_WB[7] ND_WB[8] ND_WB[9] ND_WB[10] ND_WB[11] ND_WB[12]
+       ND_WB[13] ND_WB[14] ND_WB[15] ND_WT[0] ND_WT[1] ND_WT[2] ND_WT[3]
+       ND_WT[4] ND_WT[5] ND_WT[6] ND_WT[7] ND_WT[8] ND_WT[9] ND_WT[10]
+       ND_WT[11] ND_WT[12] ND_WT[13] ND_WT[14] ND_WT[15] PWDO Q[0] Q[1] Q[2]
+       Q[3] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+       QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5]
+       QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0]
+       SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10]
+       SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] VBN[0] VBN[1] VBN[2] VBN[3]
+       VBN[4] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VDDP[0] VDDP[1] VDDP[2]
+       VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0] VDDPI[1]
+       VDDPI[2] VDDPI[3] VDDPI[4] VDDPI_DR[0] VDDPI_DR[1] VDDPI_DR[2]
+       VDDPI_DR[3] VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] WB_IN[0] WB_IN[1]
+       WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9]
+       WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WEM[0]
+       WEM[1] WEM[2] WEM[3] WEMB[0] WEMB[1] WEMB[2] WEMB[3] WEM_AL[0] WEM_AL[1]
+       WEM_AL[2] WEM_AL[3] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4]
+       WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11]
+       WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15]
X_gio_lt_seg1 CB[0] CB[1] CB[2] CB[3] CT[0] CT[1] CT[2] CT[3] D[0] D[1] D[2]
+   D[3] DCLKT DIB[0] DIB[1] DIB[2] DIB[3] DINB[0] DINB[1] DINB[2] DINB[3]
+   DLYPDBR D_AL[0] D_AL[1] D_AL[2] D_AL[3] GSE_DB GSE_DT IV_SEL[0] IV_SEL[1]
+   IV_SEL[2] IV_SEL[3] IV_SEL[4] IV_SEL[5] IV_SEL[6] IV_SEL[7] IV_SEL[8]
+   IV_SEL[9] IV_SEL[10] IV_SEL[11] IV_SEL[12] IV_SEL[13] IV_SEL[14] IV_SEL[15]
+   IV_WB[0] IV_WB[1] IV_WB[2] IV_WB[3] IV_WB[4] IV_WB[5] IV_WB[6] IV_WB[7]
+   IV_WB[8] IV_WB[9] IV_WB[10] IV_WB[11] IV_WB[12] IV_WB[13] IV_WB[14]
+   IV_WB[15] IV_WT[0] IV_WT[1] IV_WT[2] IV_WT[3] IV_WT[4] IV_WT[5] IV_WT[6]
+   IV_WT[7] IV_WT[8] IV_WT[9] IV_WT[10] IV_WT[11] IV_WT[12] IV_WT[13] IV_WT[14]
+   IV_WT[15] LDFTYBUF LDIB[0] LDIB[1] LDIB[2] LDIB[3] LOG0 LOG1 LQB[0] LQB[1]
+   LQB[2] LQB[3] LWIB[0] LWIB[1] LWIB[2] LWIB[3] LYB[0] LYB[1] ND_SEL[0]
+   ND_SEL[1] ND_SEL[2] ND_SEL[3] ND_SEL[4] ND_SEL[5] ND_SEL[6] ND_SEL[7]
+   ND_SEL[8] ND_SEL[9] ND_SEL[10] ND_SEL[11] ND_SEL[12] ND_SEL[13] ND_SEL[14]
+   ND_SEL[15] ND_WB[0] ND_WB[1] ND_WB[2] ND_WB[3] ND_WB[4] ND_WB[5] ND_WB[6]
+   ND_WB[7] ND_WB[8] ND_WB[9] ND_WB[10] ND_WB[11] ND_WB[12] ND_WB[13] ND_WB[14]
+   ND_WB[15] ND_WT[0] ND_WT[1] ND_WT[2] ND_WT[3] ND_WT[4] ND_WT[5] ND_WT[6]
+   ND_WT[7] ND_WT[8] ND_WT[9] ND_WT[10] ND_WT[11] ND_WT[12] ND_WT[13] ND_WT[14]
+   ND_WT[15] Q[0] Q[1] Q[2] Q[3] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6]
+   QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13]
+   QT[14] QT[15] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8]
+   SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] VBN[0] VBN[1] VBN[2]
+   VBN[3] VBP[0] VBP[1] VBP[2] VBP[3] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI_DR[0]
+   VDDPI_DR[1] VDDPI_DR[2] VDDPI_DR[3] VSS[0] VSS[1] VSS[2] VSS[3] WB_IN[0]
+   WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8]
+   WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WEM[0]
+   WEM[1] WEM[2] WEM[3] WEMB[0] WEMB[1] WEMB[2] WEMB[3] WEM_AL[0] WEM_AL[1]
+   WEM_AL[2] WEM_AL[3] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5]
+   WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13]
+   WT_IN[14] WT_IN[15] SNPS_SP_HD_16Kx8_gio_lt_seg1
X_mm16a05_u_hdsp_plus_capgio VDDP[8] VDDPI[4] VSS[4] VBP[4] VBN[4] LOG0 LOG1
+   PWDO VEDGE mm16a05_u_hdsp_plus_capgio
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_gio_row ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1]
+       ARYSD_BC2[0] ARYSD_BC2[1] BC0 BC1 BC2 CB[0] CB[1] CB[2] CB[3] CB[4]
+       CB[5] CB[6] CB[7] CENDP CLK CLKB CLKDEL CLKFLT CLK_MUXB CT[0] CT[1]
+       CT[2] CT[3] CT[4] CT[5] CT[6] CT[7] D[0] D[1] D[2] D[3] D[4] D[5] D[6]
+       D[7] DEF1 DEF12B_PROG DEF12_PROG DEF1B DEF2 DEF2B DEF_MODE DEF_PROG
+       DFTCLKEN DIB[0] DIB[1] DIB[2] DIB[3] DIB[4] DIB[5] DIB[6] DIB[7] DINB[0]
+       DINB[1] DINB[2] DINB[3] DINB[4] DINB[5] DINB[6] DINB[7] DISCHG DLYPDBL
+       DLYPDBR DLYPW D_AL[0] D_AL[1] D_AL[2] D_AL[3] D_AL[4] D_AL[5] D_AL[6]
+       D_AL[7] FAST1_MODE FAST2_MODE FISO FLOAT FLOATT FLOAT_RET GSE_DB[0]
+       GSE_DB[1] GSE_DT[0] GSE_DT[1] IV_SEL[0] IV_SEL[1] IV_SEL[2] IV_SEL[3]
+       IV_SEL[4] IV_SEL[5] IV_SEL[6] IV_SEL[7] IV_SEL[8] IV_SEL[9] IV_SEL[10]
+       IV_SEL[11] IV_SEL[12] IV_SEL[13] IV_SEL[14] IV_SEL[15] IV_SEL[16]
+       IV_SEL[17] IV_SEL[18] IV_SEL[19] IV_SEL[20] IV_SEL[21] IV_SEL[22]
+       IV_SEL[23] IV_SEL[24] IV_SEL[25] IV_SEL[26] IV_SEL[27] IV_SEL[28]
+       IV_SEL[29] IV_SEL[30] IV_SEL[31] IV_WB[0] IV_WB[1] IV_WB[2] IV_WB[3]
+       IV_WB[4] IV_WB[5] IV_WB[6] IV_WB[7] IV_WB[8] IV_WB[9] IV_WB[10]
+       IV_WB[11] IV_WB[12] IV_WB[13] IV_WB[14] IV_WB[15] IV_WB[16] IV_WB[17]
+       IV_WB[18] IV_WB[19] IV_WB[20] IV_WB[21] IV_WB[22] IV_WB[23] IV_WB[24]
+       IV_WB[25] IV_WB[26] IV_WB[27] IV_WB[28] IV_WB[29] IV_WB[30] IV_WB[31]
+       IV_WT[0] IV_WT[1] IV_WT[2] IV_WT[3] IV_WT[4] IV_WT[5] IV_WT[6] IV_WT[7]
+       IV_WT[8] IV_WT[9] IV_WT[10] IV_WT[11] IV_WT[12] IV_WT[13] IV_WT[14]
+       IV_WT[15] IV_WT[16] IV_WT[17] IV_WT[18] IV_WT[19] IV_WT[20] IV_WT[21]
+       IV_WT[22] IV_WT[23] IV_WT[24] IV_WT[25] IV_WT[26] IV_WT[27] IV_WT[28]
+       IV_WT[29] IV_WT[30] IV_WT[31] LBKADR0 LBKADR1 LBKADR2 LCLKB LCLKT LDFTX
+       LDFTYBUF[0] LDFTYBUF[1] LDIB[0] LDIB[1] LDIB[2] LDIB[3] LDIB[4] LDIB[5]
+       LDIB[6] LDIB[7] LITESLP LME LOG0 LOG1 LOG1_RM LQB[0] LQB[1] LQB[2]
+       LQB[3] LQB[4] LQB[5] LQB[6] LQB[7] LS LWE LWEIB LWIB[0] LWIB[1] LWIB[2]
+       LWIB[3] LWIB[4] LWIB[5] LWIB[6] LWIB[7] LXADR[0] LXADR[1] LXADR[2]
+       LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] LY_ONE
+       LY_TWO MCLKB MCLKT ME MEB_I MEB_LT MEORDFTCLKEN MEORDFTCLKEN_IN
+       ND_SEL[0] ND_SEL[1] ND_SEL[2] ND_SEL[3] ND_SEL[4] ND_SEL[5] ND_SEL[6]
+       ND_SEL[7] ND_SEL[8] ND_SEL[9] ND_SEL[10] ND_SEL[11] ND_SEL[12]
+       ND_SEL[13] ND_SEL[14] ND_SEL[15] ND_SEL[16] ND_SEL[17] ND_SEL[18]
+       ND_SEL[19] ND_SEL[20] ND_SEL[21] ND_SEL[22] ND_SEL[23] ND_SEL[24]
+       ND_SEL[25] ND_SEL[26] ND_SEL[27] ND_SEL[28] ND_SEL[29] ND_SEL[30]
+       ND_SEL[31] ND_WB[0] ND_WB[1] ND_WB[2] ND_WB[3] ND_WB[4] ND_WB[5]
+       ND_WB[6] ND_WB[7] ND_WB[8] ND_WB[9] ND_WB[10] ND_WB[11] ND_WB[12]
+       ND_WB[13] ND_WB[14] ND_WB[15] ND_WB[16] ND_WB[17] ND_WB[18] ND_WB[19]
+       ND_WB[20] ND_WB[21] ND_WB[22] ND_WB[23] ND_WB[24] ND_WB[25] ND_WB[26]
+       ND_WB[27] ND_WB[28] ND_WB[29] ND_WB[30] ND_WB[31] ND_WT[0] ND_WT[1]
+       ND_WT[2] ND_WT[3] ND_WT[4] ND_WT[5] ND_WT[6] ND_WT[7] ND_WT[8] ND_WT[9]
+       ND_WT[10] ND_WT[11] ND_WT[12] ND_WT[13] ND_WT[14] ND_WT[15] ND_WT[16]
+       ND_WT[17] ND_WT[18] ND_WT[19] ND_WT[20] ND_WT[21] ND_WT[22] ND_WT[23]
+       ND_WT[24] ND_WT[25] ND_WT[26] ND_WT[27] ND_WT[28] ND_WT[29] ND_WT[30]
+       ND_WT[31] PWDO[0] PWDO[1] Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] QB[0]
+       QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+       QB[12] QB[13] QB[14] QB[15] QB[16] QB[17] QB[18] QB[19] QB[20] QB[21]
+       QB[22] QB[23] QB[24] QB[25] QB[26] QB[27] QB[28] QB[29] QB[30] QB[31]
+       QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10]
+       QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17] QT[18] QT[19] QT[20]
+       QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28] QT[29] QT[30]
+       QT[31] RA[0] RA[1] RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RM[0]
+       RM[1] RM[2] RM[3] RM3CNT RMDEF1[0] RMDEF1[1] RMDEF1[2] RMDEF1[3]
+       RMDEF2[0] RMDEF2[1] RMDEF2[2] RMDEF2[3] RME RMENI[0] RMENI[1] RMENI[2]
+       RMSLOW[0] RMSLOW[1] RMSLOW[2] RMSLOW[3] RMT[0] RMT[1] RMT[2] RMT[3]
+       RSCEN RSCIN RSCLK RSCOUT RSCRST RWLCKB SD SEL[0] SEL[1] SEL[2] SEL[3]
+       SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+       SEL[13] SEL[14] SEL[15] SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21]
+       SEL[22] SEL[23] SEL[24] SEL[25] SEL[26] SEL[27] SEL[28] SEL[29] SEL[30]
+       SEL[31] SE_IN T1T TEST1 TEST_RNM TEST_RNMB VBN[0] VBN[1] VBN[2] VBN[3]
+       VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBP[0]
+       VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10]
+       VBP[11] VBP[12] VDDA[0] VDDA[1] VDDA[2] VDDMINB VDDP[0] VDDP[1] VDDP[2]
+       VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+       VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+       VDDP[19] VDDP[20] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5]
+       VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+       VDDPI_DR[0] VDDPI_DR[1] VDDPI_DR[2] VDDPI_DR[3] VDDPI_DR[4] VDDPI_DR[5]
+       VDDPI_DR[6] VDDPI_DR[7] VEDGE[0] VEDGE[1] VSS[0] VSS[1] VSS[2] VSS[3]
+       VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] WA[0]
+       WA[1] WABUF[0] WABUF[1] WABUF[2] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3]
+       WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10]
+       WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WB_IN[16] WB_IN[17]
+       WB_IN[18] WB_IN[19] WB_IN[20] WB_IN[21] WB_IN[22] WB_IN[23] WB_IN[24]
+       WB_IN[25] WB_IN[26] WB_IN[27] WB_IN[28] WB_IN[29] WB_IN[30] WB_IN[31] WE
+       WEM[0] WEM[1] WEM[2] WEM[3] WEM[4] WEM[5] WEM[6] WEM[7] WEMB[0] WEMB[1]
+       WEMB[2] WEMB[3] WEMB[4] WEMB[5] WEMB[6] WEMB[7] WEM_AL[0] WEM_AL[1]
+       WEM_AL[2] WEM_AL[3] WEM_AL[4] WEM_AL[5] WEM_AL[6] WEM_AL[7] WFLOAT
+       WMDEF1[0] WMDEF1[1] WMDEF1[2] WMDEF1[3] WMDEF2[0] WMDEF2[1] WMDEF2[2]
+       WMDEF2[3] WMSLOW[0] WMSLOW[1] WMSLOW[2] WMSLOW[3] WMT[0] WMT[1] WMT[2]
+       WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WPULSE[0] WPULSE[1] WPULSE[2] WT_IN[0]
+       WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8]
+       WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15]
+       WT_IN[16] WT_IN[17] WT_IN[18] WT_IN[19] WT_IN[20] WT_IN[21] WT_IN[22]
+       WT_IN[23] WT_IN[24] WT_IN[25] WT_IN[26] WT_IN[27] WT_IN[28] WT_IN[29]
+       WT_IN[30] WT_IN[31] XADR[0] XADR[1] XADR[2] XADR[3] XADR[4] XADR[5]
+       XADR[6] XADR[7] XBKADR[0] XBKADR[1] XBKADR[2] YADR[0] YADR[1] YADR[2]
+       YADR[3]
X_gio_lt CB[0] CB[1] CB[2] CB[3] CT[0] CT[1] CT[2] CT[3] D[0] D[1] D[2] D[3]
+   DCLKT[0] DIB[0] DIB[1] DIB[2] DIB[3] DINB[0] DINB[1] DINB[2] DINB[3] DLYPDBL
+   D_AL[0] D_AL[1] D_AL[2] D_AL[3] GSE_DB[0] GSE_DT[0] IV_SEL[0] IV_SEL[1]
+   IV_SEL[2] IV_SEL[3] IV_SEL[4] IV_SEL[5] IV_SEL[6] IV_SEL[7] IV_SEL[8]
+   IV_SEL[9] IV_SEL[10] IV_SEL[11] IV_SEL[12] IV_SEL[13] IV_SEL[14] IV_SEL[15]
+   IV_WB[0] IV_WB[1] IV_WB[2] IV_WB[3] IV_WB[4] IV_WB[5] IV_WB[6] IV_WB[7]
+   IV_WB[8] IV_WB[9] IV_WB[10] IV_WB[11] IV_WB[12] IV_WB[13] IV_WB[14]
+   IV_WB[15] IV_WT[0] IV_WT[1] IV_WT[2] IV_WT[3] IV_WT[4] IV_WT[5] IV_WT[6]
+   IV_WT[7] IV_WT[8] IV_WT[9] IV_WT[10] IV_WT[11] IV_WT[12] IV_WT[13] IV_WT[14]
+   IV_WT[15] LDFTYBUF[0] LDIB[0] LDIB[1] LDIB[2] LDIB[3] LOG0 LOG1 LQB[0]
+   LQB[1] LQB[2] LQB[3] LWIB[0] LWIB[1] LWIB[2] LWIB[3] LYBL[0] LYBL[1]
+   ND_SEL[0] ND_SEL[1] ND_SEL[2] ND_SEL[3] ND_SEL[4] ND_SEL[5] ND_SEL[6]
+   ND_SEL[7] ND_SEL[8] ND_SEL[9] ND_SEL[10] ND_SEL[11] ND_SEL[12] ND_SEL[13]
+   ND_SEL[14] ND_SEL[15] ND_WB[0] ND_WB[1] ND_WB[2] ND_WB[3] ND_WB[4] ND_WB[5]
+   ND_WB[6] ND_WB[7] ND_WB[8] ND_WB[9] ND_WB[10] ND_WB[11] ND_WB[12] ND_WB[13]
+   ND_WB[14] ND_WB[15] ND_WT[0] ND_WT[1] ND_WT[2] ND_WT[3] ND_WT[4] ND_WT[5]
+   ND_WT[6] ND_WT[7] ND_WT[8] ND_WT[9] ND_WT[10] ND_WT[11] ND_WT[12] ND_WT[13]
+   ND_WT[14] ND_WT[15] PWDO[0] Q[0] Q[1] Q[2] Q[3] QB[0] QB[1] QB[2] QB[3]
+   QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14]
+   QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10]
+   QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5]
+   SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4]
+   VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8]
+   VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI_DR[0] VDDPI_DR[1]
+   VDDPI_DR[2] VDDPI_DR[3] VEDGE[0] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] WB_IN[0]
+   WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8]
+   WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WEM[0]
+   WEM[1] WEM[2] WEM[3] WEMB[0] WEMB[1] WEMB[2] WEMB[3] WEM_AL[0] WEM_AL[1]
+   WEM_AL[2] WEM_AL[3] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5]
+   WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13]
+   WT_IN[14] WT_IN[15] SNPS_SP_HD_16Kx8_gio_lt
X_gio_cnt ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1]
+   BC0 BC1 BC2 CENDP CLK CLKB CLKDEL CLKFLT CLK_MUXB DCLKT[0] DCLKT[1] DEF1
+   DEF12B_PROG DEF12_PROG DEF1B DEF2 DEF2B DEF_MODE DEF_PROG DFTCLKEN DISCHG
+   DLYPDBL DLYPDBR DLYPW FAST1_MODE FAST2_MODE FISO FLOAT FLOATT FLOAT_RET
+   GSE_DB[0] GSE_DB[1] GSE_DT[0] GSE_DT[1] LBKADR0 LBKADR1 LBKADR2 LCLKB LCLKT
+   LDFTX LDFTYBUF[0] LDFTYBUF[1] LITESLP LME LOG0 LOG1 LOG1_RM LS LWE LWEIB
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] LYBH[0] LYBH[1] LYBL[0] LYBL[1] LY_ONE LY_TWO MCLKB MCLKT
+   ME MEB_I MEB_LT MEORDFTCLKEN MEORDFTCLKEN_IN RA[0] RA[1] RASSIST[0]
+   RASSIST[1] RASSIST[2] RASSIST[3] RM[0] RM[1] RM[2] RM[3] RM3CNT RMDEF1[0]
+   RMDEF1[1] RMDEF1[2] RMDEF1[3] RMDEF2[0] RMDEF2[1] RMDEF2[2] RMDEF2[3] RME
+   RMENI[0] RMENI[1] RMENI[2] RMSLOW[0] RMSLOW[1] RMSLOW[2] RMSLOW[3] RMT[0]
+   RMT[1] RMT[2] RMT[3] RSCEN RSCIN RSCLK RSCOUT RSCRST RWLCKB SD SE_IN T1T
+   TEST1 TEST_RNM TEST_RNMB VBN[5] VBN[6] VBN[7] VBP[5] VBP[6] VBP[7] VDDA[0]
+   VDDA[1] VDDA[2] VDDF VDDMINB VDDP[9] VDDP[10] VDDP[11] VDDPI[5] VDDPI[6]
+   VDDPI[7] VSS[5] VSS[6] VSS[7] WA[0] WA[1] WABUF[0] WABUF[1] WABUF[2] WE
+   WFLOAT WMDEF1[0] WMDEF1[1] WMDEF1[2] WMDEF1[3] WMDEF2[0] WMDEF2[1] WMDEF2[2]
+   WMDEF2[3] WMSLOW[0] WMSLOW[1] WMSLOW[2] WMSLOW[3] WMT[0] WMT[1] WMT[2]
+   WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WPULSE[0] WPULSE[1] WPULSE[2] XADR[0]
+   XADR[1] XADR[2] XADR[3] XADR[4] XADR[5] XADR[6] XADR[7] XBKADR[0] XBKADR[1]
+   XBKADR[2] YADR[0] YADR[1] YADR[2] YADR[3] SNPS_SP_HD_16Kx8_gio_cnt
X_gio_rt CB[4] CB[5] CB[6] CB[7] CT[4] CT[5] CT[6] CT[7] D[4] D[5] D[6] D[7]
+   DCLKT[1] DIB[4] DIB[5] DIB[6] DIB[7] DINB[4] DINB[5] DINB[6] DINB[7] DLYPDBR
+   D_AL[4] D_AL[5] D_AL[6] D_AL[7] GSE_DB[1] GSE_DT[1] IV_SEL[16] IV_SEL[17]
+   IV_SEL[18] IV_SEL[19] IV_SEL[20] IV_SEL[21] IV_SEL[22] IV_SEL[23] IV_SEL[24]
+   IV_SEL[25] IV_SEL[26] IV_SEL[27] IV_SEL[28] IV_SEL[29] IV_SEL[30] IV_SEL[31]
+   IV_WB[16] IV_WB[17] IV_WB[18] IV_WB[19] IV_WB[20] IV_WB[21] IV_WB[22]
+   IV_WB[23] IV_WB[24] IV_WB[25] IV_WB[26] IV_WB[27] IV_WB[28] IV_WB[29]
+   IV_WB[30] IV_WB[31] IV_WT[16] IV_WT[17] IV_WT[18] IV_WT[19] IV_WT[20]
+   IV_WT[21] IV_WT[22] IV_WT[23] IV_WT[24] IV_WT[25] IV_WT[26] IV_WT[27]
+   IV_WT[28] IV_WT[29] IV_WT[30] IV_WT[31] LDFTYBUF[1] LDIB[4] LDIB[5] LDIB[6]
+   LDIB[7] LOG0 LOG1 LQB[4] LQB[5] LQB[6] LQB[7] LWIB[4] LWIB[5] LWIB[6]
+   LWIB[7] LYBH[0] LYBH[1] ND_SEL[16] ND_SEL[17] ND_SEL[18] ND_SEL[19]
+   ND_SEL[20] ND_SEL[21] ND_SEL[22] ND_SEL[23] ND_SEL[24] ND_SEL[25] ND_SEL[26]
+   ND_SEL[27] ND_SEL[28] ND_SEL[29] ND_SEL[30] ND_SEL[31] ND_WB[16] ND_WB[17]
+   ND_WB[18] ND_WB[19] ND_WB[20] ND_WB[21] ND_WB[22] ND_WB[23] ND_WB[24]
+   ND_WB[25] ND_WB[26] ND_WB[27] ND_WB[28] ND_WB[29] ND_WB[30] ND_WB[31]
+   ND_WT[16] ND_WT[17] ND_WT[18] ND_WT[19] ND_WT[20] ND_WT[21] ND_WT[22]
+   ND_WT[23] ND_WT[24] ND_WT[25] ND_WT[26] ND_WT[27] ND_WT[28] ND_WT[29]
+   ND_WT[30] ND_WT[31] PWDO[1] Q[4] Q[5] Q[6] Q[7] QB[16] QB[17] QB[18] QB[19]
+   QB[20] QB[21] QB[22] QB[23] QB[24] QB[25] QB[26] QB[27] QB[28] QB[29] QB[30]
+   QB[31] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] SEL[16] SEL[17] SEL[18] SEL[19]
+   SEL[20] SEL[21] SEL[22] SEL[23] SEL[24] SEL[25] SEL[26] SEL[27] SEL[28]
+   SEL[29] SEL[30] SEL[31] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBP[8] VBP[9]
+   VBP[10] VBP[11] VBP[12] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16]
+   VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI_DR[4] VDDPI_DR[5] VDDPI_DR[6] VDDPI_DR[7] VEDGE[1] VSS[8]
+   VSS[9] VSS[10] VSS[11] VSS[12] WB_IN[16] WB_IN[17] WB_IN[18] WB_IN[19]
+   WB_IN[20] WB_IN[21] WB_IN[22] WB_IN[23] WB_IN[24] WB_IN[25] WB_IN[26]
+   WB_IN[27] WB_IN[28] WB_IN[29] WB_IN[30] WB_IN[31] WEM[4] WEM[5] WEM[6]
+   WEM[7] WEMB[4] WEMB[5] WEMB[6] WEMB[7] WEM_AL[4] WEM_AL[5] WEM_AL[6]
+   WEM_AL[7] WT_IN[16] WT_IN[17] WT_IN[18] WT_IN[19] WT_IN[20] WT_IN[21]
+   WT_IN[22] WT_IN[23] WT_IN[24] WT_IN[25] WT_IN[26] WT_IN[27] WT_IN[28]
+   WT_IN[29] WT_IN[30] WT_IN[31] SNPS_SP_HD_16Kx8_gio_rt
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_lt_seg1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+       BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+       BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+       BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] LLSB LOG0 LOG1 QB[0]
+       QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+       QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+       QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SDB_BC1T
+       SDB_BC2T SDOR SDOR_RET SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+       SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15]
+       VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9]
+       VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBN[0] VBN[1] VBN[2]
+       VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12]
+       VBN[13] VBN[14] VBN[15] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+       VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15]
+       VDDA VDDAI[0] VDDAI[1] VDDAI[2] VDDAI[3] VDDAI[4] VDDAI[5] VDDAI[6]
+       VDDAI[7] VDDAI[8] VDDAI[9] VDDAI[10] VDDAI[11] VDDAI[12] VDDAI[13]
+       VDDAI[14] VDDAI[15] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5]
+       VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+       VDDP[14] VDDP[15] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5]
+       VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+       VDDPI[13] VDDPI[14] VDDPI[15] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+       VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14]
+       VSS[15] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8]
+       WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WTI[0] WTI[1]
+       WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11]
+       WTI[12] WTI[13] WTI[14] WTI[15]

*** Jumper Report ***
* Jumper: VBA[0] VSS[0]
* Jumper: VBA[1] VSS[1]
* Jumper: VBA[2] VSS[2]
* Jumper: VBA[3] VSS[3]
* Jumper: VBA[4] VSS[4]
* Jumper: VBA[5] VSS[5]
* Jumper: VBA[6] VSS[6]
* Jumper: VBA[7] VSS[7]
* Jumper: VBA[8] VSS[8]
* Jumper: VBA[9] VSS[9]
* Jumper: VBA[10] VSS[10]
* Jumper: VBA[11] VSS[11]
* Jumper: VBA[12] VSS[12]
* Jumper: VBA[13] VSS[13]
* Jumper: VBA[14] VSS[14]
* Jumper: VBA[15] VSS[15]

X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_S0 VDDA VDDAI[0] VDDP[0] VDDPI[0] VSS[0]
+   VBP[0] VBN[0] BB[0] BB[1] BB[2] BB[3] LOG0 LOG1 QB[0] QT[0] SDOR SDOR_RET
+   SEL[0] VBA[0] WBI[0] WTI[0] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_S1 VDDA VDDAI[1] VDDP[1] VDDPI[1] VSS[1]
+   VBP[1] VBN[1] BB[4] BB[5] BB[6] BB[7] LOG0 LOG1 QB[1] QT[1] SDOR SDOR_RET
+   SEL[1] VBA[1] WBI[1] WTI[1] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_S2 VDDA VDDAI[2] VDDP[2] VDDPI[2] VSS[2]
+   VBP[2] VBN[2] BB[8] BB[9] BB[10] BB[11] LOG0 LOG1 QB[2] QT[2] SDOR SDOR_RET
+   SEL[2] VBA[2] WBI[2] WTI[2] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_S3 VDDA VDDAI[3] VDDP[3] VDDPI[3] VSS[3]
+   VBP[3] VBN[3] BB[12] BB[13] BB[14] BB[15] LOG0 LOG1 QB[3] QT[3] SDOR
+   SDOR_RET SEL[3] VBA[3] WBI[3] WTI[3] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_S4 VDDA VDDAI[4] VDDP[4] VDDPI[4] VSS[4]
+   VBP[4] VBN[4] BB[16] BB[17] BB[18] BB[19] LOG0 LOG1 QB[4] QT[4] SDOR
+   SDOR_RET SEL[4] VBA[4] WBI[4] WTI[4] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_S5 VDDA VDDAI[5] VDDP[5] VDDPI[5] VSS[5]
+   VBP[5] VBN[5] BB[20] BB[21] BB[22] BB[23] LOG0 LOG1 QB[5] QT[5] SDOR
+   SDOR_RET SEL[5] VBA[5] WBI[5] WTI[5] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_S6 VDDA VDDAI[6] VDDP[6] VDDPI[6] VSS[6]
+   VBP[6] VBN[6] BB[24] BB[25] BB[26] BB[27] LOG0 LOG1 QB[6] QT[6] SDOR
+   SDOR_RET SEL[6] VBA[6] WBI[6] WTI[6] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_S7 VDDA VDDAI[7] VDDP[7] VDDPI[7] VSS[7]
+   VBP[7] VBN[7] BB[28] BB[29] BB[30] BB[31] LOG0 LOG1 QB[7] QT[7] SDOR
+   SDOR_RET SEL[7] VBA[7] WBI[7] WTI[7] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_F7 VDDA VDDAI[8] VDDP[8] VDDPI[8] VSS[8]
+   VBP[8] VBN[8] BB[32] BB[33] BB[34] BB[35] LOG0 LOG1 QB[8] QT[8] SDOR
+   SDOR_RET SEL[8] VBA[8] WBI[8] WTI[8] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_F6 VDDA VDDAI[9] VDDP[9] VDDPI[9] VSS[9]
+   VBP[9] VBN[9] BB[36] BB[37] BB[38] BB[39] LOG0 LOG1 QB[9] QT[9] SDOR
+   SDOR_RET SEL[9] VBA[9] WBI[9] WTI[9] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_F5 VDDA VDDAI[10] VDDP[10] VDDPI[10]
+   VSS[10] VBP[10] VBN[10] BB[40] BB[41] BB[42] BB[43] LOG0 LOG1 QB[10] QT[10]
+   SDOR SDOR_RET SEL[10] VBA[10] WBI[10] WTI[10] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_F4 VDDA VDDAI[11] VDDP[11] VDDPI[11]
+   VSS[11] VBP[11] VBN[11] BB[44] BB[45] BB[46] BB[47] LOG0 LOG1 QB[11] QT[11]
+   SDOR SDOR_RET SEL[11] VBA[11] WBI[11] WTI[11] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_F3 VDDA VDDAI[12] VDDP[12] VDDPI[12]
+   VSS[12] VBP[12] VBN[12] BB[48] BB[49] BB[50] BB[51] LOG0 LOG1 QB[12] QT[12]
+   SDOR SDOR_RET SEL[12] VBA[12] WBI[12] WTI[12] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_F2 VDDA VDDAI[13] VDDP[13] VDDPI[13]
+   VSS[13] VBP[13] VBN[13] BB[52] BB[53] BB[54] BB[55] LOG0 LOG1 QB[13] QT[13]
+   SDOR SDOR_RET SEL[13] VBA[13] WBI[13] WTI[13] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_F1 VDDA VDDAI[14] VDDP[14] VDDPI[14]
+   VSS[14] VBP[14] VBN[14] BB[56] BB[57] BB[58] BB[59] LOG0 LOG1 QB[14] QT[14]
+   SDOR SDOR_RET SEL[14] VBA[14] WBI[14] WTI[14] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_F0 VDDA VDDAI[15] VDDP[15] VDDPI[15]
+   VSS[15] VBP[15] VBN[15] BB[60] BB[61] BB[62] BB[63] LOG0 LOG1 QB[15] QT[15]
+   SDOR SDOR_RET SEL[15] VBA[15] WBI[15] WTI[15] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_lt BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7]
+       BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17]
+       BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27]
+       BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37]
+       BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47]
+       BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57]
+       BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] LLSB LOG0 LOG1 PGIOI QB[0]
+       QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+       QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+       QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SDB_BC1T
+       SDB_BC2T SDOR SDOR_RET SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+       SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15]
+       TOPEDGE VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8]
+       VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16] VBN[0]
+       VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10]
+       VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2]
+       VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+       VBP[13] VBP[14] VBP[15] VBP[16] VDDA VDDAIL1 VDDP[0] VDDP[1] VDDP[2]
+       VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+       VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1]
+       VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9]
+       VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16]
+       VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+       VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] WBI[0]
+       WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10]
+       WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WTI[0] WTI[1] WTI[2] WTI[3]
+       WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12]
+       WTI[13] WTI[14] WTI[15]

*** Jumper Report ***
* Jumper: LOG1 PGIOI

X_mm16a05_u_hdsp_plus_pg_pwedge_wk_bk2_bot VDDA VDDP[0] VDDPI[0] VSS[0] VBP[0]
+   VBN[0] LOG0 LOG1 PGIOI PO SDOR_RET TOPEDGE VBA[0] VEDGE SDOR
+   mm16a05_u_hdsp_plus_pg_pwedge
X_ref_lt_seg1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] LLSB LOG0
+   LOG1 QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SDB_BC1T
+   SDB_BC2T SDOR SDOR_RET SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+   SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] VBA[1]
+   VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11]
+   VBA[12] VBA[13] VBA[14] VBA[15] VBA[16] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5]
+   VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15]
+   VBN[16] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9]
+   VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA VDDAIL1 VDDAIL1
+   VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1
+   VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5]
+   VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13]
+   VDDPI[14] VDDPI[15] VDDPI[16] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6]
+   VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9]
+   WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WTI[0] WTI[1] WTI[2] WTI[3]
+   WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13]
+   WTI[14] WTI[15] SNPS_SP_HD_16Kx8_ref_lt_seg1
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_buf_l ARYSDB_BC1 ARYSDB_BC2 ARYSD_BC1 ARYSD_BC2
+       ARYSD_IN ARYSD_OUT ARYSD_TOP LCGTH LLSB LOG0 LOG1 PO RASSIST[0]
+       RASSIST[1] RASSISTB[0] RASSISTB[1] RWLB_RD RWLB_WR RWLD_RD RWLD_WR
+       RWL_RD RWL_WR SDOR_RETI TOPEDGE VBA VBN VBP VDDA VDDP VDDPI VDDWL VSS
X_mm16a05_u_hdsp_plus_rwbuf_wk_bk2_left_bot VDDA VDDP VDDPI VDDWL VSS VBP VBN
+   ARYSDB_BC1 ARYSDB_BC2 ARYSD_TOP LLSB RWL_RD RWL_WR ARYSD_OUT LOG0 LOG1 PO
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] RWLD_RD RWLD_WR TOPEDGE VBA
+   ARYSD_BC1 ARYSD_BC2 ARYSD_IN LCGTH RWLB_RD RWLB_WR SDOR_RETI
+   mm16a05_u_hdsp_plus_rwbuf_wk_bk2_left
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_cnt ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+       ARYSD_BC2[1] ARYSD_IN[0] ARYSD_IN[1] ARYSD_TOP[0] ARYSD_TOP[1] CENDP
+       DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR0 LBKADR1
+       LCGTH[0] LCGTH[1] LDFTX LITESLP LLBKADRB[0] LLBKADRB[1] LLSB[0] LLSB[1]
+       LMATCHB LMATCHB_I LOG0[0] LOG0[1] LOG0[2] LOG0[3] LOG1[0] LOG1[1]
+       LOG1[2] LOG1[3] LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+       LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PLBKADR[0] PLBKADR[1]
+       RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RASSISTB[0] RASSISTB[1]
+       RASSISTB[2] RASSISTB[3] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2]
+       RMT[3] RWLB_RD RWLB_SAC RWLB_WR RWLD_RD RWLD_WR RWL_RD[1] RWL_WR[1]
+       SDB_BC1T[0] SDB_BC1T[1] SDB_BC2T[0] SDB_BC2T[1] SDOR[0] SDOR[1]
+       SDOR_RET[0] SDOR_RET[1] T1T TEST_RNMB TOPEDGE[0] TOPEDGE[1] VBA[0]
+       VBA[1] VBN[0] VBN[1] VBN[2] VBP[0] VBP[1] VBP[2] VDDA[0] VDDA[1] VDDA[2]
+       VDDMINB VDDP[0] VDDP[1] VDDP[2] VDDPI[0] VDDPI[1] VDDPI[2] VDDWL[0]
+       VDDWL[1] VSS[0] VSS[1] VSS[2] WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1]
+       WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]

*** Jumper Report ***
* Jumper: VDDA[1] VDDP[1] VDDPI[1]

X_ref_buf_l SDB_BC1T[0] SDB_BC2T[0] ARYSD_BC1[0] ARYSD_BC2[0] ARYSD_IN[0]
+   SDOR[0] ARYSD_TOP[0] LCGTH[0] LLSB[0] LOG0[0] LOG1[0] PO[0] RASSIST[0]
+   RASSIST[1] RASSISTB[0] RASSISTB[1] LOG1[1] LOG1[2] LOG0[1] LOG0[2] RWL_RD[0]
+   RWL_WR[0] SDOR_RET[0] TOPEDGE[0] VBA[0] VBN[0] VBP[0] VDDA[0] VDDP[0]
+   VDDPI[0] VDDWL[0] VSS[0] SNPS_SP_HD_16Kx8_ref_buf_l
X_mm16a05_u_hdsp_plus_rw_wk_bk2_bot VDDA[1] VDDMINB VDDP[1] VDDPI[1] VSS[1]
+   VBP[1] VBN[1] RWLB_RD RWLB_WR CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT_RET
+   LBKADR0 LBKADR1 LBKADR LDFTX LITESLP LLBKADRB[0] LLBKADRB[1] LMATCHB
+   LMATCHB_I LOG0[3] LOG1[3] LWEIB_HV LXADR[0] LXADR[1] LXADR[2] LXADR[3]
+   LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PLBKADR[0] PLBKADR[1]
+   RBLRD RBLWA RBLWR RM3CNT RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2]
+   WPBUF[0] WPBUF[1] WPBUF[2] FLOAT FLOATT LWEIB RMT[0] RMT[1] RMT[2] RMT[3]
+   RWLD_RD RWLD_WR WMT[0] WMT[1] WMT[2] WMT[3] mm16a05_u_hdsp_plus_rw_wk_bk2
X_mm16a05_u_hdsp_plus_rwbuf_wk_bk2_bot VDDA[2] VDDP[2] VDDPI[2] VDDWL[1] VSS[2]
+   VBP[2] VBN[2] SDB_BC1T[1] SDB_BC2T[1] ARYSD_TOP[1] LCGTHB LLSB[1] RWL_RD[1]
+   RWL_WR[1] ARYSD_IN[1] SDOR[1] LOG0[3] LOG1[3] PO[1] RASSIST[2] RASSIST[3]
+   RASSISTB[2] RASSISTB[3] RWLD_RD RWLD_WR TOPEDGE[1] VBA[1] ARYSD_BC1[1]
+   ARYSD_BC2[1] LCGTH[1] RWLB_RD RWLB_WR SDOR_RET[1]
+   mm16a05_u_hdsp_plus_rwbuf_wk_bk2
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_rt_rwl BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] LLSB LOG0 LOG1 QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QT[0]
+       QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] SDB_BC1T SDB_BC2T SDOR SDOR_RET
+       SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] VBA[0] VBA[1] VBA[2]
+       VBA[3] VBA[4] VBA[5] VBA[6] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5]
+       VBN[6] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VDDA VDDAI[0]
+       VDDAI[1] VDDAI[2] VDDAI[3] VDDAI[4] VDDAI[5] VDDAI[6] VDDP[0] VDDP[1]
+       VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDPI[0] VDDPI[1] VDDPI[2]
+       VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4]
+       VSS[5] VSS[6] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WTI[0]
+       WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]

*** Jumper Report ***
* Jumper: VBA[0] VSS[0]
* Jumper: VBA[1] VSS[1]
* Jumper: VBA[2] VSS[2]
* Jumper: VBA[3] VSS[3]
* Jumper: VBA[4] VSS[4]
* Jumper: VBA[5] VSS[5]
* Jumper: VBA[6] VSS[6]

X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_S0 VDDA VDDAI[0] VDDP[0] VDDPI[0] VSS[0]
+   VBP[0] VBN[0] BB[0] BB[1] BB[2] BB[3] LOG0 LOG1 QB[0] QT[0] SDOR SDOR_RET
+   SEL[0] VBA[0] WBI[0] WTI[0] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_S1 VDDA VDDAI[1] VDDP[1] VDDPI[1] VSS[1]
+   VBP[1] VBN[1] BB[4] BB[5] BB[6] BB[7] LOG0 LOG1 QB[1] QT[1] SDOR SDOR_RET
+   SEL[1] VBA[1] WBI[1] WTI[1] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_S2 VDDA VDDAI[2] VDDP[2] VDDPI[2] VSS[2]
+   VBP[2] VBN[2] BB[8] BB[9] BB[10] BB[11] LOG0 LOG1 QB[2] QT[2] SDOR SDOR_RET
+   SEL[2] VBA[2] WBI[2] WTI[2] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_F3 VDDA VDDAI[3] VDDP[3] VDDPI[3] VSS[3]
+   VBP[3] VBN[3] BB[12] BB[13] BB[14] BB[15] LOG0 LOG1 QB[3] QT[3] SDOR
+   SDOR_RET SEL[3] VBA[3] WBI[3] WTI[3] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_F2 VDDA VDDAI[4] VDDP[4] VDDPI[4] VSS[4]
+   VBP[4] VBN[4] BB[16] BB[17] BB[18] BB[19] LOG0 LOG1 QB[4] QT[4] SDOR
+   SDOR_RET SEL[4] VBA[4] WBI[4] WTI[4] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_F1 VDDA VDDAI[5] VDDP[5] VDDPI[5] VSS[5]
+   VBP[5] VBN[5] BB[20] BB[21] BB[22] BB[23] LOG0 LOG1 QB[5] QT[5] SDOR
+   SDOR_RET SEL[5] VBA[5] WBI[5] WTI[5] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_F0 VDDA VDDAI[6] VDDP[6] VDDPI[6] VSS[6]
+   VBP[6] VBN[6] BB[24] BB[25] BB[26] BB[27] LOG0 LOG1 QB[6] QT[6] SDOR
+   SDOR_RET SEL[6] VBA[6] WBI[6] WTI[6] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_cnt_rt_rwl ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+       ARYSD_BC2[1] ARYSD_IN[0] ARYSD_IN[1] ARYSD_TOP[0] ARYSD_TOP[1] BB[0]
+       BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11]
+       BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+       BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] CENDP DEF_MODE FAST1_MODE
+       FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR0 LBKADR1 LCGTH[0] LCGTH[1]
+       LDFTX LITESLP LLBKADRB[0] LLBKADRB[1] LLSB[0] LLSB[1] LMATCHB LMATCHB_I
+       LOG0[0] LOG0[1] LOG0[2] LOG0[3] LOG1[0] LOG1[1] LOG1[2] LOG1[3] LWEIB
+       LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+       LYADR[0] LYADR[1] PLBKADR[0] PLBKADR[1] QB[0] QB[1] QB[2] QB[3] QB[4]
+       QB[5] QB[6] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] RASSIST[0]
+       RASSIST[1] RASSIST[2] RASSIST[3] RASSISTB[0] RASSISTB[1] RASSISTB[2]
+       RASSISTB[3] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3]
+       RWLB_SAC SDB_BC1T[0] SDB_BC1T[1] SDB_BC2T[0] SDB_BC2T[1] SDOR[0] SDOR[1]
+       SDOR_RET[0] SDOR_RET[1] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+       T1T TEST_RNMB TOPEDGE[0] TOPEDGE[1] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4]
+       VBA[5] VBA[6] VBA[7] VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5]
+       VBN[6] VBN[7] VBN[8] VBN[9] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5]
+       VBP[6] VBP[7] VBP[8] VBP[9] VDDA[0] VDDA[1] VDDA[2] VDDAI[0] VDDAI[1]
+       VDDAI[2] VDDAI[3] VDDAI[4] VDDAI[5] VDDAI[6] VDDMINB VDDP[0] VDDP[1]
+       VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+       VDDPI[9] VDDWL[0] VDDWL[1] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+       VSS[6] VSS[7] VSS[8] VSS[9] WABUF[0] WABUF[1] WABUF[2] WBI[0] WBI[1]
+       WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0]
+       WPBUF[1] WPBUF[2] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
X_ref_cnt ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1] ARYSD_IN[0]
+   ARYSD_IN[1] ARYSD_TOP[0] ARYSD_TOP[1] CENDP DEF_MODE FAST1_MODE FAST2_MODE
+   FLOAT FLOATT FLOAT_RET LBKADR0 LBKADR1 LCGTH[0] LCGTH[1] LDFTX LITESLP
+   LLBKADRB[0] LLBKADRB[1] LLSB[0] LLSB[1] LMATCHB LMATCHB_I LOG0[0] LOG0[1]
+   LOG0[2] LOG0[3] LOG1[0] LOG1[1] LOG1[2] LOG1[3] LWEIB LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PLBKADR[0] PLBKADR[1] RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3]
+   RASSISTB[0] RASSISTB[1] RASSISTB[2] RASSISTB[3] RBLRD RBLWA RBLWR RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_RD RWLB_SAC RWLB_WR RWLD_RD RWLD_WR RWL_RD
+   RWL_WR SDB_BC1T[0] SDB_BC1T[1] SDB_BC2T[0] SDB_BC2T[1] SDOR[0] SDOR[1]
+   SDOR_RET[0] SDOR_RET[1] T1T TEST_RNMB TOPEDGE[0] TOPEDGE[1] VBA[0] VBA[1]
+   VBN[0] VBN[1] VBN[2] VBP[0] VBP[1] VBP[2] VDDA[0] VDDA[1] VDDA[2] VDDMINB
+   VDDP[0] VDDP[1] VDDP[2] VDDPI[0] VDDPI[1] VDDPI[2] VDDWL[0] VDDWL[1] VSS[0]
+   VSS[1] VSS[2] WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3]
+   WPBUF[0] WPBUF[1] WPBUF[2] SNPS_SP_HD_16Kx8_ref_cnt
X_ref_rt_rwl BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] LLSB[1] LOG0[3] LOG1[3] QB[0]
+   QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5]
+   QT[6] SDB_BC1T[1] SDB_BC2T[1] SDOR[1] SDOR_RET[1] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8]
+   VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBP[3] VBP[4] VBP[5] VBP[6]
+   VBP[7] VBP[8] VBP[9] VDDA[2] VDDAI[0] VDDAI[1] VDDAI[2] VDDAI[3] VDDAI[4]
+   VDDAI[5] VDDAI[6] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9]
+   VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VSS[3] VSS[4]
+   VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   SNPS_SP_HD_16Kx8_ref_rt_rwl
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_rt_log0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] LLSB LOG0 LOG1 QB[0] QB[1] QB[2]
+       QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+       QT[7] SDB_BC1T SDB_BC2T SDOR SDOR_RET SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+       SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+       VBA[7] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBP[0]
+       VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VDDA VDDAI[0] VDDAI[1]
+       VDDAI[2] VDDAI[3] VDDAI[4] VDDAI[5] VDDAI[6] VDDAI[7] VDDP[0] VDDP[1]
+       VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDPI[0] VDDPI[1]
+       VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VSS[0] VSS[1]
+       VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] WBI[0] WBI[1] WBI[2] WBI[3]
+       WBI[4] WBI[5] WBI[6] WBI[7] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+       WTI[6] WTI[7]

*** Jumper Report ***
* Jumper: VBA[0] VSS[0]
* Jumper: VBA[1] VSS[1]
* Jumper: VBA[2] VSS[2]
* Jumper: VBA[3] VSS[3]
* Jumper: VBA[4] VSS[4]
* Jumper: VBA[5] VSS[5]
* Jumper: VBA[6] VSS[6]
* Jumper: VBA[7] VSS[7]

X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_S0 VDDA VDDAI[0] VDDP[0] VDDPI[0] VSS[0]
+   VBP[0] VBN[0] BB[0] BB[1] BB[2] BB[3] LOG0 LOG1 QB[0] QT[0] SDOR SDOR_RET
+   SEL[0] VBA[0] WBI[0] WTI[0] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_S1 VDDA VDDAI[1] VDDP[1] VDDPI[1] VSS[1]
+   VBP[1] VBN[1] BB[4] BB[5] BB[6] BB[7] LOG0 LOG1 QB[1] QT[1] SDOR SDOR_RET
+   SEL[1] VBA[1] WBI[1] WTI[1] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_S2 VDDA VDDAI[2] VDDP[2] VDDPI[2] VSS[2]
+   VBP[2] VBN[2] BB[8] BB[9] BB[10] BB[11] LOG0 LOG1 QB[2] QT[2] SDOR SDOR_RET
+   SEL[2] VBA[2] WBI[2] WTI[2] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_S3 VDDA VDDAI[3] VDDP[3] VDDPI[3] VSS[3]
+   VBP[3] VBN[3] BB[12] BB[13] BB[14] BB[15] LOG0 LOG1 QB[3] QT[3] SDOR
+   SDOR_RET SEL[3] VBA[3] WBI[3] WTI[3] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_F3 VDDA VDDAI[4] VDDP[4] VDDPI[4] VSS[4]
+   VBP[4] VBN[4] BB[16] BB[17] BB[18] BB[19] LOG0 LOG1 QB[4] QT[4] SDOR
+   SDOR_RET SEL[4] VBA[4] WBI[4] WTI[4] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_F2 VDDA VDDAI[5] VDDP[5] VDDPI[5] VSS[5]
+   VBP[5] VBN[5] BB[20] BB[21] BB[22] BB[23] LOG0 LOG1 QB[5] QT[5] SDOR
+   SDOR_RET SEL[5] VBA[5] WBI[5] WTI[5] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_F1 VDDA VDDAI[6] VDDP[6] VDDPI[6] VSS[6]
+   VBP[6] VBN[6] BB[24] BB[25] BB[26] BB[27] LOG0 LOG1 QB[6] QT[6] SDOR
+   SDOR_RET SEL[6] VBA[6] WBI[6] WTI[6] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot_F0 VDDA VDDAI[7] VDDP[7] VDDPI[7] VSS[7]
+   VBP[7] VBN[7] BB[28] BB[29] BB[30] BB[31] LOG0 LOG1 QB[7] QT[7] SDOR
+   SDOR_RET SEL[7] VBA[7] WBI[7] WTI[7] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_row_mx_2 ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+       ARYSD_BC2[1] ARYSD_IN[0] ARYSD_IN[1] ARYSD_TOP[0] ARYSD_TOP[1] BB[0]
+       BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11]
+       BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+       BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31]
+       BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41]
+       BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51]
+       BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61]
+       BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+       BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81]
+       BB[82] BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91]
+       BB[92] BB[93] BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101]
+       BB[102] BB[103] BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110]
+       BB[111] BB[112] BB[113] BB[114] BB[115] BB[116] BB[117] BB[118] BB[119]
+       BB[120] BB[121] BB[122] BB[123] BB[124] BB[125] BB[126] BB[127] CENDP
+       DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR0 LBKADR1
+       LCGTH[0] LCGTH[1] LDFTX LITESLP LLBKADRB[0] LLBKADRB[1] LMATCHB
+       LMATCHB_I LOG0[0] LOG0[1] LOG1[0] LOG1[1] LWEIB LXADR[0] LXADR[1]
+       LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+       PGIOI[0] PGIOI[1] PLBKADR[0] PLBKADR[1] QB[0] QB[1] QB[2] QB[3] QB[4]
+       QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15]
+       QB[16] QB[17] QB[18] QB[19] QB[20] QB[21] QB[22] QB[23] QB[24] QB[25]
+       QB[26] QB[27] QB[28] QB[29] QB[30] QB[31] QT[0] QT[1] QT[2] QT[3] QT[4]
+       QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15]
+       QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+       QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] RASSIST[0] RASSIST[1]
+       RASSIST[2] RASSIST[3] RASSISTB[0] RASSISTB[1] RASSISTB[2] RASSISTB[3]
+       RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC SEL[0]
+       SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10]
+       SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] SEL[16] SEL[17] SEL[18] SEL[19]
+       SEL[20] SEL[21] SEL[22] SEL[23] SEL[24] SEL[25] SEL[26] SEL[27] SEL[28]
+       SEL[29] SEL[30] SEL[31] T1T TEST_RNMB TOPEDGE[0] TOPEDGE[1] TOPEDGE[2]
+       TOPEDGE[3] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+       VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+       VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23] VBA[24] VBA[25]
+       VBA[26] VBA[27] VBA[28] VBA[29] VBA[30] VBA[31] VBA[32] VBA[33] VBA[34]
+       VBA[35] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+       VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+       VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+       VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+       VBN[36] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8]
+       VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VBP[17]
+       VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25] VBP[26]
+       VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32] VBP[33] VBP[34] VBP[35]
+       VBP[36] VDDA[0] VDDA[1] VDDA[2] VDDAIL1 VDDAIR1 VDDMINB VDDP[0] VDDP[1]
+       VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+       VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+       VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+       VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+       VDDP[35] VDDP[36] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5]
+       VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+       VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19]
+       VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26]
+       VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33]
+       VDDPI[34] VDDPI[35] VDDPI[36] VDDWL[0] VDDWL[1] VEDGE[0] VEDGE[1] VSS[0]
+       VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+       VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19]
+       VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28]
+       VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34] VSS[35] VSS[36] WABUF[0]
+       WABUF[1] WABUF[2] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+       WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+       WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24]
+       WBI[25] WBI[26] WBI[27] WBI[28] WBI[29] WBI[30] WBI[31] WMT[0] WMT[1]
+       WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WTI[0] WTI[1] WTI[2] WTI[3]
+       WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12]
+       WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21]
+       WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27] WTI[28] WTI[29] WTI[30]
+       WTI[31]

*** Jumper Report ***
* Jumper: LOG1[1] PGIOI[1]
* Jumper: VBA[26] VSS[27]

X_ref_lt BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] LLSB[0]
+   LOG0[0] LOG1[0] PGIOI[0] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7]
+   QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] SDB_BC1T[0] SDB_BC2T[0] SDOR[0] SDOR_RET[0] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+   SEL[13] SEL[14] SEL[15] TOPEDGE[0] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDAIL1 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1]
+   VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9]
+   VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16]
+   VEDGE[0] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+   VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1]
+   WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11]
+   WBI[12] WBI[13] WBI[14] WBI[15] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ref_lt
X_ref_cnt_rt_rwl ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1] ARYSD_IN[0]
+   ARYSD_IN[1] ARYSD_TOP[0] ARYSD_TOP[1] BB[64] BB[65] BB[66] BB[67] BB[68]
+   BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79]
+   BB[80] BB[81] BB[82] BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90]
+   BB[91] CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR0
+   LBKADR1 LCGTH[0] LCGTH[1] LDFTX LITESLP LLBKADRB[0] LLBKADRB[1] LLSB[0]
+   LLSB[1] LMATCHB LMATCHB_I LOG0[0] LOG0[0] LOG0[0] LOG0[1] LOG1[0] LOG1[0]
+   LOG1[0] LOG1[1] LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+   LXADR[6] LXADR[7] LYADR[0] LYADR[1] PLBKADR[0] PLBKADR[1] QB[16] QB[17]
+   QB[18] QB[19] QB[20] QB[21] QB[22] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21]
+   QT[22] RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RASSISTB[0] RASSISTB[1]
+   RASSISTB[2] RASSISTB[3] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3]
+   RWLB_SAC SDB_BC1T[0] SDB_BC1T[1] SDB_BC2T[0] SDB_BC2T[1] SDOR[0] SDOR[1]
+   SDOR_RET[0] SDOR_RET[1] SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21]
+   SEL[22] T1T TEST_RNMB TOPEDGE[1] TOPEDGE[2] VBA[17] VBA[18] VBA[19] VBA[20]
+   VBA[21] VBA[22] VBA[23] VBA[24] VBA[25] VBN[17] VBN[18] VBN[19] VBN[20]
+   VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBP[17] VBP[18] VBP[19]
+   VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25] VBP[26] VDDA[0] VDDA[1]
+   VDDA[2] VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDMINB
+   VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24]
+   VDDP[25] VDDP[26] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21]
+   VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDWL[0] VDDWL[1] VSS[17]
+   VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26]
+   WABUF[0] WABUF[1] WABUF[2] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21]
+   WBI[22] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WTI[16]
+   WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22]
+   SNPS_SP_HD_16Kx8_ref_cnt_rt_rwl
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_bot VDDA[2] VDDAIR1 VDDP[27] VDDPI[27]
+   VSS[27] VBP[27] VBN[27] BB[92] BB[93] BB[94] BB[95] LOG0[1] LOG1[1] QB[23]
+   QT[23] SDOR[1] SDOR_RET[1] SEL[23] VBA[26] WBI[23] WTI[23] LLSB[1]
+   SDB_BC1T[1] SDB_BC2T[1] mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_ref_rt_log0 BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103]
+   BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BB[112]
+   BB[113] BB[114] BB[115] BB[116] BB[117] BB[118] BB[119] BB[120] BB[121]
+   BB[122] BB[123] BB[124] BB[125] BB[126] BB[127] LLSB[1] LOG0[1] LOG1[1]
+   QB[24] QB[25] QB[26] QB[27] QB[28] QB[29] QB[30] QB[31] QT[24] QT[25] QT[26]
+   QT[27] QT[28] QT[29] QT[30] QT[31] SDB_BC1T[1] SDB_BC2T[1] SDOR[1]
+   SDOR_RET[1] SEL[24] SEL[25] SEL[26] SEL[27] SEL[28] SEL[29] SEL[30] SEL[31]
+   VBA[27] VBA[28] VBA[29] VBA[30] VBA[31] VBA[32] VBA[33] VBA[34] VBN[28]
+   VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35] VBP[28] VBP[29]
+   VBP[30] VBP[31] VBP[32] VBP[33] VBP[34] VBP[35] VDDA[2] VDDAIR1 VDDAIR1
+   VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDP[28] VDDP[29] VDDP[30]
+   VDDP[31] VDDP[32] VDDP[33] VDDP[34] VDDP[35] VDDPI[28] VDDPI[29] VDDPI[30]
+   VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VSS[28] VSS[29] VSS[30]
+   VSS[31] VSS[32] VSS[33] VSS[34] VSS[35] WBI[24] WBI[25] WBI[26] WBI[27]
+   WBI[28] WBI[29] WBI[30] WBI[31] WTI[24] WTI[25] WTI[26] WTI[27] WTI[28]
+   WTI[29] WTI[30] WTI[31] SNPS_SP_HD_16Kx8_ref_rt_log0
X_mm16a05_u_hdsp_plus_pg_pwedge_wk_bk2_bot VDDA[2] VDDP[36] VDDPI[36] VSS[36]
+   VBP[36] VBN[36] LOG0[1] LOG1[1] PGIOI[1] PO SDOR_RET[1] TOPEDGE[3] VBA[35]
+   VEDGE[1] SDOR[1] mm16a05_u_hdsp_plus_pg_pwedge
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ary_lt_seg1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+       BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+       BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+       BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1] BT[2] BT[3]
+       BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14]
+       BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+       BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34]
+       BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44]
+       BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54]
+       BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] QB[0]
+       QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+       QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+       QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0]
+       SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10]
+       SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3]
+       VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12]
+       VBA[13] VBA[14] VBA[15] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+       VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15]
+       VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9]
+       VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VDDA[0] VDDA[1] VDDA[2]
+       VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10]
+       VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDAI[0] VDDAI[1] VDDAI[2]
+       VDDAI[3] VDDAI[4] VDDAI[5] VDDAI[6] VDDAI[7] VDDAI[8] VDDAI[9] VDDAI[10]
+       VDDAI[11] VDDAI[12] VDDAI[13] VDDAI[14] VDDAI[15] VDDP[0] VDDP[1]
+       VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+       VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDPI[0] VDDPI[1] VDDPI[2]
+       VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+       VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VSS[0] VSS[1] VSS[2]
+       VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+       VSS[13] VSS[14] VSS[15] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+       WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+       WL[0] WL[1] WL[2] WL[3] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+       WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
X_mm16a05_u_hdsp_plus_ar4x4m4_S0 VDDA[0] VDDAI[0] VDDP[0] VDDPI[0] VSS[0] VBP[0]
+   VBN[0] BB[0] BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3] QB[0] QT[0] SEL[0]
+   VBA[0] WBI[0] WTI[0] WL[0] WL[1] WL[2] WL[3] mm16a05_u_hdsp_plus_ar4x4m4
X_mm16a05_u_hdsp_plus_ar4x4m4_S1 VDDA[1] VDDAI[1] VDDP[1] VDDPI[1] VSS[1] VBP[1]
+   VBN[1] BB[4] BB[5] BB[6] BB[7] BT[4] BT[5] BT[6] BT[7] QB[1] QT[1] SEL[1]
+   VBA[1] WBI[1] WTI[1] WL[0] WL[1] WL[2] WL[3] mm16a05_u_hdsp_plus_ar4x4m4
X_mm16a05_u_hdsp_plus_ar4x4m4_S2 VDDA[2] VDDAI[2] VDDP[2] VDDPI[2] VSS[2] VBP[2]
+   VBN[2] BB[8] BB[9] BB[10] BB[11] BT[8] BT[9] BT[10] BT[11] QB[2] QT[2]
+   SEL[2] VBA[2] WBI[2] WTI[2] WL[0] WL[1] WL[2] WL[3]
+   mm16a05_u_hdsp_plus_ar4x4m4
X_mm16a05_u_hdsp_plus_ar4x4m4_S3 VDDA[3] VDDAI[3] VDDP[3] VDDPI[3] VSS[3] VBP[3]
+   VBN[3] BB[12] BB[13] BB[14] BB[15] BT[12] BT[13] BT[14] BT[15] QB[3] QT[3]
+   SEL[3] VBA[3] WBI[3] WTI[3] WL[0] WL[1] WL[2] WL[3]
+   mm16a05_u_hdsp_plus_ar4x4m4
X_mm16a05_u_hdsp_plus_ar4x4m4_S4 VDDA[4] VDDAI[4] VDDP[4] VDDPI[4] VSS[4] VBP[4]
+   VBN[4] BB[16] BB[17] BB[18] BB[19] BT[16] BT[17] BT[18] BT[19] QB[4] QT[4]
+   SEL[4] VBA[4] WBI[4] WTI[4] WL[0] WL[1] WL[2] WL[3]
+   mm16a05_u_hdsp_plus_ar4x4m4
X_mm16a05_u_hdsp_plus_ar4x4m4_S5 VDDA[5] VDDAI[5] VDDP[5] VDDPI[5] VSS[5] VBP[5]
+   VBN[5] BB[20] BB[21] BB[22] BB[23] BT[20] BT[21] BT[22] BT[23] QB[5] QT[5]
+   SEL[5] VBA[5] WBI[5] WTI[5] WL[0] WL[1] WL[2] WL[3]
+   mm16a05_u_hdsp_plus_ar4x4m4
X_mm16a05_u_hdsp_plus_ar4x4m4_S6 VDDA[6] VDDAI[6] VDDP[6] VDDPI[6] VSS[6] VBP[6]
+   VBN[6] BB[24] BB[25] BB[26] BB[27] BT[24] BT[25] BT[26] BT[27] QB[6] QT[6]
+   SEL[6] VBA[6] WBI[6] WTI[6] WL[0] WL[1] WL[2] WL[3]
+   mm16a05_u_hdsp_plus_ar4x4m4
X_mm16a05_u_hdsp_plus_ar4x4m4_S7 VDDA[7] VDDAI[7] VDDP[7] VDDPI[7] VSS[7] VBP[7]
+   VBN[7] BB[28] BB[29] BB[30] BB[31] BT[28] BT[29] BT[30] BT[31] QB[7] QT[7]
+   SEL[7] VBA[7] WBI[7] WTI[7] WL[0] WL[1] WL[2] WL[3]
+   mm16a05_u_hdsp_plus_ar4x4m4
X_mm16a05_u_hdsp_plus_ar4x4m4_F7 VDDA[8] VDDAI[8] VDDP[8] VDDPI[8] VSS[8] VBP[8]
+   VBN[8] BB[32] BB[33] BB[34] BB[35] BT[32] BT[33] BT[34] BT[35] QB[8] QT[8]
+   SEL[8] VBA[8] WBI[8] WTI[8] WL[0] WL[1] WL[2] WL[3]
+   mm16a05_u_hdsp_plus_ar4x4m4
X_mm16a05_u_hdsp_plus_ar4x4m4_F6 VDDA[9] VDDAI[9] VDDP[9] VDDPI[9] VSS[9] VBP[9]
+   VBN[9] BB[36] BB[37] BB[38] BB[39] BT[36] BT[37] BT[38] BT[39] QB[9] QT[9]
+   SEL[9] VBA[9] WBI[9] WTI[9] WL[0] WL[1] WL[2] WL[3]
+   mm16a05_u_hdsp_plus_ar4x4m4
X_mm16a05_u_hdsp_plus_ar4x4m4_F5 VDDA[10] VDDAI[10] VDDP[10] VDDPI[10] VSS[10]
+   VBP[10] VBN[10] BB[40] BB[41] BB[42] BB[43] BT[40] BT[41] BT[42] BT[43]
+   QB[10] QT[10] SEL[10] VBA[10] WBI[10] WTI[10] WL[0] WL[1] WL[2] WL[3]
+   mm16a05_u_hdsp_plus_ar4x4m4
X_mm16a05_u_hdsp_plus_ar4x4m4_F4 VDDA[11] VDDAI[11] VDDP[11] VDDPI[11] VSS[11]
+   VBP[11] VBN[11] BB[44] BB[45] BB[46] BB[47] BT[44] BT[45] BT[46] BT[47]
+   QB[11] QT[11] SEL[11] VBA[11] WBI[11] WTI[11] WL[0] WL[1] WL[2] WL[3]
+   mm16a05_u_hdsp_plus_ar4x4m4
X_mm16a05_u_hdsp_plus_ar4x4m4_F3 VDDA[12] VDDAI[12] VDDP[12] VDDPI[12] VSS[12]
+   VBP[12] VBN[12] BB[48] BB[49] BB[50] BB[51] BT[48] BT[49] BT[50] BT[51]
+   QB[12] QT[12] SEL[12] VBA[12] WBI[12] WTI[12] WL[0] WL[1] WL[2] WL[3]
+   mm16a05_u_hdsp_plus_ar4x4m4
X_mm16a05_u_hdsp_plus_ar4x4m4_F2 VDDA[13] VDDAI[13] VDDP[13] VDDPI[13] VSS[13]
+   VBP[13] VBN[13] BB[52] BB[53] BB[54] BB[55] BT[52] BT[53] BT[54] BT[55]
+   QB[13] QT[13] SEL[13] VBA[13] WBI[13] WTI[13] WL[0] WL[1] WL[2] WL[3]
+   mm16a05_u_hdsp_plus_ar4x4m4
X_mm16a05_u_hdsp_plus_ar4x4m4_F1 VDDA[14] VDDAI[14] VDDP[14] VDDPI[14] VSS[14]
+   VBP[14] VBN[14] BB[56] BB[57] BB[58] BB[59] BT[56] BT[57] BT[58] BT[59]
+   QB[14] QT[14] SEL[14] VBA[14] WBI[14] WTI[14] WL[0] WL[1] WL[2] WL[3]
+   mm16a05_u_hdsp_plus_ar4x4m4
X_mm16a05_u_hdsp_plus_ar4x4m4_F0 VDDA[15] VDDAI[15] VDDP[15] VDDPI[15] VSS[15]
+   VBP[15] VBN[15] BB[60] BB[61] BB[62] BB[63] BT[60] BT[61] BT[62] BT[63]
+   QB[15] QT[15] SEL[15] VBA[15] WBI[15] WTI[15] WL[0] WL[1] WL[2] WL[3]
+   mm16a05_u_hdsp_plus_ar4x4m4
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ary_lt BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7]
+       BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17]
+       BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27]
+       BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37]
+       BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47]
+       BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57]
+       BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1] BT[2] BT[3] BT[4]
+       BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15]
+       BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25]
+       BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+       BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45]
+       BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55]
+       BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB EDGET LOG0
+       LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9]
+       QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4]
+       QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15]
+       SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9]
+       SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2]
+       VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12]
+       VBA[13] VBA[14] VBA[15] VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4]
+       VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13]
+       VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+       VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15]
+       VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+       VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+       VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6]
+       VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14]
+       VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5]
+       VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+       VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+       VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+       VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4]
+       WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13]
+       WBI[14] WBI[15] WL[0] WL[1] WL[2] WL[3] WTI[0] WTI[1] WTI[2] WTI[3]
+       WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12]
+       WTI[13] WTI[14] WTI[15]
X_mm16a05_u_hdsp_plus_edge4 VDDA[0] VDDP[0] VDDPI[0] VSS[0] VBP[0] VBN[0] EDGEB
+   EDGET LOG0 LOG1 PGIOI VBA[0] VEDGE WL[0] WL[1] WL[2] WL[3]
+   mm16a05_u_hdsp_plus_edge4
X_ary_lt_seg1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] QB[0] QB[1] QB[2] QB[3] QB[4]
+   QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15]
+   QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11]
+   QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+   SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] VBA[1]
+   VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11]
+   VBA[12] VBA[13] VBA[14] VBA[15] VBA[16] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5]
+   VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15]
+   VBN[16] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9]
+   VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[1] VDDA[2]
+   VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11]
+   VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1
+   VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1
+   VDDAIL1 VDDAIL1 VDDAIL1 VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6]
+   VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14]
+   VDDP[15] VDDP[16] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6]
+   VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+   VDDPI[15] VDDPI[16] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+   VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1]
+   WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11]
+   WBI[12] WBI[13] WBI[14] WBI[15] WL[0] WL[1] WL[2] WL[3] WTI[0] WTI[1] WTI[2]
+   WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12]
+   WTI[13] WTI[14] WTI[15] SNPS_SP_HD_16Kx8_ary_lt_seg1
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ary_left_strap BB[0] BB[1] BB[2] BB[3] BB[4] BB[5]
+       BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+       BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+       BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+       BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1] BT[2] BT[3]
+       BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14]
+       BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+       BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34]
+       BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44]
+       BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54]
+       BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[0]
+       EDGET[63] LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6]
+       QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1]
+       QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12]
+       QT[13] QT[14] QT[15] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+       SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15]
+       VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9]
+       VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16] VBN[0] VBN[1]
+       VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11]
+       VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2] VBP[3]
+       VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+       VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4]
+       VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+       VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20]
+       VDDA[21] VDDA[22] VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28]
+       VDDA[29] VDDA[30] VDDA[31] VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36]
+       VDDA[37] VDDA[38] VDDA[39] VDDA[40] VDDA[41] VDDA[42] VDDA[43] VDDA[44]
+       VDDA[45] VDDA[46] VDDA[47] VDDA[48] VDDA[49] VDDA[50] VDDA[51] VDDA[52]
+       VDDA[53] VDDA[54] VDDA[55] VDDA[56] VDDA[57] VDDA[58] VDDA[59] VDDA[60]
+       VDDA[61] VDDA[62] VDDA[63] VDDA[64] VDDA[65] VDDA[66] VDDA[67] VDDA[68]
+       VDDA[69] VDDA[70] VDDA[71] VDDA[72] VDDA[73] VDDA[74] VDDA[75] VDDA[76]
+       VDDA[77] VDDA[78] VDDA[79] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+       VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11]
+       VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2]
+       VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+       VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0]
+       VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+       VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2]
+       WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12]
+       WBI[13] WBI[14] WBI[15] WL[0] WL[1] WL[2] WL[3] WL[4] WL[5] WL[6] WL[7]
+       WL[8] WL[9] WL[10] WL[11] WL[12] WL[13] WL[14] WL[15] WL[16] WL[17]
+       WL[18] WL[19] WL[20] WL[21] WL[22] WL[23] WL[24] WL[25] WL[26] WL[27]
+       WL[28] WL[29] WL[30] WL[31] WL[32] WL[33] WL[34] WL[35] WL[36] WL[37]
+       WL[38] WL[39] WL[40] WL[41] WL[42] WL[43] WL[44] WL[45] WL[46] WL[47]
+       WL[48] WL[49] WL[50] WL[51] WL[52] WL[53] WL[54] WL[55] WL[56] WL[57]
+       WL[58] WL[59] WL[60] WL[61] WL[62] WL[63] WL[64] WL[65] WL[66] WL[67]
+       WL[68] WL[69] WL[70] WL[71] WL[72] WL[73] WL[74] WL[75] WL[76] WL[77]
+       WL[78] WL[79] WL[80] WL[81] WL[82] WL[83] WL[84] WL[85] WL[86] WL[87]
+       WL[88] WL[89] WL[90] WL[91] WL[92] WL[93] WL[94] WL[95] WL[96] WL[97]
+       WL[98] WL[99] WL[100] WL[101] WL[102] WL[103] WL[104] WL[105] WL[106]
+       WL[107] WL[108] WL[109] WL[110] WL[111] WL[112] WL[113] WL[114] WL[115]
+       WL[116] WL[117] WL[118] WL[119] WL[120] WL[121] WL[122] WL[123] WL[124]
+       WL[125] WL[126] WL[127] WL[128] WL[129] WL[130] WL[131] WL[132] WL[133]
+       WL[134] WL[135] WL[136] WL[137] WL[138] WL[139] WL[140] WL[141] WL[142]
+       WL[143] WL[144] WL[145] WL[146] WL[147] WL[148] WL[149] WL[150] WL[151]
+       WL[152] WL[153] WL[154] WL[155] WL[156] WL[157] WL[158] WL[159] WL[160]
+       WL[161] WL[162] WL[163] WL[164] WL[165] WL[166] WL[167] WL[168] WL[169]
+       WL[170] WL[171] WL[172] WL[173] WL[174] WL[175] WL[176] WL[177] WL[178]
+       WL[179] WL[180] WL[181] WL[182] WL[183] WL[184] WL[185] WL[186] WL[187]
+       WL[188] WL[189] WL[190] WL[191] WL[192] WL[193] WL[194] WL[195] WL[196]
+       WL[197] WL[198] WL[199] WL[200] WL[201] WL[202] WL[203] WL[204] WL[205]
+       WL[206] WL[207] WL[208] WL[209] WL[210] WL[211] WL[212] WL[213] WL[214]
+       WL[215] WL[216] WL[217] WL[218] WL[219] WL[220] WL[221] WL[222] WL[223]
+       WL[224] WL[225] WL[226] WL[227] WL[228] WL[229] WL[230] WL[231] WL[232]
+       WL[233] WL[234] WL[235] WL[236] WL[237] WL[238] WL[239] WL[240] WL[241]
+       WL[242] WL[243] WL[244] WL[245] WL[246] WL[247] WL[248] WL[249] WL[250]
+       WL[251] WL[252] WL[253] WL[254] WL[255] WTI[0] WTI[1] WTI[2] WTI[3]
+       WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12]
+       WTI[13] WTI[14] WTI[15]
X_ary_lt_S0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[0] EDGET[0] LOG0 LOG1 PGIOI
+   QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+   QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+   QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+   SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2]
+   VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+   VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4]
+   VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13]
+   VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+   VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+   VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2] VSS[3]
+   VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13]
+   VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+   WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WL[0]
+   WL[1] WL[2] WL[3] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[1] EDGET[1] LOG0 LOG1 PGIOI
+   QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+   QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+   QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+   SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2]
+   VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+   VBP[13] VBP[14] VBP[15] VBP[16] VDDA[17] VDDA[1] VDDA[2] VDDA[3] VDDA[4]
+   VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13]
+   VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+   VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+   VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2] VSS[3]
+   VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13]
+   VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+   WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WL[4]
+   WL[5] WL[6] WL[7] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S2 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[2] EDGET[2] LOG0 LOG1 PGIOI
+   QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+   QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+   QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+   SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2]
+   VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+   VBP[13] VBP[14] VBP[15] VBP[16] VDDA[18] VDDA[1] VDDA[2] VDDA[3] VDDA[4]
+   VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13]
+   VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+   VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+   VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2] VSS[3]
+   VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13]
+   VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+   WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WL[8]
+   WL[9] WL[10] WL[11] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S3 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[3] EDGET[3] LOG0 LOG1 PGIOI
+   QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+   QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+   QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+   SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2]
+   VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+   VBP[13] VBP[14] VBP[15] VBP[16] VDDA[19] VDDA[1] VDDA[2] VDDA[3] VDDA[4]
+   VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13]
+   VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+   VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+   VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2] VSS[3]
+   VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13]
+   VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+   WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WL[12]
+   WL[13] WL[14] WL[15] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S4 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[4] EDGET[4] LOG0 LOG1 PGIOI
+   QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+   QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+   QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+   SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2]
+   VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+   VBP[13] VBP[14] VBP[15] VBP[16] VDDA[20] VDDA[1] VDDA[2] VDDA[3] VDDA[4]
+   VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13]
+   VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+   VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+   VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2] VSS[3]
+   VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13]
+   VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+   WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WL[16]
+   WL[17] WL[18] WL[19] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S5 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[5] EDGET[5] LOG0 LOG1 PGIOI
+   QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+   QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+   QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+   SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2]
+   VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+   VBP[13] VBP[14] VBP[15] VBP[16] VDDA[21] VDDA[1] VDDA[2] VDDA[3] VDDA[4]
+   VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13]
+   VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+   VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+   VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2] VSS[3]
+   VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13]
+   VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+   WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WL[20]
+   WL[21] WL[22] WL[23] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S6 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[6] EDGET[6] LOG0 LOG1 PGIOI
+   QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+   QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+   QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+   SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2]
+   VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+   VBP[13] VBP[14] VBP[15] VBP[16] VDDA[22] VDDA[1] VDDA[2] VDDA[3] VDDA[4]
+   VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13]
+   VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+   VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+   VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2] VSS[3]
+   VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13]
+   VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+   WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WL[24]
+   WL[25] WL[26] WL[27] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S7 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[7] EDGET[7] LOG0 LOG1 PGIOI
+   QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+   QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+   QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+   SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2]
+   VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+   VBP[13] VBP[14] VBP[15] VBP[16] VDDA[23] VDDA[1] VDDA[2] VDDA[3] VDDA[4]
+   VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13]
+   VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+   VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+   VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2] VSS[3]
+   VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13]
+   VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+   WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WL[28]
+   WL[29] WL[30] WL[31] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S8 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[8] EDGET[8] LOG0 LOG1 PGIOI
+   QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+   QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+   QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+   SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2]
+   VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+   VBP[13] VBP[14] VBP[15] VBP[16] VDDA[24] VDDA[1] VDDA[2] VDDA[3] VDDA[4]
+   VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13]
+   VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+   VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+   VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2] VSS[3]
+   VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13]
+   VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+   WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WL[32]
+   WL[33] WL[34] WL[35] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S9 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[9] EDGET[9] LOG0 LOG1 PGIOI
+   QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+   QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+   QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+   SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2]
+   VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+   VBP[13] VBP[14] VBP[15] VBP[16] VDDA[25] VDDA[1] VDDA[2] VDDA[3] VDDA[4]
+   VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13]
+   VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+   VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+   VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2] VSS[3]
+   VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13]
+   VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+   WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WL[36]
+   WL[37] WL[38] WL[39] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S10 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[10] EDGET[10] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[26] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[40] WL[41] WL[42] WL[43] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S11 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[11] EDGET[11] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[27] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[44] WL[45] WL[46] WL[47] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S12 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[12] EDGET[12] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[28] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[48] WL[49] WL[50] WL[51] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S13 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[13] EDGET[13] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[29] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[52] WL[53] WL[54] WL[55] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S14 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[14] EDGET[14] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[30] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[56] WL[57] WL[58] WL[59] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S15 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[15] EDGET[15] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[31] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[60] WL[61] WL[62] WL[63] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S16 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[16] EDGET[16] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[32] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[64] WL[65] WL[66] WL[67] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S17 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[17] EDGET[17] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[33] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[68] WL[69] WL[70] WL[71] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S18 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[18] EDGET[18] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[34] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[72] WL[73] WL[74] WL[75] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S19 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[19] EDGET[19] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[35] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[76] WL[77] WL[78] WL[79] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S20 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[20] EDGET[20] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[36] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[80] WL[81] WL[82] WL[83] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S21 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[21] EDGET[21] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[37] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[84] WL[85] WL[86] WL[87] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S22 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[22] EDGET[22] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[38] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[88] WL[89] WL[90] WL[91] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S23 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[23] EDGET[23] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[39] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[92] WL[93] WL[94] WL[95] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S24 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[24] EDGET[24] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[40] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[96] WL[97] WL[98] WL[99] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S25 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[25] EDGET[25] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[41] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[100] WL[101] WL[102] WL[103] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S26 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[26] EDGET[26] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[42] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[104] WL[105] WL[106] WL[107] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S27 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[27] EDGET[27] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[43] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[108] WL[109] WL[110] WL[111] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S28 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[28] EDGET[28] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[44] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[112] WL[113] WL[114] WL[115] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S29 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[29] EDGET[29] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[45] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[116] WL[117] WL[118] WL[119] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S30 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[30] EDGET[30] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[46] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[120] WL[121] WL[122] WL[123] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_S31 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[31] EDGET[31] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[47] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[124] WL[125] WL[126] WL[127] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F31 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[32] EDGET[32] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[48] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[128] WL[129] WL[130] WL[131] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F30 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[33] EDGET[33] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[49] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[132] WL[133] WL[134] WL[135] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F29 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[34] EDGET[34] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[50] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[136] WL[137] WL[138] WL[139] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F28 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[35] EDGET[35] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[51] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[140] WL[141] WL[142] WL[143] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F27 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[36] EDGET[36] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[52] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[144] WL[145] WL[146] WL[147] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F26 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[37] EDGET[37] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[53] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[148] WL[149] WL[150] WL[151] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F25 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[38] EDGET[38] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[54] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[152] WL[153] WL[154] WL[155] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F24 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[39] EDGET[39] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[55] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[156] WL[157] WL[158] WL[159] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F23 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[40] EDGET[40] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[56] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[160] WL[161] WL[162] WL[163] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F22 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[41] EDGET[41] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[57] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[164] WL[165] WL[166] WL[167] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F21 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[42] EDGET[42] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[58] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[168] WL[169] WL[170] WL[171] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F20 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[43] EDGET[43] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[59] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[172] WL[173] WL[174] WL[175] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F19 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[44] EDGET[44] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[60] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[176] WL[177] WL[178] WL[179] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F18 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[45] EDGET[45] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[61] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[180] WL[181] WL[182] WL[183] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F17 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[46] EDGET[46] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[62] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[184] WL[185] WL[186] WL[187] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F16 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[47] EDGET[47] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[63] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[188] WL[189] WL[190] WL[191] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F15 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[48] EDGET[48] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[64] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[192] WL[193] WL[194] WL[195] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F14 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[49] EDGET[49] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[65] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[196] WL[197] WL[198] WL[199] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F13 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[50] EDGET[50] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[66] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[200] WL[201] WL[202] WL[203] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F12 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[51] EDGET[51] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[67] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[204] WL[205] WL[206] WL[207] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F11 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[52] EDGET[52] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[68] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[208] WL[209] WL[210] WL[211] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F10 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[53] EDGET[53] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[69] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[212] WL[213] WL[214] WL[215] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F9 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[54] EDGET[54] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[70] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[216] WL[217] WL[218] WL[219] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F8 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[55] EDGET[55] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[71] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[220] WL[221] WL[222] WL[223] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F7 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[56] EDGET[56] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[72] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[224] WL[225] WL[226] WL[227] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F6 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[57] EDGET[57] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[73] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[228] WL[229] WL[230] WL[231] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F5 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[58] EDGET[58] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[74] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[232] WL[233] WL[234] WL[235] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F4 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[59] EDGET[59] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[75] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[236] WL[237] WL[238] WL[239] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F3 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[60] EDGET[60] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[76] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[240] WL[241] WL[242] WL[243] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F2 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[61] EDGET[61] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[77] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[244] WL[245] WL[246] WL[247] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[62] EDGET[62] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[78] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[248] WL[249] WL[250] WL[251] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
X_ary_lt_F0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[63] EDGET[63] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[79] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[252] WL[253] WL[254] WL[255] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_lt
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ary_buf_lt_col ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[0]
+       EDGET[63] LCGTH LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1]
+       VBA VBN VBP VDDA VDDP VDDPI VDDWL VSS WL[0] WL[1] WL[2] WL[3] WL[4]
+       WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13] WL[14] WL[15]
+       WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23] WL[24] WL[25]
+       WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33] WL[34] WL[35]
+       WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42] WL[43] WL[44] WL[45]
+       WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53] WL[54] WL[55]
+       WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63] WL[64] WL[65]
+       WL[66] WL[67] WL[68] WL[69] WL[70] WL[71] WL[72] WL[73] WL[74] WL[75]
+       WL[76] WL[77] WL[78] WL[79] WL[80] WL[81] WL[82] WL[83] WL[84] WL[85]
+       WL[86] WL[87] WL[88] WL[89] WL[90] WL[91] WL[92] WL[93] WL[94] WL[95]
+       WL[96] WL[97] WL[98] WL[99] WL[100] WL[101] WL[102] WL[103] WL[104]
+       WL[105] WL[106] WL[107] WL[108] WL[109] WL[110] WL[111] WL[112] WL[113]
+       WL[114] WL[115] WL[116] WL[117] WL[118] WL[119] WL[120] WL[121] WL[122]
+       WL[123] WL[124] WL[125] WL[126] WL[127] WL[128] WL[129] WL[130] WL[131]
+       WL[132] WL[133] WL[134] WL[135] WL[136] WL[137] WL[138] WL[139] WL[140]
+       WL[141] WL[142] WL[143] WL[144] WL[145] WL[146] WL[147] WL[148] WL[149]
+       WL[150] WL[151] WL[152] WL[153] WL[154] WL[155] WL[156] WL[157] WL[158]
+       WL[159] WL[160] WL[161] WL[162] WL[163] WL[164] WL[165] WL[166] WL[167]
+       WL[168] WL[169] WL[170] WL[171] WL[172] WL[173] WL[174] WL[175] WL[176]
+       WL[177] WL[178] WL[179] WL[180] WL[181] WL[182] WL[183] WL[184] WL[185]
+       WL[186] WL[187] WL[188] WL[189] WL[190] WL[191] WL[192] WL[193] WL[194]
+       WL[195] WL[196] WL[197] WL[198] WL[199] WL[200] WL[201] WL[202] WL[203]
+       WL[204] WL[205] WL[206] WL[207] WL[208] WL[209] WL[210] WL[211] WL[212]
+       WL[213] WL[214] WL[215] WL[216] WL[217] WL[218] WL[219] WL[220] WL[221]
+       WL[222] WL[223] WL[224] WL[225] WL[226] WL[227] WL[228] WL[229] WL[230]
+       WL[231] WL[232] WL[233] WL[234] WL[235] WL[236] WL[237] WL[238] WL[239]
+       WL[240] WL[241] WL[242] WL[243] WL[244] WL[245] WL[246] WL[247] WL[248]
+       WL[249] WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] WLB[0] WLB[1]
+       WLB[2] WLB[3] WLB[4] WLB[5] WLB[6] WLB[7] WLB[8] WLB[9] WLB[10] WLB[11]
+       WLB[12] WLB[13] WLB[14] WLB[15] WLB[16] WLB[17] WLB[18] WLB[19] WLB[20]
+       WLB[21] WLB[22] WLB[23] WLB[24] WLB[25] WLB[26] WLB[27] WLB[28] WLB[29]
+       WLB[30] WLB[31] WLB[32] WLB[33] WLB[34] WLB[35] WLB[36] WLB[37] WLB[38]
+       WLB[39] WLB[40] WLB[41] WLB[42] WLB[43] WLB[44] WLB[45] WLB[46] WLB[47]
+       WLB[48] WLB[49] WLB[50] WLB[51] WLB[52] WLB[53] WLB[54] WLB[55] WLB[56]
+       WLB[57] WLB[58] WLB[59] WLB[60] WLB[61] WLB[62] WLB[63] WLB[64] WLB[65]
+       WLB[66] WLB[67] WLB[68] WLB[69] WLB[70] WLB[71] WLB[72] WLB[73] WLB[74]
+       WLB[75] WLB[76] WLB[77] WLB[78] WLB[79] WLB[80] WLB[81] WLB[82] WLB[83]
+       WLB[84] WLB[85] WLB[86] WLB[87] WLB[88] WLB[89] WLB[90] WLB[91] WLB[92]
+       WLB[93] WLB[94] WLB[95] WLB[96] WLB[97] WLB[98] WLB[99] WLB[100]
+       WLB[101] WLB[102] WLB[103] WLB[104] WLB[105] WLB[106] WLB[107] WLB[108]
+       WLB[109] WLB[110] WLB[111] WLB[112] WLB[113] WLB[114] WLB[115] WLB[116]
+       WLB[117] WLB[118] WLB[119] WLB[120] WLB[121] WLB[122] WLB[123] WLB[124]
+       WLB[125] WLB[126] WLB[127] WLB[128] WLB[129] WLB[130] WLB[131] WLB[132]
+       WLB[133] WLB[134] WLB[135] WLB[136] WLB[137] WLB[138] WLB[139] WLB[140]
+       WLB[141] WLB[142] WLB[143] WLB[144] WLB[145] WLB[146] WLB[147] WLB[148]
+       WLB[149] WLB[150] WLB[151] WLB[152] WLB[153] WLB[154] WLB[155] WLB[156]
+       WLB[157] WLB[158] WLB[159] WLB[160] WLB[161] WLB[162] WLB[163] WLB[164]
+       WLB[165] WLB[166] WLB[167] WLB[168] WLB[169] WLB[170] WLB[171] WLB[172]
+       WLB[173] WLB[174] WLB[175] WLB[176] WLB[177] WLB[178] WLB[179] WLB[180]
+       WLB[181] WLB[182] WLB[183] WLB[184] WLB[185] WLB[186] WLB[187] WLB[188]
+       WLB[189] WLB[190] WLB[191] WLB[192] WLB[193] WLB[194] WLB[195] WLB[196]
+       WLB[197] WLB[198] WLB[199] WLB[200] WLB[201] WLB[202] WLB[203] WLB[204]
+       WLB[205] WLB[206] WLB[207] WLB[208] WLB[209] WLB[210] WLB[211] WLB[212]
+       WLB[213] WLB[214] WLB[215] WLB[216] WLB[217] WLB[218] WLB[219] WLB[220]
+       WLB[221] WLB[222] WLB[223] WLB[224] WLB[225] WLB[226] WLB[227] WLB[228]
+       WLB[229] WLB[230] WLB[231] WLB[232] WLB[233] WLB[234] WLB[235] WLB[236]
+       WLB[237] WLB[238] WLB[239] WLB[240] WLB[241] WLB[242] WLB[243] WLB[244]
+       WLB[245] WLB[246] WLB[247] WLB[248] WLB[249] WLB[250] WLB[251] WLB[252]
+       WLB[253] WLB[254] WLB[255]
X_mm16a05_u_hdsp_plus_x4buf_left_S0 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[0]
+   WL[1] WL[2] WL[3] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[0] EDGET[0] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[0] WLB[1] WLB[2]
+   WLB[3] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S1 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[4]
+   WL[5] WL[6] WL[7] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[1] EDGET[1] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[4] WLB[5] WLB[6]
+   WLB[7] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S2 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[8]
+   WL[9] WL[10] WL[11] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[2] EDGET[2] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[8] WLB[9] WLB[10]
+   WLB[11] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S3 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[12]
+   WL[13] WL[14] WL[15] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[3] EDGET[3] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[12] WLB[13]
+   WLB[14] WLB[15] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S4 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[16]
+   WL[17] WL[18] WL[19] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[4] EDGET[4] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[16] WLB[17]
+   WLB[18] WLB[19] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S5 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[20]
+   WL[21] WL[22] WL[23] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[5] EDGET[5] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[20] WLB[21]
+   WLB[22] WLB[23] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S6 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[24]
+   WL[25] WL[26] WL[27] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[6] EDGET[6] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[24] WLB[25]
+   WLB[26] WLB[27] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S7 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[28]
+   WL[29] WL[30] WL[31] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[7] EDGET[7] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[28] WLB[29]
+   WLB[30] WLB[31] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S8 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[32]
+   WL[33] WL[34] WL[35] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[8] EDGET[8] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[32] WLB[33]
+   WLB[34] WLB[35] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S9 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[36]
+   WL[37] WL[38] WL[39] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[9] EDGET[9] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[36] WLB[37]
+   WLB[38] WLB[39] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S10 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[40]
+   WL[41] WL[42] WL[43] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[10] EDGET[10] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[40] WLB[41]
+   WLB[42] WLB[43] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S11 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[44]
+   WL[45] WL[46] WL[47] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[11] EDGET[11] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[44] WLB[45]
+   WLB[46] WLB[47] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S12 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[48]
+   WL[49] WL[50] WL[51] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[12] EDGET[12] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[48] WLB[49]
+   WLB[50] WLB[51] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S13 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[52]
+   WL[53] WL[54] WL[55] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[13] EDGET[13] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[52] WLB[53]
+   WLB[54] WLB[55] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S14 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[56]
+   WL[57] WL[58] WL[59] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[14] EDGET[14] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[56] WLB[57]
+   WLB[58] WLB[59] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S15 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[60]
+   WL[61] WL[62] WL[63] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[15] EDGET[15] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[60] WLB[61]
+   WLB[62] WLB[63] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S16 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[64]
+   WL[65] WL[66] WL[67] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[16] EDGET[16] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[64] WLB[65]
+   WLB[66] WLB[67] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S17 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[68]
+   WL[69] WL[70] WL[71] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[17] EDGET[17] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[68] WLB[69]
+   WLB[70] WLB[71] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S18 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[72]
+   WL[73] WL[74] WL[75] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[18] EDGET[18] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[72] WLB[73]
+   WLB[74] WLB[75] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S19 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[76]
+   WL[77] WL[78] WL[79] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[19] EDGET[19] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[76] WLB[77]
+   WLB[78] WLB[79] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S20 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[80]
+   WL[81] WL[82] WL[83] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[20] EDGET[20] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[80] WLB[81]
+   WLB[82] WLB[83] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S21 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[84]
+   WL[85] WL[86] WL[87] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[21] EDGET[21] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[84] WLB[85]
+   WLB[86] WLB[87] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S22 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[88]
+   WL[89] WL[90] WL[91] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[22] EDGET[22] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[88] WLB[89]
+   WLB[90] WLB[91] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S23 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[92]
+   WL[93] WL[94] WL[95] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[23] EDGET[23] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[92] WLB[93]
+   WLB[94] WLB[95] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S24 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[96]
+   WL[97] WL[98] WL[99] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[24] EDGET[24] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[96] WLB[97]
+   WLB[98] WLB[99] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S25 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[100]
+   WL[101] WL[102] WL[103] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[25] EDGET[25] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[100]
+   WLB[101] WLB[102] WLB[103] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S26 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[104]
+   WL[105] WL[106] WL[107] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[26] EDGET[26] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[104]
+   WLB[105] WLB[106] WLB[107] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S27 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[108]
+   WL[109] WL[110] WL[111] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[27] EDGET[27] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[108]
+   WLB[109] WLB[110] WLB[111] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S28 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[112]
+   WL[113] WL[114] WL[115] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[28] EDGET[28] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[112]
+   WLB[113] WLB[114] WLB[115] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S29 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[116]
+   WL[117] WL[118] WL[119] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[29] EDGET[29] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[116]
+   WLB[117] WLB[118] WLB[119] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S30 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[120]
+   WL[121] WL[122] WL[123] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[30] EDGET[30] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[120]
+   WLB[121] WLB[122] WLB[123] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S31 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[124]
+   WL[125] WL[126] WL[127] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[31] EDGET[31] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[124]
+   WLB[125] WLB[126] WLB[127] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F31 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[128]
+   WL[129] WL[130] WL[131] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[32] EDGET[32] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[128]
+   WLB[129] WLB[130] WLB[131] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F30 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[132]
+   WL[133] WL[134] WL[135] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[33] EDGET[33] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[132]
+   WLB[133] WLB[134] WLB[135] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F29 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[136]
+   WL[137] WL[138] WL[139] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[34] EDGET[34] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[136]
+   WLB[137] WLB[138] WLB[139] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F28 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[140]
+   WL[141] WL[142] WL[143] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[35] EDGET[35] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[140]
+   WLB[141] WLB[142] WLB[143] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F27 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[144]
+   WL[145] WL[146] WL[147] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[36] EDGET[36] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[144]
+   WLB[145] WLB[146] WLB[147] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F26 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[148]
+   WL[149] WL[150] WL[151] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[37] EDGET[37] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[148]
+   WLB[149] WLB[150] WLB[151] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F25 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[152]
+   WL[153] WL[154] WL[155] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[38] EDGET[38] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[152]
+   WLB[153] WLB[154] WLB[155] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F24 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[156]
+   WL[157] WL[158] WL[159] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[39] EDGET[39] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[156]
+   WLB[157] WLB[158] WLB[159] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F23 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[160]
+   WL[161] WL[162] WL[163] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[40] EDGET[40] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[160]
+   WLB[161] WLB[162] WLB[163] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F22 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[164]
+   WL[165] WL[166] WL[167] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[41] EDGET[41] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[164]
+   WLB[165] WLB[166] WLB[167] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F21 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[168]
+   WL[169] WL[170] WL[171] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[42] EDGET[42] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[168]
+   WLB[169] WLB[170] WLB[171] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F20 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[172]
+   WL[173] WL[174] WL[175] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[43] EDGET[43] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[172]
+   WLB[173] WLB[174] WLB[175] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F19 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[176]
+   WL[177] WL[178] WL[179] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[44] EDGET[44] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[176]
+   WLB[177] WLB[178] WLB[179] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F18 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[180]
+   WL[181] WL[182] WL[183] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[45] EDGET[45] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[180]
+   WLB[181] WLB[182] WLB[183] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F17 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[184]
+   WL[185] WL[186] WL[187] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[46] EDGET[46] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[184]
+   WLB[185] WLB[186] WLB[187] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F16 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[188]
+   WL[189] WL[190] WL[191] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[47] EDGET[47] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[188]
+   WLB[189] WLB[190] WLB[191] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F15 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[192]
+   WL[193] WL[194] WL[195] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[48] EDGET[48] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[192]
+   WLB[193] WLB[194] WLB[195] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F14 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[196]
+   WL[197] WL[198] WL[199] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[49] EDGET[49] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[196]
+   WLB[197] WLB[198] WLB[199] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F13 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[200]
+   WL[201] WL[202] WL[203] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[50] EDGET[50] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[200]
+   WLB[201] WLB[202] WLB[203] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F12 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[204]
+   WL[205] WL[206] WL[207] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[51] EDGET[51] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[204]
+   WLB[205] WLB[206] WLB[207] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F11 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[208]
+   WL[209] WL[210] WL[211] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[52] EDGET[52] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[208]
+   WLB[209] WLB[210] WLB[211] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F10 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[212]
+   WL[213] WL[214] WL[215] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[53] EDGET[53] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[212]
+   WLB[213] WLB[214] WLB[215] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F9 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[216]
+   WL[217] WL[218] WL[219] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[54] EDGET[54] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[216]
+   WLB[217] WLB[218] WLB[219] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F8 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[220]
+   WL[221] WL[222] WL[223] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[55] EDGET[55] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[220]
+   WLB[221] WLB[222] WLB[223] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F7 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[224]
+   WL[225] WL[226] WL[227] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[56] EDGET[56] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[224]
+   WLB[225] WLB[226] WLB[227] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F6 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[228]
+   WL[229] WL[230] WL[231] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[57] EDGET[57] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[228]
+   WLB[229] WLB[230] WLB[231] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F5 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[232]
+   WL[233] WL[234] WL[235] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[58] EDGET[58] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[232]
+   WLB[233] WLB[234] WLB[235] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F4 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[236]
+   WL[237] WL[238] WL[239] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[59] EDGET[59] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[236]
+   WLB[237] WLB[238] WLB[239] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F3 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[240]
+   WL[241] WL[242] WL[243] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[60] EDGET[60] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[240]
+   WLB[241] WLB[242] WLB[243] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F2 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[244]
+   WL[245] WL[246] WL[247] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[61] EDGET[61] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[244]
+   WLB[245] WLB[246] WLB[247] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F1 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[248]
+   WL[249] WL[250] WL[251] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[62] EDGET[62] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[248]
+   WLB[249] WLB[250] WLB[251] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F0 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[252]
+   WL[253] WL[254] WL[255] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[63] EDGET[63] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[252]
+   WLB[253] WLB[254] WLB[255] mm16a05_u_hdsp_plus_x4buf
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ary_buf_lsh_l ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB EDGET
+       LCGTH LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTBL[0] RASSISTBL[1] VBA VBN
+       VBP VDDA VDDP VDDPI VDDWL VSS WLBL[0] WLBL[1] WLBL[2] WLBL[3] WLBL[4]
+       WLBL[5] WLBL[6] WLBL[7] WLBL[8] WLBL[9] WLBL[10] WLBL[11] WLBL[12]
+       WLBL[13] WLBL[14] WLBL[15] WLBL[16] WLBL[17] WLBL[18] WLBL[19] WLBL[20]
+       WLBL[21] WLBL[22] WLBL[23] WLBL[24] WLBL[25] WLBL[26] WLBL[27] WLBL[28]
+       WLBL[29] WLBL[30] WLBL[31] WLBL[32] WLBL[33] WLBL[34] WLBL[35] WLBL[36]
+       WLBL[37] WLBL[38] WLBL[39] WLBL[40] WLBL[41] WLBL[42] WLBL[43] WLBL[44]
+       WLBL[45] WLBL[46] WLBL[47] WLBL[48] WLBL[49] WLBL[50] WLBL[51] WLBL[52]
+       WLBL[53] WLBL[54] WLBL[55] WLBL[56] WLBL[57] WLBL[58] WLBL[59] WLBL[60]
+       WLBL[61] WLBL[62] WLBL[63] WLBL[64] WLBL[65] WLBL[66] WLBL[67] WLBL[68]
+       WLBL[69] WLBL[70] WLBL[71] WLBL[72] WLBL[73] WLBL[74] WLBL[75] WLBL[76]
+       WLBL[77] WLBL[78] WLBL[79] WLBL[80] WLBL[81] WLBL[82] WLBL[83] WLBL[84]
+       WLBL[85] WLBL[86] WLBL[87] WLBL[88] WLBL[89] WLBL[90] WLBL[91] WLBL[92]
+       WLBL[93] WLBL[94] WLBL[95] WLBL[96] WLBL[97] WLBL[98] WLBL[99] WLBL[100]
+       WLBL[101] WLBL[102] WLBL[103] WLBL[104] WLBL[105] WLBL[106] WLBL[107]
+       WLBL[108] WLBL[109] WLBL[110] WLBL[111] WLBL[112] WLBL[113] WLBL[114]
+       WLBL[115] WLBL[116] WLBL[117] WLBL[118] WLBL[119] WLBL[120] WLBL[121]
+       WLBL[122] WLBL[123] WLBL[124] WLBL[125] WLBL[126] WLBL[127] WLBL[128]
+       WLBL[129] WLBL[130] WLBL[131] WLBL[132] WLBL[133] WLBL[134] WLBL[135]
+       WLBL[136] WLBL[137] WLBL[138] WLBL[139] WLBL[140] WLBL[141] WLBL[142]
+       WLBL[143] WLBL[144] WLBL[145] WLBL[146] WLBL[147] WLBL[148] WLBL[149]
+       WLBL[150] WLBL[151] WLBL[152] WLBL[153] WLBL[154] WLBL[155] WLBL[156]
+       WLBL[157] WLBL[158] WLBL[159] WLBL[160] WLBL[161] WLBL[162] WLBL[163]
+       WLBL[164] WLBL[165] WLBL[166] WLBL[167] WLBL[168] WLBL[169] WLBL[170]
+       WLBL[171] WLBL[172] WLBL[173] WLBL[174] WLBL[175] WLBL[176] WLBL[177]
+       WLBL[178] WLBL[179] WLBL[180] WLBL[181] WLBL[182] WLBL[183] WLBL[184]
+       WLBL[185] WLBL[186] WLBL[187] WLBL[188] WLBL[189] WLBL[190] WLBL[191]
+       WLBL[192] WLBL[193] WLBL[194] WLBL[195] WLBL[196] WLBL[197] WLBL[198]
+       WLBL[199] WLBL[200] WLBL[201] WLBL[202] WLBL[203] WLBL[204] WLBL[205]
+       WLBL[206] WLBL[207] WLBL[208] WLBL[209] WLBL[210] WLBL[211] WLBL[212]
+       WLBL[213] WLBL[214] WLBL[215] WLBL[216] WLBL[217] WLBL[218] WLBL[219]
+       WLBL[220] WLBL[221] WLBL[222] WLBL[223] WLBL[224] WLBL[225] WLBL[226]
+       WLBL[227] WLBL[228] WLBL[229] WLBL[230] WLBL[231] WLBL[232] WLBL[233]
+       WLBL[234] WLBL[235] WLBL[236] WLBL[237] WLBL[238] WLBL[239] WLBL[240]
+       WLBL[241] WLBL[242] WLBL[243] WLBL[244] WLBL[245] WLBL[246] WLBL[247]
+       WLBL[248] WLBL[249] WLBL[250] WLBL[251] WLBL[252] WLBL[253] WLBL[254]
+       WLBL[255] WLL[0] WLL[1] WLL[2] WLL[3] WLL[4] WLL[5] WLL[6] WLL[7] WLL[8]
+       WLL[9] WLL[10] WLL[11] WLL[12] WLL[13] WLL[14] WLL[15] WLL[16] WLL[17]
+       WLL[18] WLL[19] WLL[20] WLL[21] WLL[22] WLL[23] WLL[24] WLL[25] WLL[26]
+       WLL[27] WLL[28] WLL[29] WLL[30] WLL[31] WLL[32] WLL[33] WLL[34] WLL[35]
+       WLL[36] WLL[37] WLL[38] WLL[39] WLL[40] WLL[41] WLL[42] WLL[43] WLL[44]
+       WLL[45] WLL[46] WLL[47] WLL[48] WLL[49] WLL[50] WLL[51] WLL[52] WLL[53]
+       WLL[54] WLL[55] WLL[56] WLL[57] WLL[58] WLL[59] WLL[60] WLL[61] WLL[62]
+       WLL[63] WLL[64] WLL[65] WLL[66] WLL[67] WLL[68] WLL[69] WLL[70] WLL[71]
+       WLL[72] WLL[73] WLL[74] WLL[75] WLL[76] WLL[77] WLL[78] WLL[79] WLL[80]
+       WLL[81] WLL[82] WLL[83] WLL[84] WLL[85] WLL[86] WLL[87] WLL[88] WLL[89]
+       WLL[90] WLL[91] WLL[92] WLL[93] WLL[94] WLL[95] WLL[96] WLL[97] WLL[98]
+       WLL[99] WLL[100] WLL[101] WLL[102] WLL[103] WLL[104] WLL[105] WLL[106]
+       WLL[107] WLL[108] WLL[109] WLL[110] WLL[111] WLL[112] WLL[113] WLL[114]
+       WLL[115] WLL[116] WLL[117] WLL[118] WLL[119] WLL[120] WLL[121] WLL[122]
+       WLL[123] WLL[124] WLL[125] WLL[126] WLL[127] WLL[128] WLL[129] WLL[130]
+       WLL[131] WLL[132] WLL[133] WLL[134] WLL[135] WLL[136] WLL[137] WLL[138]
+       WLL[139] WLL[140] WLL[141] WLL[142] WLL[143] WLL[144] WLL[145] WLL[146]
+       WLL[147] WLL[148] WLL[149] WLL[150] WLL[151] WLL[152] WLL[153] WLL[154]
+       WLL[155] WLL[156] WLL[157] WLL[158] WLL[159] WLL[160] WLL[161] WLL[162]
+       WLL[163] WLL[164] WLL[165] WLL[166] WLL[167] WLL[168] WLL[169] WLL[170]
+       WLL[171] WLL[172] WLL[173] WLL[174] WLL[175] WLL[176] WLL[177] WLL[178]
+       WLL[179] WLL[180] WLL[181] WLL[182] WLL[183] WLL[184] WLL[185] WLL[186]
+       WLL[187] WLL[188] WLL[189] WLL[190] WLL[191] WLL[192] WLL[193] WLL[194]
+       WLL[195] WLL[196] WLL[197] WLL[198] WLL[199] WLL[200] WLL[201] WLL[202]
+       WLL[203] WLL[204] WLL[205] WLL[206] WLL[207] WLL[208] WLL[209] WLL[210]
+       WLL[211] WLL[212] WLL[213] WLL[214] WLL[215] WLL[216] WLL[217] WLL[218]
+       WLL[219] WLL[220] WLL[221] WLL[222] WLL[223] WLL[224] WLL[225] WLL[226]
+       WLL[227] WLL[228] WLL[229] WLL[230] WLL[231] WLL[232] WLL[233] WLL[234]
+       WLL[235] WLL[236] WLL[237] WLL[238] WLL[239] WLL[240] WLL[241] WLL[242]
+       WLL[243] WLL[244] WLL[245] WLL[246] WLL[247] WLL[248] WLL[249] WLL[250]
+       WLL[251] WLL[252] WLL[253] WLL[254] WLL[255]
X_ary_buf_lt_col ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB EDGET LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTBL[0] RASSISTBL[1] VBA VBN VBP VDDA VDDP VDDPI
+   VDDWL VSS WLL[0] WLL[1] WLL[2] WLL[3] WLL[4] WLL[5] WLL[6] WLL[7] WLL[8]
+   WLL[9] WLL[10] WLL[11] WLL[12] WLL[13] WLL[14] WLL[15] WLL[16] WLL[17]
+   WLL[18] WLL[19] WLL[20] WLL[21] WLL[22] WLL[23] WLL[24] WLL[25] WLL[26]
+   WLL[27] WLL[28] WLL[29] WLL[30] WLL[31] WLL[32] WLL[33] WLL[34] WLL[35]
+   WLL[36] WLL[37] WLL[38] WLL[39] WLL[40] WLL[41] WLL[42] WLL[43] WLL[44]
+   WLL[45] WLL[46] WLL[47] WLL[48] WLL[49] WLL[50] WLL[51] WLL[52] WLL[53]
+   WLL[54] WLL[55] WLL[56] WLL[57] WLL[58] WLL[59] WLL[60] WLL[61] WLL[62]
+   WLL[63] WLL[64] WLL[65] WLL[66] WLL[67] WLL[68] WLL[69] WLL[70] WLL[71]
+   WLL[72] WLL[73] WLL[74] WLL[75] WLL[76] WLL[77] WLL[78] WLL[79] WLL[80]
+   WLL[81] WLL[82] WLL[83] WLL[84] WLL[85] WLL[86] WLL[87] WLL[88] WLL[89]
+   WLL[90] WLL[91] WLL[92] WLL[93] WLL[94] WLL[95] WLL[96] WLL[97] WLL[98]
+   WLL[99] WLL[100] WLL[101] WLL[102] WLL[103] WLL[104] WLL[105] WLL[106]
+   WLL[107] WLL[108] WLL[109] WLL[110] WLL[111] WLL[112] WLL[113] WLL[114]
+   WLL[115] WLL[116] WLL[117] WLL[118] WLL[119] WLL[120] WLL[121] WLL[122]
+   WLL[123] WLL[124] WLL[125] WLL[126] WLL[127] WLL[128] WLL[129] WLL[130]
+   WLL[131] WLL[132] WLL[133] WLL[134] WLL[135] WLL[136] WLL[137] WLL[138]
+   WLL[139] WLL[140] WLL[141] WLL[142] WLL[143] WLL[144] WLL[145] WLL[146]
+   WLL[147] WLL[148] WLL[149] WLL[150] WLL[151] WLL[152] WLL[153] WLL[154]
+   WLL[155] WLL[156] WLL[157] WLL[158] WLL[159] WLL[160] WLL[161] WLL[162]
+   WLL[163] WLL[164] WLL[165] WLL[166] WLL[167] WLL[168] WLL[169] WLL[170]
+   WLL[171] WLL[172] WLL[173] WLL[174] WLL[175] WLL[176] WLL[177] WLL[178]
+   WLL[179] WLL[180] WLL[181] WLL[182] WLL[183] WLL[184] WLL[185] WLL[186]
+   WLL[187] WLL[188] WLL[189] WLL[190] WLL[191] WLL[192] WLL[193] WLL[194]
+   WLL[195] WLL[196] WLL[197] WLL[198] WLL[199] WLL[200] WLL[201] WLL[202]
+   WLL[203] WLL[204] WLL[205] WLL[206] WLL[207] WLL[208] WLL[209] WLL[210]
+   WLL[211] WLL[212] WLL[213] WLL[214] WLL[215] WLL[216] WLL[217] WLL[218]
+   WLL[219] WLL[220] WLL[221] WLL[222] WLL[223] WLL[224] WLL[225] WLL[226]
+   WLL[227] WLL[228] WLL[229] WLL[230] WLL[231] WLL[232] WLL[233] WLL[234]
+   WLL[235] WLL[236] WLL[237] WLL[238] WLL[239] WLL[240] WLL[241] WLL[242]
+   WLL[243] WLL[244] WLL[245] WLL[246] WLL[247] WLL[248] WLL[249] WLL[250]
+   WLL[251] WLL[252] WLL[253] WLL[254] WLL[255] WLBL[0] WLBL[1] WLBL[2] WLBL[3]
+   WLBL[4] WLBL[5] WLBL[6] WLBL[7] WLBL[8] WLBL[9] WLBL[10] WLBL[11] WLBL[12]
+   WLBL[13] WLBL[14] WLBL[15] WLBL[16] WLBL[17] WLBL[18] WLBL[19] WLBL[20]
+   WLBL[21] WLBL[22] WLBL[23] WLBL[24] WLBL[25] WLBL[26] WLBL[27] WLBL[28]
+   WLBL[29] WLBL[30] WLBL[31] WLBL[32] WLBL[33] WLBL[34] WLBL[35] WLBL[36]
+   WLBL[37] WLBL[38] WLBL[39] WLBL[40] WLBL[41] WLBL[42] WLBL[43] WLBL[44]
+   WLBL[45] WLBL[46] WLBL[47] WLBL[48] WLBL[49] WLBL[50] WLBL[51] WLBL[52]
+   WLBL[53] WLBL[54] WLBL[55] WLBL[56] WLBL[57] WLBL[58] WLBL[59] WLBL[60]
+   WLBL[61] WLBL[62] WLBL[63] WLBL[64] WLBL[65] WLBL[66] WLBL[67] WLBL[68]
+   WLBL[69] WLBL[70] WLBL[71] WLBL[72] WLBL[73] WLBL[74] WLBL[75] WLBL[76]
+   WLBL[77] WLBL[78] WLBL[79] WLBL[80] WLBL[81] WLBL[82] WLBL[83] WLBL[84]
+   WLBL[85] WLBL[86] WLBL[87] WLBL[88] WLBL[89] WLBL[90] WLBL[91] WLBL[92]
+   WLBL[93] WLBL[94] WLBL[95] WLBL[96] WLBL[97] WLBL[98] WLBL[99] WLBL[100]
+   WLBL[101] WLBL[102] WLBL[103] WLBL[104] WLBL[105] WLBL[106] WLBL[107]
+   WLBL[108] WLBL[109] WLBL[110] WLBL[111] WLBL[112] WLBL[113] WLBL[114]
+   WLBL[115] WLBL[116] WLBL[117] WLBL[118] WLBL[119] WLBL[120] WLBL[121]
+   WLBL[122] WLBL[123] WLBL[124] WLBL[125] WLBL[126] WLBL[127] WLBL[128]
+   WLBL[129] WLBL[130] WLBL[131] WLBL[132] WLBL[133] WLBL[134] WLBL[135]
+   WLBL[136] WLBL[137] WLBL[138] WLBL[139] WLBL[140] WLBL[141] WLBL[142]
+   WLBL[143] WLBL[144] WLBL[145] WLBL[146] WLBL[147] WLBL[148] WLBL[149]
+   WLBL[150] WLBL[151] WLBL[152] WLBL[153] WLBL[154] WLBL[155] WLBL[156]
+   WLBL[157] WLBL[158] WLBL[159] WLBL[160] WLBL[161] WLBL[162] WLBL[163]
+   WLBL[164] WLBL[165] WLBL[166] WLBL[167] WLBL[168] WLBL[169] WLBL[170]
+   WLBL[171] WLBL[172] WLBL[173] WLBL[174] WLBL[175] WLBL[176] WLBL[177]
+   WLBL[178] WLBL[179] WLBL[180] WLBL[181] WLBL[182] WLBL[183] WLBL[184]
+   WLBL[185] WLBL[186] WLBL[187] WLBL[188] WLBL[189] WLBL[190] WLBL[191]
+   WLBL[192] WLBL[193] WLBL[194] WLBL[195] WLBL[196] WLBL[197] WLBL[198]
+   WLBL[199] WLBL[200] WLBL[201] WLBL[202] WLBL[203] WLBL[204] WLBL[205]
+   WLBL[206] WLBL[207] WLBL[208] WLBL[209] WLBL[210] WLBL[211] WLBL[212]
+   WLBL[213] WLBL[214] WLBL[215] WLBL[216] WLBL[217] WLBL[218] WLBL[219]
+   WLBL[220] WLBL[221] WLBL[222] WLBL[223] WLBL[224] WLBL[225] WLBL[226]
+   WLBL[227] WLBL[228] WLBL[229] WLBL[230] WLBL[231] WLBL[232] WLBL[233]
+   WLBL[234] WLBL[235] WLBL[236] WLBL[237] WLBL[238] WLBL[239] WLBL[240]
+   WLBL[241] WLBL[242] WLBL[243] WLBL[244] WLBL[245] WLBL[246] WLBL[247]
+   WLBL[248] WLBL[249] WLBL[250] WLBL[251] WLBL[252] WLBL[253] WLBL[254]
+   WLBL[255] SNPS_SP_HD_16Kx8_ary_buf_lt_col
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ary_xdec B[0] BYP_VLOAD C[0] CENDP DECH[0] DECH[1]
+       DECH[2] DECH[3] DECH[4] DECH[5] DECH[6] DECH[7] DECH[8] DECH[9] DECH[10]
+       DECH[11] DECH[12] DECH[13] DECH[14] DECH[15] DECH[16] DECH[17] DECH[18]
+       DECH[19] DECH[20] DECH[21] DECH[22] DECH[23] DECH[24] DECH[25] DECH[26]
+       DECH[27] DECH[28] DECH[29] DECH[30] DECH[31] DECH[32] DECH[33] DECH[34]
+       DECH[35] DECH[36] DECH[37] DECH[38] DECH[39] DECH[40] DECH[41] DECH[42]
+       DECH[43] DECH[44] DECH[45] DECH[46] DECH[47] DECH[48] DECH[49] DECH[50]
+       DECH[51] DECH[52] DECH[53] DECH[54] DECH[55] DECH[56] DECH[57] DECH[58]
+       DECH[59] DECH[60] DECH[61] DECH[62] DECH[63] DECL[0] DECL[1] DECL[2]
+       DECL[3] DECL[4] DECL[5] DECL[6] DECL[7] DECL[8] DECL[9] DECL[10]
+       DECL[11] DECL[12] DECL[13] DECL[14] DECL[15] DECL[16] DECL[17] DECL[18]
+       DECL[19] DECL[20] DECL[21] DECL[22] DECL[23] DECL[24] DECL[25] DECL[26]
+       DECL[27] DECL[28] DECL[29] DECL[30] DECL[31] DECL[32] DECL[33] DECL[34]
+       DECL[35] DECL[36] DECL[37] DECL[38] DECL[39] DECL[40] DECL[41] DECL[42]
+       DECL[43] DECL[44] DECL[45] DECL[46] DECL[47] DECL[48] DECL[49] DECL[50]
+       DECL[51] DECL[52] DECL[53] DECL[54] DECL[55] DECL[56] DECL[57] DECL[58]
+       DECL[59] DECL[60] DECL[61] DECL[62] DECL[63] DEF_MODE FAST1_MODE
+       FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR0 LBKADR1 LDFTX LITESLP
+       LMATCH[0] LMATCHB LOG0 LOG1 LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3]
+       LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1]
+       PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3]
+       PCB[4] PCB[5] PCB[6] PCB[7] RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT RMT[0]
+       RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB VBN VBP VDDA VDDMINB VDDP
+       VDDPI VSS VSSC_WL_L VSSC_WL_R WABUF[0] WABUF[1] WABUF[2] WCLKB[0]
+       WCLKB[1] WCLKB[2] WCLKB[3] WLBH[0] WLBH[1] WLBH[2] WLBH[3] WLBH[4]
+       WLBH[5] WLBH[6] WLBH[7] WLBH[8] WLBH[9] WLBH[10] WLBH[11] WLBH[12]
+       WLBH[13] WLBH[14] WLBH[15] WLBH[16] WLBH[17] WLBH[18] WLBH[19] WLBH[20]
+       WLBH[21] WLBH[22] WLBH[23] WLBH[24] WLBH[25] WLBH[26] WLBH[27] WLBH[28]
+       WLBH[29] WLBH[30] WLBH[31] WLBH[32] WLBH[33] WLBH[34] WLBH[35] WLBH[36]
+       WLBH[37] WLBH[38] WLBH[39] WLBH[40] WLBH[41] WLBH[42] WLBH[43] WLBH[44]
+       WLBH[45] WLBH[46] WLBH[47] WLBH[48] WLBH[49] WLBH[50] WLBH[51] WLBH[52]
+       WLBH[53] WLBH[54] WLBH[55] WLBH[56] WLBH[57] WLBH[58] WLBH[59] WLBH[60]
+       WLBH[61] WLBH[62] WLBH[63] WLBH[64] WLBH[65] WLBH[66] WLBH[67] WLBH[68]
+       WLBH[69] WLBH[70] WLBH[71] WLBH[72] WLBH[73] WLBH[74] WLBH[75] WLBH[76]
+       WLBH[77] WLBH[78] WLBH[79] WLBH[80] WLBH[81] WLBH[82] WLBH[83] WLBH[84]
+       WLBH[85] WLBH[86] WLBH[87] WLBH[88] WLBH[89] WLBH[90] WLBH[91] WLBH[92]
+       WLBH[93] WLBH[94] WLBH[95] WLBH[96] WLBH[97] WLBH[98] WLBH[99] WLBH[100]
+       WLBH[101] WLBH[102] WLBH[103] WLBH[104] WLBH[105] WLBH[106] WLBH[107]
+       WLBH[108] WLBH[109] WLBH[110] WLBH[111] WLBH[112] WLBH[113] WLBH[114]
+       WLBH[115] WLBH[116] WLBH[117] WLBH[118] WLBH[119] WLBH[120] WLBH[121]
+       WLBH[122] WLBH[123] WLBH[124] WLBH[125] WLBH[126] WLBH[127] WLBH[128]
+       WLBH[129] WLBH[130] WLBH[131] WLBH[132] WLBH[133] WLBH[134] WLBH[135]
+       WLBH[136] WLBH[137] WLBH[138] WLBH[139] WLBH[140] WLBH[141] WLBH[142]
+       WLBH[143] WLBH[144] WLBH[145] WLBH[146] WLBH[147] WLBH[148] WLBH[149]
+       WLBH[150] WLBH[151] WLBH[152] WLBH[153] WLBH[154] WLBH[155] WLBH[156]
+       WLBH[157] WLBH[158] WLBH[159] WLBH[160] WLBH[161] WLBH[162] WLBH[163]
+       WLBH[164] WLBH[165] WLBH[166] WLBH[167] WLBH[168] WLBH[169] WLBH[170]
+       WLBH[171] WLBH[172] WLBH[173] WLBH[174] WLBH[175] WLBH[176] WLBH[177]
+       WLBH[178] WLBH[179] WLBH[180] WLBH[181] WLBH[182] WLBH[183] WLBH[184]
+       WLBH[185] WLBH[186] WLBH[187] WLBH[188] WLBH[189] WLBH[190] WLBH[191]
+       WLBH[192] WLBH[193] WLBH[194] WLBH[195] WLBH[196] WLBH[197] WLBH[198]
+       WLBH[199] WLBH[200] WLBH[201] WLBH[202] WLBH[203] WLBH[204] WLBH[205]
+       WLBH[206] WLBH[207] WLBH[208] WLBH[209] WLBH[210] WLBH[211] WLBH[212]
+       WLBH[213] WLBH[214] WLBH[215] WLBH[216] WLBH[217] WLBH[218] WLBH[219]
+       WLBH[220] WLBH[221] WLBH[222] WLBH[223] WLBH[224] WLBH[225] WLBH[226]
+       WLBH[227] WLBH[228] WLBH[229] WLBH[230] WLBH[231] WLBH[232] WLBH[233]
+       WLBH[234] WLBH[235] WLBH[236] WLBH[237] WLBH[238] WLBH[239] WLBH[240]
+       WLBH[241] WLBH[242] WLBH[243] WLBH[244] WLBH[245] WLBH[246] WLBH[247]
+       WLBH[248] WLBH[249] WLBH[250] WLBH[251] WLBH[252] WLBH[253] WLBH[254]
+       WLBH[255] WLBL[0] WLBL[1] WLBL[2] WLBL[3] WLBL[4] WLBL[5] WLBL[6]
+       WLBL[7] WLBL[8] WLBL[9] WLBL[10] WLBL[11] WLBL[12] WLBL[13] WLBL[14]
+       WLBL[15] WLBL[16] WLBL[17] WLBL[18] WLBL[19] WLBL[20] WLBL[21] WLBL[22]
+       WLBL[23] WLBL[24] WLBL[25] WLBL[26] WLBL[27] WLBL[28] WLBL[29] WLBL[30]
+       WLBL[31] WLBL[32] WLBL[33] WLBL[34] WLBL[35] WLBL[36] WLBL[37] WLBL[38]
+       WLBL[39] WLBL[40] WLBL[41] WLBL[42] WLBL[43] WLBL[44] WLBL[45] WLBL[46]
+       WLBL[47] WLBL[48] WLBL[49] WLBL[50] WLBL[51] WLBL[52] WLBL[53] WLBL[54]
+       WLBL[55] WLBL[56] WLBL[57] WLBL[58] WLBL[59] WLBL[60] WLBL[61] WLBL[62]
+       WLBL[63] WLBL[64] WLBL[65] WLBL[66] WLBL[67] WLBL[68] WLBL[69] WLBL[70]
+       WLBL[71] WLBL[72] WLBL[73] WLBL[74] WLBL[75] WLBL[76] WLBL[77] WLBL[78]
+       WLBL[79] WLBL[80] WLBL[81] WLBL[82] WLBL[83] WLBL[84] WLBL[85] WLBL[86]
+       WLBL[87] WLBL[88] WLBL[89] WLBL[90] WLBL[91] WLBL[92] WLBL[93] WLBL[94]
+       WLBL[95] WLBL[96] WLBL[97] WLBL[98] WLBL[99] WLBL[100] WLBL[101]
+       WLBL[102] WLBL[103] WLBL[104] WLBL[105] WLBL[106] WLBL[107] WLBL[108]
+       WLBL[109] WLBL[110] WLBL[111] WLBL[112] WLBL[113] WLBL[114] WLBL[115]
+       WLBL[116] WLBL[117] WLBL[118] WLBL[119] WLBL[120] WLBL[121] WLBL[122]
+       WLBL[123] WLBL[124] WLBL[125] WLBL[126] WLBL[127] WLBL[128] WLBL[129]
+       WLBL[130] WLBL[131] WLBL[132] WLBL[133] WLBL[134] WLBL[135] WLBL[136]
+       WLBL[137] WLBL[138] WLBL[139] WLBL[140] WLBL[141] WLBL[142] WLBL[143]
+       WLBL[144] WLBL[145] WLBL[146] WLBL[147] WLBL[148] WLBL[149] WLBL[150]
+       WLBL[151] WLBL[152] WLBL[153] WLBL[154] WLBL[155] WLBL[156] WLBL[157]
+       WLBL[158] WLBL[159] WLBL[160] WLBL[161] WLBL[162] WLBL[163] WLBL[164]
+       WLBL[165] WLBL[166] WLBL[167] WLBL[168] WLBL[169] WLBL[170] WLBL[171]
+       WLBL[172] WLBL[173] WLBL[174] WLBL[175] WLBL[176] WLBL[177] WLBL[178]
+       WLBL[179] WLBL[180] WLBL[181] WLBL[182] WLBL[183] WLBL[184] WLBL[185]
+       WLBL[186] WLBL[187] WLBL[188] WLBL[189] WLBL[190] WLBL[191] WLBL[192]
+       WLBL[193] WLBL[194] WLBL[195] WLBL[196] WLBL[197] WLBL[198] WLBL[199]
+       WLBL[200] WLBL[201] WLBL[202] WLBL[203] WLBL[204] WLBL[205] WLBL[206]
+       WLBL[207] WLBL[208] WLBL[209] WLBL[210] WLBL[211] WLBL[212] WLBL[213]
+       WLBL[214] WLBL[215] WLBL[216] WLBL[217] WLBL[218] WLBL[219] WLBL[220]
+       WLBL[221] WLBL[222] WLBL[223] WLBL[224] WLBL[225] WLBL[226] WLBL[227]
+       WLBL[228] WLBL[229] WLBL[230] WLBL[231] WLBL[232] WLBL[233] WLBL[234]
+       WLBL[235] WLBL[236] WLBL[237] WLBL[238] WLBL[239] WLBL[240] WLBL[241]
+       WLBL[242] WLBL[243] WLBL[244] WLBL[245] WLBL[246] WLBL[247] WLBL[248]
+       WLBL[249] WLBL[250] WLBL[251] WLBL[252] WLBL[253] WLBL[254] WLBL[255]
+       WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]

*** Jumper Report ***
* Jumper: B[0] PBB[0] B[8] B[16] B[24] B[32] B[40] B[48] B[56]
* Jumper: C[0] PCB[0] C[1] C[2] C[3] C[4] C[5] C[6] C[7]
* Jumper: DECH[0] DECL[0]
* Jumper: DECH[1] DECL[1]
* Jumper: DECH[2] DECL[2]
* Jumper: DECH[3] DECL[3]
* Jumper: DECH[4] DECL[4]
* Jumper: DECH[5] DECL[5]
* Jumper: DECH[6] DECL[6]
* Jumper: DECH[7] DECL[7]
* Jumper: DECH[8] DECL[8]
* Jumper: DECH[9] DECL[9]
* Jumper: DECH[10] DECL[10]
* Jumper: DECH[11] DECL[11]
* Jumper: DECH[12] DECL[12]
* Jumper: DECH[13] DECL[13]
* Jumper: DECH[14] DECL[14]
* Jumper: DECH[15] DECL[15]
* Jumper: DECH[16] DECL[16]
* Jumper: DECH[17] DECL[17]
* Jumper: DECH[18] DECL[18]
* Jumper: DECH[19] DECL[19]
* Jumper: DECH[20] DECL[20]
* Jumper: DECH[21] DECL[21]
* Jumper: DECH[22] DECL[22]
* Jumper: DECH[23] DECL[23]
* Jumper: DECH[24] DECL[24]
* Jumper: DECH[25] DECL[25]
* Jumper: DECH[26] DECL[26]
* Jumper: DECH[27] DECL[27]
* Jumper: DECH[28] DECL[28]
* Jumper: DECH[29] DECL[29]
* Jumper: DECH[30] DECL[30]
* Jumper: DECH[31] DECL[31]
* Jumper: DECH[32] DECL[32]
* Jumper: DECH[33] DECL[33]
* Jumper: DECH[34] DECL[34]
* Jumper: DECH[35] DECL[35]
* Jumper: DECH[36] DECL[36]
* Jumper: DECH[37] DECL[37]
* Jumper: DECH[38] DECL[38]
* Jumper: DECH[39] DECL[39]
* Jumper: DECH[40] DECL[40]
* Jumper: DECH[41] DECL[41]
* Jumper: DECH[42] DECL[42]
* Jumper: DECH[43] DECL[43]
* Jumper: DECH[44] DECL[44]
* Jumper: DECH[45] DECL[45]
* Jumper: DECH[46] DECL[46]
* Jumper: DECH[47] DECL[47]
* Jumper: DECH[48] DECL[48]
* Jumper: DECH[49] DECL[49]
* Jumper: DECH[50] DECL[50]
* Jumper: DECH[51] DECL[51]
* Jumper: DECH[52] DECL[52]
* Jumper: DECH[53] DECL[53]
* Jumper: DECH[54] DECL[54]
* Jumper: DECH[55] DECL[55]
* Jumper: DECH[56] DECL[56]
* Jumper: DECH[57] DECL[57]
* Jumper: DECH[58] DECL[58]
* Jumper: DECH[59] DECL[59]
* Jumper: DECH[60] DECL[60]
* Jumper: DECH[61] DECL[61]
* Jumper: DECH[62] DECL[62]
* Jumper: DECH[63] DECL[63]
* Jumper: PBB[1] B[1] B[9] B[17] B[25] B[33] B[41] B[49] B[57]
* Jumper: PBB[2] B[2] B[10] B[18] B[26] B[34] B[42] B[50] B[58]
* Jumper: PBB[3] B[3] B[11] B[19] B[27] B[35] B[43] B[51] B[59]
* Jumper: PBB[4] B[4] B[12] B[20] B[28] B[36] B[44] B[52] B[60]
* Jumper: PBB[5] B[5] B[13] B[21] B[29] B[37] B[45] B[53] B[61]
* Jumper: PBB[6] B[6] B[14] B[22] B[30] B[38] B[46] B[54] B[62]
* Jumper: PBB[7] B[7] B[15] B[23] B[31] B[39] B[47] B[55] B[63]
* Jumper: PCB[1] C[8] C[9] C[10] C[11] C[12] C[13] C[14] C[15]
* Jumper: PCB[2] C[16] C[17] C[18] C[19] C[20] C[21] C[22] C[23]
* Jumper: PCB[3] C[24] C[25] C[26] C[27] C[28] C[29] C[30] C[31]
* Jumper: PCB[4] C[32] C[33] C[34] C[35] C[36] C[37] C[38] C[39]
* Jumper: PCB[5] C[40] C[41] C[42] C[43] C[44] C[45] C[46] C[47]
* Jumper: PCB[6] C[48] C[49] C[50] C[51] C[52] C[53] C[54] C[55]
* Jumper: PCB[7] C[56] C[57] C[58] C[59] C[60] C[61] C[62] C[63]

X_mm16a05_u_hdsp_plus_x4dec_S0 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[0] WLBH[0] WLBH[1] WLBH[2] WLBH[3] WLBL[0] WLBL[1] WLBL[2]
+   WLBL[3] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET LDFTX
+   LMATCH[0] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT RMT[0]
+   RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2]
+   WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] B[0] C[0] CENDP
+   DECH[0] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP LXADR[0] LXADR[1] LXADR[2]
+   LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1]
+   PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4]
+   PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S1 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[1] WLBH[4] WLBH[5] WLBH[6] WLBH[7] WLBL[4] WLBL[5] WLBL[6]
+   WLBL[7] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET LDFTX
+   LMATCH[1] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT RMT[0]
+   RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2]
+   WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[1] C[0] CENDP
+   DECH[1] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP LXADR[0] LXADR[1] LXADR[2]
+   LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1]
+   PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4]
+   PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S2 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[2] WLBH[8] WLBH[9] WLBH[10] WLBH[11] WLBL[8] WLBL[9] WLBL[10]
+   WLBL[11] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET LDFTX
+   LMATCH[2] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT RMT[0]
+   RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2]
+   WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[2] C[0] CENDP
+   DECH[2] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP LXADR[0] LXADR[1] LXADR[2]
+   LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1]
+   PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4]
+   PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S3 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[3] WLBH[12] WLBH[13] WLBH[14] WLBH[15] WLBL[12] WLBL[13]
+   WLBL[14] WLBL[15] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[3] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[3] C[0]
+   CENDP DECH[3] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S4 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[4] WLBH[16] WLBH[17] WLBH[18] WLBH[19] WLBL[16] WLBL[17]
+   WLBL[18] WLBL[19] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[4] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[4] C[0]
+   CENDP DECH[4] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S5 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[5] WLBH[20] WLBH[21] WLBH[22] WLBH[23] WLBL[20] WLBL[21]
+   WLBL[22] WLBL[23] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[5] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[5] C[0]
+   CENDP DECH[5] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S6 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[6] WLBH[24] WLBH[25] WLBH[26] WLBH[27] WLBL[24] WLBL[25]
+   WLBL[26] WLBL[27] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[6] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[6] C[0]
+   CENDP DECH[6] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S7 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[7] WLBH[28] WLBH[29] WLBH[30] WLBH[31] WLBL[28] WLBL[29]
+   WLBL[30] WLBL[31] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[7] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[7] C[0]
+   CENDP DECH[7] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S8 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[8] WLBH[32] WLBH[33] WLBH[34] WLBH[35] WLBL[32] WLBL[33]
+   WLBL[34] WLBL[35] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[8] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] B[0] PCB[1]
+   CENDP DECH[8] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S9 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[9] WLBH[36] WLBH[37] WLBH[38] WLBH[39] WLBL[36] WLBL[37]
+   WLBL[38] WLBL[39] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[9] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[1]
+   PCB[1] CENDP DECH[9] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S10 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[10] WLBH[40] WLBH[41] WLBH[42] WLBH[43] WLBL[40] WLBL[41]
+   WLBL[42] WLBL[43] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[10] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[2]
+   PCB[1] CENDP DECH[10] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S11 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[11] WLBH[44] WLBH[45] WLBH[46] WLBH[47] WLBL[44] WLBL[45]
+   WLBL[46] WLBL[47] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[11] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[3]
+   PCB[1] CENDP DECH[11] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S12 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[12] WLBH[48] WLBH[49] WLBH[50] WLBH[51] WLBL[48] WLBL[49]
+   WLBL[50] WLBL[51] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[12] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[4]
+   PCB[1] CENDP DECH[12] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S13 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[13] WLBH[52] WLBH[53] WLBH[54] WLBH[55] WLBL[52] WLBL[53]
+   WLBL[54] WLBL[55] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[13] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[5]
+   PCB[1] CENDP DECH[13] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S14 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[14] WLBH[56] WLBH[57] WLBH[58] WLBH[59] WLBL[56] WLBL[57]
+   WLBL[58] WLBL[59] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[14] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[6]
+   PCB[1] CENDP DECH[14] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S15 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[15] WLBH[60] WLBH[61] WLBH[62] WLBH[63] WLBL[60] WLBL[61]
+   WLBL[62] WLBL[63] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[15] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[7]
+   PCB[1] CENDP DECH[15] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S16 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[16] WLBH[64] WLBH[65] WLBH[66] WLBH[67] WLBL[64] WLBL[65]
+   WLBL[66] WLBL[67] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[16] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] B[0] PCB[2]
+   CENDP DECH[16] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S17 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[17] WLBH[68] WLBH[69] WLBH[70] WLBH[71] WLBL[68] WLBL[69]
+   WLBL[70] WLBL[71] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[17] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[1]
+   PCB[2] CENDP DECH[17] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S18 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[18] WLBH[72] WLBH[73] WLBH[74] WLBH[75] WLBL[72] WLBL[73]
+   WLBL[74] WLBL[75] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[18] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[2]
+   PCB[2] CENDP DECH[18] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S19 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[19] WLBH[76] WLBH[77] WLBH[78] WLBH[79] WLBL[76] WLBL[77]
+   WLBL[78] WLBL[79] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[19] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[3]
+   PCB[2] CENDP DECH[19] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S20 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[20] WLBH[80] WLBH[81] WLBH[82] WLBH[83] WLBL[80] WLBL[81]
+   WLBL[82] WLBL[83] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[20] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[4]
+   PCB[2] CENDP DECH[20] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S21 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[21] WLBH[84] WLBH[85] WLBH[86] WLBH[87] WLBL[84] WLBL[85]
+   WLBL[86] WLBL[87] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[21] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[5]
+   PCB[2] CENDP DECH[21] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S22 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[22] WLBH[88] WLBH[89] WLBH[90] WLBH[91] WLBL[88] WLBL[89]
+   WLBL[90] WLBL[91] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[22] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[6]
+   PCB[2] CENDP DECH[22] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S23 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[23] WLBH[92] WLBH[93] WLBH[94] WLBH[95] WLBL[92] WLBL[93]
+   WLBL[94] WLBL[95] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[23] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[7]
+   PCB[2] CENDP DECH[23] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S24 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[24] WLBH[96] WLBH[97] WLBH[98] WLBH[99] WLBL[96] WLBL[97]
+   WLBL[98] WLBL[99] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[24] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] B[0] PCB[3]
+   CENDP DECH[24] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S25 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[25] WLBH[100] WLBH[101] WLBH[102] WLBH[103] WLBL[100] WLBL[101]
+   WLBL[102] WLBL[103] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[25] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[1] PCB[3] CENDP DECH[25] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S26 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[26] WLBH[104] WLBH[105] WLBH[106] WLBH[107] WLBL[104] WLBL[105]
+   WLBL[106] WLBL[107] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[26] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[2] PCB[3] CENDP DECH[26] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S27 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[27] WLBH[108] WLBH[109] WLBH[110] WLBH[111] WLBL[108] WLBL[109]
+   WLBL[110] WLBL[111] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[27] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[3] PCB[3] CENDP DECH[27] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S28 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[28] WLBH[112] WLBH[113] WLBH[114] WLBH[115] WLBL[112] WLBL[113]
+   WLBL[114] WLBL[115] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[28] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[4] PCB[3] CENDP DECH[28] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S29 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[29] WLBH[116] WLBH[117] WLBH[118] WLBH[119] WLBL[116] WLBL[117]
+   WLBL[118] WLBL[119] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[29] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[5] PCB[3] CENDP DECH[29] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S30 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[30] WLBH[120] WLBH[121] WLBH[122] WLBH[123] WLBL[120] WLBL[121]
+   WLBL[122] WLBL[123] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[30] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[6] PCB[3] CENDP DECH[30] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S31 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[31] WLBH[124] WLBH[125] WLBH[126] WLBH[127] WLBL[124] WLBL[125]
+   WLBL[126] WLBL[127] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[31] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[7] PCB[3] CENDP DECH[31] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F31 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[32] WLBH[128] WLBH[129] WLBH[130] WLBH[131] WLBL[128] WLBL[129]
+   WLBL[130] WLBL[131] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[32] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] B[0] PCB[4] CENDP DECH[32] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F30 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[33] WLBH[132] WLBH[133] WLBH[134] WLBH[135] WLBL[132] WLBL[133]
+   WLBL[134] WLBL[135] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[33] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[1] PCB[4] CENDP DECH[33] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F29 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[34] WLBH[136] WLBH[137] WLBH[138] WLBH[139] WLBL[136] WLBL[137]
+   WLBL[138] WLBL[139] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[34] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[2] PCB[4] CENDP DECH[34] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F28 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[35] WLBH[140] WLBH[141] WLBH[142] WLBH[143] WLBL[140] WLBL[141]
+   WLBL[142] WLBL[143] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[35] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[3] PCB[4] CENDP DECH[35] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F27 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[36] WLBH[144] WLBH[145] WLBH[146] WLBH[147] WLBL[144] WLBL[145]
+   WLBL[146] WLBL[147] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[36] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[4] PCB[4] CENDP DECH[36] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F26 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[37] WLBH[148] WLBH[149] WLBH[150] WLBH[151] WLBL[148] WLBL[149]
+   WLBL[150] WLBL[151] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[37] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[5] PCB[4] CENDP DECH[37] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F25 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[38] WLBH[152] WLBH[153] WLBH[154] WLBH[155] WLBL[152] WLBL[153]
+   WLBL[154] WLBL[155] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[38] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[6] PCB[4] CENDP DECH[38] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F24 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[39] WLBH[156] WLBH[157] WLBH[158] WLBH[159] WLBL[156] WLBL[157]
+   WLBL[158] WLBL[159] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[39] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[7] PCB[4] CENDP DECH[39] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F23 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[40] WLBH[160] WLBH[161] WLBH[162] WLBH[163] WLBL[160] WLBL[161]
+   WLBL[162] WLBL[163] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[40] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] B[0] PCB[5] CENDP DECH[40] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F22 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[41] WLBH[164] WLBH[165] WLBH[166] WLBH[167] WLBL[164] WLBL[165]
+   WLBL[166] WLBL[167] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[41] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[1] PCB[5] CENDP DECH[41] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F21 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[42] WLBH[168] WLBH[169] WLBH[170] WLBH[171] WLBL[168] WLBL[169]
+   WLBL[170] WLBL[171] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[42] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[2] PCB[5] CENDP DECH[42] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F20 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[43] WLBH[172] WLBH[173] WLBH[174] WLBH[175] WLBL[172] WLBL[173]
+   WLBL[174] WLBL[175] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[43] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[3] PCB[5] CENDP DECH[43] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F19 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[44] WLBH[176] WLBH[177] WLBH[178] WLBH[179] WLBL[176] WLBL[177]
+   WLBL[178] WLBL[179] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[44] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[4] PCB[5] CENDP DECH[44] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F18 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[45] WLBH[180] WLBH[181] WLBH[182] WLBH[183] WLBL[180] WLBL[181]
+   WLBL[182] WLBL[183] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[45] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[5] PCB[5] CENDP DECH[45] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F17 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[46] WLBH[184] WLBH[185] WLBH[186] WLBH[187] WLBL[184] WLBL[185]
+   WLBL[186] WLBL[187] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[46] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[6] PCB[5] CENDP DECH[46] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F16 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[47] WLBH[188] WLBH[189] WLBH[190] WLBH[191] WLBL[188] WLBL[189]
+   WLBL[190] WLBL[191] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[47] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[7] PCB[5] CENDP DECH[47] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F15 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[48] WLBH[192] WLBH[193] WLBH[194] WLBH[195] WLBL[192] WLBL[193]
+   WLBL[194] WLBL[195] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[48] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] B[0] PCB[6] CENDP DECH[48] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F14 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[49] WLBH[196] WLBH[197] WLBH[198] WLBH[199] WLBL[196] WLBL[197]
+   WLBL[198] WLBL[199] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[49] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[1] PCB[6] CENDP DECH[49] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F13 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[50] WLBH[200] WLBH[201] WLBH[202] WLBH[203] WLBL[200] WLBL[201]
+   WLBL[202] WLBL[203] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[50] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[2] PCB[6] CENDP DECH[50] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F12 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[51] WLBH[204] WLBH[205] WLBH[206] WLBH[207] WLBL[204] WLBL[205]
+   WLBL[206] WLBL[207] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[51] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[3] PCB[6] CENDP DECH[51] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F11 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[52] WLBH[208] WLBH[209] WLBH[210] WLBH[211] WLBL[208] WLBL[209]
+   WLBL[210] WLBL[211] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[52] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[4] PCB[6] CENDP DECH[52] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F10 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[53] WLBH[212] WLBH[213] WLBH[214] WLBH[215] WLBL[212] WLBL[213]
+   WLBL[214] WLBL[215] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[53] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[5] PCB[6] CENDP DECH[53] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F9 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[54] WLBH[216] WLBH[217] WLBH[218] WLBH[219] WLBL[216] WLBL[217]
+   WLBL[218] WLBL[219] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[54] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[6] PCB[6] CENDP DECH[54] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F8 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[55] WLBH[220] WLBH[221] WLBH[222] WLBH[223] WLBL[220] WLBL[221]
+   WLBL[222] WLBL[223] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[55] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[7] PCB[6] CENDP DECH[55] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F7 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[56] WLBH[224] WLBH[225] WLBH[226] WLBH[227] WLBL[224] WLBL[225]
+   WLBL[226] WLBL[227] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[56] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] B[0] PCB[7] CENDP DECH[56] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F6 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[57] WLBH[228] WLBH[229] WLBH[230] WLBH[231] WLBL[228] WLBL[229]
+   WLBL[230] WLBL[231] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[57] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[1] PCB[7] CENDP DECH[57] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F5 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[58] WLBH[232] WLBH[233] WLBH[234] WLBH[235] WLBL[232] WLBL[233]
+   WLBL[234] WLBL[235] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[58] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[2] PCB[7] CENDP DECH[58] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F4 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[59] WLBH[236] WLBH[237] WLBH[238] WLBH[239] WLBL[236] WLBL[237]
+   WLBL[238] WLBL[239] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[59] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[3] PCB[7] CENDP DECH[59] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F3 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[60] WLBH[240] WLBH[241] WLBH[242] WLBH[243] WLBL[240] WLBL[241]
+   WLBL[242] WLBL[243] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[60] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[4] PCB[7] CENDP DECH[60] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F2 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[61] WLBH[244] WLBH[245] WLBH[246] WLBH[247] WLBL[244] WLBL[245]
+   WLBL[246] WLBL[247] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[61] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[5] PCB[7] CENDP DECH[61] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F1 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[62] WLBH[248] WLBH[249] WLBH[250] WLBH[251] WLBL[248] WLBL[249]
+   WLBL[250] WLBL[251] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[62] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[6] PCB[7] CENDP DECH[62] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F0 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[63] WLBH[252] WLBH[253] WLBH[254] WLBH[255] WLBL[252] WLBL[253]
+   WLBL[254] WLBL[255] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT
+   FLOAT_RET LDFTX LMATCH[63] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB
+   WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] PBB[7] PCB[7] CENDP DECH[63] FLOAT LBKADR0 LBKADR1 LBKADR LITESLP
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] mm16a05_u_hdsp_plus_x4dec
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ary_buf_col ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[0]
+       EDGET[63] LCGTH LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1]
+       VBA VBN VBP VDDA VDDP VDDPI VDDWL VSS WL[0] WL[1] WL[2] WL[3] WL[4]
+       WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13] WL[14] WL[15]
+       WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23] WL[24] WL[25]
+       WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33] WL[34] WL[35]
+       WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42] WL[43] WL[44] WL[45]
+       WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53] WL[54] WL[55]
+       WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63] WL[64] WL[65]
+       WL[66] WL[67] WL[68] WL[69] WL[70] WL[71] WL[72] WL[73] WL[74] WL[75]
+       WL[76] WL[77] WL[78] WL[79] WL[80] WL[81] WL[82] WL[83] WL[84] WL[85]
+       WL[86] WL[87] WL[88] WL[89] WL[90] WL[91] WL[92] WL[93] WL[94] WL[95]
+       WL[96] WL[97] WL[98] WL[99] WL[100] WL[101] WL[102] WL[103] WL[104]
+       WL[105] WL[106] WL[107] WL[108] WL[109] WL[110] WL[111] WL[112] WL[113]
+       WL[114] WL[115] WL[116] WL[117] WL[118] WL[119] WL[120] WL[121] WL[122]
+       WL[123] WL[124] WL[125] WL[126] WL[127] WL[128] WL[129] WL[130] WL[131]
+       WL[132] WL[133] WL[134] WL[135] WL[136] WL[137] WL[138] WL[139] WL[140]
+       WL[141] WL[142] WL[143] WL[144] WL[145] WL[146] WL[147] WL[148] WL[149]
+       WL[150] WL[151] WL[152] WL[153] WL[154] WL[155] WL[156] WL[157] WL[158]
+       WL[159] WL[160] WL[161] WL[162] WL[163] WL[164] WL[165] WL[166] WL[167]
+       WL[168] WL[169] WL[170] WL[171] WL[172] WL[173] WL[174] WL[175] WL[176]
+       WL[177] WL[178] WL[179] WL[180] WL[181] WL[182] WL[183] WL[184] WL[185]
+       WL[186] WL[187] WL[188] WL[189] WL[190] WL[191] WL[192] WL[193] WL[194]
+       WL[195] WL[196] WL[197] WL[198] WL[199] WL[200] WL[201] WL[202] WL[203]
+       WL[204] WL[205] WL[206] WL[207] WL[208] WL[209] WL[210] WL[211] WL[212]
+       WL[213] WL[214] WL[215] WL[216] WL[217] WL[218] WL[219] WL[220] WL[221]
+       WL[222] WL[223] WL[224] WL[225] WL[226] WL[227] WL[228] WL[229] WL[230]
+       WL[231] WL[232] WL[233] WL[234] WL[235] WL[236] WL[237] WL[238] WL[239]
+       WL[240] WL[241] WL[242] WL[243] WL[244] WL[245] WL[246] WL[247] WL[248]
+       WL[249] WL[250] WL[251] WL[252] WL[253] WL[254] WL[255] WLB[0] WLB[1]
+       WLB[2] WLB[3] WLB[4] WLB[5] WLB[6] WLB[7] WLB[8] WLB[9] WLB[10] WLB[11]
+       WLB[12] WLB[13] WLB[14] WLB[15] WLB[16] WLB[17] WLB[18] WLB[19] WLB[20]
+       WLB[21] WLB[22] WLB[23] WLB[24] WLB[25] WLB[26] WLB[27] WLB[28] WLB[29]
+       WLB[30] WLB[31] WLB[32] WLB[33] WLB[34] WLB[35] WLB[36] WLB[37] WLB[38]
+       WLB[39] WLB[40] WLB[41] WLB[42] WLB[43] WLB[44] WLB[45] WLB[46] WLB[47]
+       WLB[48] WLB[49] WLB[50] WLB[51] WLB[52] WLB[53] WLB[54] WLB[55] WLB[56]
+       WLB[57] WLB[58] WLB[59] WLB[60] WLB[61] WLB[62] WLB[63] WLB[64] WLB[65]
+       WLB[66] WLB[67] WLB[68] WLB[69] WLB[70] WLB[71] WLB[72] WLB[73] WLB[74]
+       WLB[75] WLB[76] WLB[77] WLB[78] WLB[79] WLB[80] WLB[81] WLB[82] WLB[83]
+       WLB[84] WLB[85] WLB[86] WLB[87] WLB[88] WLB[89] WLB[90] WLB[91] WLB[92]
+       WLB[93] WLB[94] WLB[95] WLB[96] WLB[97] WLB[98] WLB[99] WLB[100]
+       WLB[101] WLB[102] WLB[103] WLB[104] WLB[105] WLB[106] WLB[107] WLB[108]
+       WLB[109] WLB[110] WLB[111] WLB[112] WLB[113] WLB[114] WLB[115] WLB[116]
+       WLB[117] WLB[118] WLB[119] WLB[120] WLB[121] WLB[122] WLB[123] WLB[124]
+       WLB[125] WLB[126] WLB[127] WLB[128] WLB[129] WLB[130] WLB[131] WLB[132]
+       WLB[133] WLB[134] WLB[135] WLB[136] WLB[137] WLB[138] WLB[139] WLB[140]
+       WLB[141] WLB[142] WLB[143] WLB[144] WLB[145] WLB[146] WLB[147] WLB[148]
+       WLB[149] WLB[150] WLB[151] WLB[152] WLB[153] WLB[154] WLB[155] WLB[156]
+       WLB[157] WLB[158] WLB[159] WLB[160] WLB[161] WLB[162] WLB[163] WLB[164]
+       WLB[165] WLB[166] WLB[167] WLB[168] WLB[169] WLB[170] WLB[171] WLB[172]
+       WLB[173] WLB[174] WLB[175] WLB[176] WLB[177] WLB[178] WLB[179] WLB[180]
+       WLB[181] WLB[182] WLB[183] WLB[184] WLB[185] WLB[186] WLB[187] WLB[188]
+       WLB[189] WLB[190] WLB[191] WLB[192] WLB[193] WLB[194] WLB[195] WLB[196]
+       WLB[197] WLB[198] WLB[199] WLB[200] WLB[201] WLB[202] WLB[203] WLB[204]
+       WLB[205] WLB[206] WLB[207] WLB[208] WLB[209] WLB[210] WLB[211] WLB[212]
+       WLB[213] WLB[214] WLB[215] WLB[216] WLB[217] WLB[218] WLB[219] WLB[220]
+       WLB[221] WLB[222] WLB[223] WLB[224] WLB[225] WLB[226] WLB[227] WLB[228]
+       WLB[229] WLB[230] WLB[231] WLB[232] WLB[233] WLB[234] WLB[235] WLB[236]
+       WLB[237] WLB[238] WLB[239] WLB[240] WLB[241] WLB[242] WLB[243] WLB[244]
+       WLB[245] WLB[246] WLB[247] WLB[248] WLB[249] WLB[250] WLB[251] WLB[252]
+       WLB[253] WLB[254] WLB[255]
X_mm16a05_u_hdsp_plus_x4buf_S0 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[0] WL[1]
+   WL[2] WL[3] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[0] EDGET[0] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[0] WLB[1] WLB[2]
+   WLB[3] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S1 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[4] WL[5]
+   WL[6] WL[7] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[1] EDGET[1] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[4] WLB[5] WLB[6]
+   WLB[7] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S2 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[8] WL[9]
+   WL[10] WL[11] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[2] EDGET[2] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[8] WLB[9] WLB[10]
+   WLB[11] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S3 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[12] WL[13]
+   WL[14] WL[15] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[3] EDGET[3] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[12] WLB[13] WLB[14]
+   WLB[15] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S4 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[16] WL[17]
+   WL[18] WL[19] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[4] EDGET[4] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[16] WLB[17] WLB[18]
+   WLB[19] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S5 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[20] WL[21]
+   WL[22] WL[23] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[5] EDGET[5] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[20] WLB[21] WLB[22]
+   WLB[23] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S6 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[24] WL[25]
+   WL[26] WL[27] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[6] EDGET[6] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[24] WLB[25] WLB[26]
+   WLB[27] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S7 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[28] WL[29]
+   WL[30] WL[31] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[7] EDGET[7] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[28] WLB[29] WLB[30]
+   WLB[31] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S8 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[32] WL[33]
+   WL[34] WL[35] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[8] EDGET[8] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[32] WLB[33] WLB[34]
+   WLB[35] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S9 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[36] WL[37]
+   WL[38] WL[39] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[9] EDGET[9] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[36] WLB[37] WLB[38]
+   WLB[39] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S10 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[40] WL[41]
+   WL[42] WL[43] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[10] EDGET[10] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[40] WLB[41] WLB[42]
+   WLB[43] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S11 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[44] WL[45]
+   WL[46] WL[47] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[11] EDGET[11] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[44] WLB[45] WLB[46]
+   WLB[47] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S12 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[48] WL[49]
+   WL[50] WL[51] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[12] EDGET[12] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[48] WLB[49] WLB[50]
+   WLB[51] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S13 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[52] WL[53]
+   WL[54] WL[55] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[13] EDGET[13] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[52] WLB[53] WLB[54]
+   WLB[55] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S14 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[56] WL[57]
+   WL[58] WL[59] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[14] EDGET[14] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[56] WLB[57] WLB[58]
+   WLB[59] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S15 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[60] WL[61]
+   WL[62] WL[63] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[15] EDGET[15] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[60] WLB[61] WLB[62]
+   WLB[63] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S16 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[64] WL[65]
+   WL[66] WL[67] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[16] EDGET[16] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[64] WLB[65] WLB[66]
+   WLB[67] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S17 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[68] WL[69]
+   WL[70] WL[71] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[17] EDGET[17] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[68] WLB[69] WLB[70]
+   WLB[71] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S18 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[72] WL[73]
+   WL[74] WL[75] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[18] EDGET[18] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[72] WLB[73] WLB[74]
+   WLB[75] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S19 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[76] WL[77]
+   WL[78] WL[79] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[19] EDGET[19] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[76] WLB[77] WLB[78]
+   WLB[79] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S20 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[80] WL[81]
+   WL[82] WL[83] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[20] EDGET[20] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[80] WLB[81] WLB[82]
+   WLB[83] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S21 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[84] WL[85]
+   WL[86] WL[87] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[21] EDGET[21] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[84] WLB[85] WLB[86]
+   WLB[87] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S22 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[88] WL[89]
+   WL[90] WL[91] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[22] EDGET[22] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[88] WLB[89] WLB[90]
+   WLB[91] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S23 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[92] WL[93]
+   WL[94] WL[95] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[23] EDGET[23] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[92] WLB[93] WLB[94]
+   WLB[95] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S24 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[96] WL[97]
+   WL[98] WL[99] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[24] EDGET[24] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[96] WLB[97] WLB[98]
+   WLB[99] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S25 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[100]
+   WL[101] WL[102] WL[103] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[25] EDGET[25] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[100]
+   WLB[101] WLB[102] WLB[103] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S26 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[104]
+   WL[105] WL[106] WL[107] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[26] EDGET[26] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[104]
+   WLB[105] WLB[106] WLB[107] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S27 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[108]
+   WL[109] WL[110] WL[111] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[27] EDGET[27] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[108]
+   WLB[109] WLB[110] WLB[111] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S28 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[112]
+   WL[113] WL[114] WL[115] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[28] EDGET[28] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[112]
+   WLB[113] WLB[114] WLB[115] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S29 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[116]
+   WL[117] WL[118] WL[119] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[29] EDGET[29] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[116]
+   WLB[117] WLB[118] WLB[119] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S30 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[120]
+   WL[121] WL[122] WL[123] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[30] EDGET[30] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[120]
+   WLB[121] WLB[122] WLB[123] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S31 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[124]
+   WL[125] WL[126] WL[127] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[31] EDGET[31] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[124]
+   WLB[125] WLB[126] WLB[127] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F31 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[128]
+   WL[129] WL[130] WL[131] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[32] EDGET[32] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[128]
+   WLB[129] WLB[130] WLB[131] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F30 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[132]
+   WL[133] WL[134] WL[135] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[33] EDGET[33] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[132]
+   WLB[133] WLB[134] WLB[135] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F29 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[136]
+   WL[137] WL[138] WL[139] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[34] EDGET[34] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[136]
+   WLB[137] WLB[138] WLB[139] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F28 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[140]
+   WL[141] WL[142] WL[143] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[35] EDGET[35] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[140]
+   WLB[141] WLB[142] WLB[143] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F27 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[144]
+   WL[145] WL[146] WL[147] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[36] EDGET[36] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[144]
+   WLB[145] WLB[146] WLB[147] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F26 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[148]
+   WL[149] WL[150] WL[151] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[37] EDGET[37] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[148]
+   WLB[149] WLB[150] WLB[151] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F25 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[152]
+   WL[153] WL[154] WL[155] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[38] EDGET[38] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[152]
+   WLB[153] WLB[154] WLB[155] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F24 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[156]
+   WL[157] WL[158] WL[159] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[39] EDGET[39] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[156]
+   WLB[157] WLB[158] WLB[159] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F23 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[160]
+   WL[161] WL[162] WL[163] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[40] EDGET[40] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[160]
+   WLB[161] WLB[162] WLB[163] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F22 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[164]
+   WL[165] WL[166] WL[167] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[41] EDGET[41] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[164]
+   WLB[165] WLB[166] WLB[167] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F21 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[168]
+   WL[169] WL[170] WL[171] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[42] EDGET[42] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[168]
+   WLB[169] WLB[170] WLB[171] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F20 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[172]
+   WL[173] WL[174] WL[175] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[43] EDGET[43] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[172]
+   WLB[173] WLB[174] WLB[175] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F19 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[176]
+   WL[177] WL[178] WL[179] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[44] EDGET[44] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[176]
+   WLB[177] WLB[178] WLB[179] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F18 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[180]
+   WL[181] WL[182] WL[183] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[45] EDGET[45] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[180]
+   WLB[181] WLB[182] WLB[183] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F17 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[184]
+   WL[185] WL[186] WL[187] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[46] EDGET[46] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[184]
+   WLB[185] WLB[186] WLB[187] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F16 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[188]
+   WL[189] WL[190] WL[191] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[47] EDGET[47] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[188]
+   WLB[189] WLB[190] WLB[191] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F15 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[192]
+   WL[193] WL[194] WL[195] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[48] EDGET[48] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[192]
+   WLB[193] WLB[194] WLB[195] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F14 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[196]
+   WL[197] WL[198] WL[199] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[49] EDGET[49] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[196]
+   WLB[197] WLB[198] WLB[199] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F13 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[200]
+   WL[201] WL[202] WL[203] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[50] EDGET[50] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[200]
+   WLB[201] WLB[202] WLB[203] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F12 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[204]
+   WL[205] WL[206] WL[207] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[51] EDGET[51] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[204]
+   WLB[205] WLB[206] WLB[207] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F11 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[208]
+   WL[209] WL[210] WL[211] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[52] EDGET[52] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[208]
+   WLB[209] WLB[210] WLB[211] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F10 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[212]
+   WL[213] WL[214] WL[215] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[53] EDGET[53] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[212]
+   WLB[213] WLB[214] WLB[215] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F9 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[216] WL[217]
+   WL[218] WL[219] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[54] EDGET[54] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[216] WLB[217]
+   WLB[218] WLB[219] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F8 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[220] WL[221]
+   WL[222] WL[223] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[55] EDGET[55] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[220] WLB[221]
+   WLB[222] WLB[223] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F7 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[224] WL[225]
+   WL[226] WL[227] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[56] EDGET[56] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[224] WLB[225]
+   WLB[226] WLB[227] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F6 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[228] WL[229]
+   WL[230] WL[231] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[57] EDGET[57] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[228] WLB[229]
+   WLB[230] WLB[231] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F5 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[232] WL[233]
+   WL[234] WL[235] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[58] EDGET[58] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[232] WLB[233]
+   WLB[234] WLB[235] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F4 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[236] WL[237]
+   WL[238] WL[239] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[59] EDGET[59] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[236] WLB[237]
+   WLB[238] WLB[239] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F3 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[240] WL[241]
+   WL[242] WL[243] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[60] EDGET[60] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[240] WLB[241]
+   WLB[242] WLB[243] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F2 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[244] WL[245]
+   WL[246] WL[247] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[61] EDGET[61] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[244] WLB[245]
+   WLB[246] WLB[247] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F1 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[248] WL[249]
+   WL[250] WL[251] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[62] EDGET[62] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[248] WLB[249]
+   WLB[250] WLB[251] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F0 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[252] WL[253]
+   WL[254] WL[255] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[63] EDGET[63] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[252] WLB[253]
+   WLB[254] WLB[255] mm16a05_u_hdsp_plus_x4buf
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ary_buf_lsh ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB EDGET LCGTH
+       LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTBH[0] RASSISTBH[1] VBA VBN VBP
+       VDDA VDDP VDDPI VDDWL VSS WLBH[0] WLBH[1] WLBH[2] WLBH[3] WLBH[4]
+       WLBH[5] WLBH[6] WLBH[7] WLBH[8] WLBH[9] WLBH[10] WLBH[11] WLBH[12]
+       WLBH[13] WLBH[14] WLBH[15] WLBH[16] WLBH[17] WLBH[18] WLBH[19] WLBH[20]
+       WLBH[21] WLBH[22] WLBH[23] WLBH[24] WLBH[25] WLBH[26] WLBH[27] WLBH[28]
+       WLBH[29] WLBH[30] WLBH[31] WLBH[32] WLBH[33] WLBH[34] WLBH[35] WLBH[36]
+       WLBH[37] WLBH[38] WLBH[39] WLBH[40] WLBH[41] WLBH[42] WLBH[43] WLBH[44]
+       WLBH[45] WLBH[46] WLBH[47] WLBH[48] WLBH[49] WLBH[50] WLBH[51] WLBH[52]
+       WLBH[53] WLBH[54] WLBH[55] WLBH[56] WLBH[57] WLBH[58] WLBH[59] WLBH[60]
+       WLBH[61] WLBH[62] WLBH[63] WLBH[64] WLBH[65] WLBH[66] WLBH[67] WLBH[68]
+       WLBH[69] WLBH[70] WLBH[71] WLBH[72] WLBH[73] WLBH[74] WLBH[75] WLBH[76]
+       WLBH[77] WLBH[78] WLBH[79] WLBH[80] WLBH[81] WLBH[82] WLBH[83] WLBH[84]
+       WLBH[85] WLBH[86] WLBH[87] WLBH[88] WLBH[89] WLBH[90] WLBH[91] WLBH[92]
+       WLBH[93] WLBH[94] WLBH[95] WLBH[96] WLBH[97] WLBH[98] WLBH[99] WLBH[100]
+       WLBH[101] WLBH[102] WLBH[103] WLBH[104] WLBH[105] WLBH[106] WLBH[107]
+       WLBH[108] WLBH[109] WLBH[110] WLBH[111] WLBH[112] WLBH[113] WLBH[114]
+       WLBH[115] WLBH[116] WLBH[117] WLBH[118] WLBH[119] WLBH[120] WLBH[121]
+       WLBH[122] WLBH[123] WLBH[124] WLBH[125] WLBH[126] WLBH[127] WLBH[128]
+       WLBH[129] WLBH[130] WLBH[131] WLBH[132] WLBH[133] WLBH[134] WLBH[135]
+       WLBH[136] WLBH[137] WLBH[138] WLBH[139] WLBH[140] WLBH[141] WLBH[142]
+       WLBH[143] WLBH[144] WLBH[145] WLBH[146] WLBH[147] WLBH[148] WLBH[149]
+       WLBH[150] WLBH[151] WLBH[152] WLBH[153] WLBH[154] WLBH[155] WLBH[156]
+       WLBH[157] WLBH[158] WLBH[159] WLBH[160] WLBH[161] WLBH[162] WLBH[163]
+       WLBH[164] WLBH[165] WLBH[166] WLBH[167] WLBH[168] WLBH[169] WLBH[170]
+       WLBH[171] WLBH[172] WLBH[173] WLBH[174] WLBH[175] WLBH[176] WLBH[177]
+       WLBH[178] WLBH[179] WLBH[180] WLBH[181] WLBH[182] WLBH[183] WLBH[184]
+       WLBH[185] WLBH[186] WLBH[187] WLBH[188] WLBH[189] WLBH[190] WLBH[191]
+       WLBH[192] WLBH[193] WLBH[194] WLBH[195] WLBH[196] WLBH[197] WLBH[198]
+       WLBH[199] WLBH[200] WLBH[201] WLBH[202] WLBH[203] WLBH[204] WLBH[205]
+       WLBH[206] WLBH[207] WLBH[208] WLBH[209] WLBH[210] WLBH[211] WLBH[212]
+       WLBH[213] WLBH[214] WLBH[215] WLBH[216] WLBH[217] WLBH[218] WLBH[219]
+       WLBH[220] WLBH[221] WLBH[222] WLBH[223] WLBH[224] WLBH[225] WLBH[226]
+       WLBH[227] WLBH[228] WLBH[229] WLBH[230] WLBH[231] WLBH[232] WLBH[233]
+       WLBH[234] WLBH[235] WLBH[236] WLBH[237] WLBH[238] WLBH[239] WLBH[240]
+       WLBH[241] WLBH[242] WLBH[243] WLBH[244] WLBH[245] WLBH[246] WLBH[247]
+       WLBH[248] WLBH[249] WLBH[250] WLBH[251] WLBH[252] WLBH[253] WLBH[254]
+       WLBH[255] WLH[0] WLH[1] WLH[2] WLH[3] WLH[4] WLH[5] WLH[6] WLH[7] WLH[8]
+       WLH[9] WLH[10] WLH[11] WLH[12] WLH[13] WLH[14] WLH[15] WLH[16] WLH[17]
+       WLH[18] WLH[19] WLH[20] WLH[21] WLH[22] WLH[23] WLH[24] WLH[25] WLH[26]
+       WLH[27] WLH[28] WLH[29] WLH[30] WLH[31] WLH[32] WLH[33] WLH[34] WLH[35]
+       WLH[36] WLH[37] WLH[38] WLH[39] WLH[40] WLH[41] WLH[42] WLH[43] WLH[44]
+       WLH[45] WLH[46] WLH[47] WLH[48] WLH[49] WLH[50] WLH[51] WLH[52] WLH[53]
+       WLH[54] WLH[55] WLH[56] WLH[57] WLH[58] WLH[59] WLH[60] WLH[61] WLH[62]
+       WLH[63] WLH[64] WLH[65] WLH[66] WLH[67] WLH[68] WLH[69] WLH[70] WLH[71]
+       WLH[72] WLH[73] WLH[74] WLH[75] WLH[76] WLH[77] WLH[78] WLH[79] WLH[80]
+       WLH[81] WLH[82] WLH[83] WLH[84] WLH[85] WLH[86] WLH[87] WLH[88] WLH[89]
+       WLH[90] WLH[91] WLH[92] WLH[93] WLH[94] WLH[95] WLH[96] WLH[97] WLH[98]
+       WLH[99] WLH[100] WLH[101] WLH[102] WLH[103] WLH[104] WLH[105] WLH[106]
+       WLH[107] WLH[108] WLH[109] WLH[110] WLH[111] WLH[112] WLH[113] WLH[114]
+       WLH[115] WLH[116] WLH[117] WLH[118] WLH[119] WLH[120] WLH[121] WLH[122]
+       WLH[123] WLH[124] WLH[125] WLH[126] WLH[127] WLH[128] WLH[129] WLH[130]
+       WLH[131] WLH[132] WLH[133] WLH[134] WLH[135] WLH[136] WLH[137] WLH[138]
+       WLH[139] WLH[140] WLH[141] WLH[142] WLH[143] WLH[144] WLH[145] WLH[146]
+       WLH[147] WLH[148] WLH[149] WLH[150] WLH[151] WLH[152] WLH[153] WLH[154]
+       WLH[155] WLH[156] WLH[157] WLH[158] WLH[159] WLH[160] WLH[161] WLH[162]
+       WLH[163] WLH[164] WLH[165] WLH[166] WLH[167] WLH[168] WLH[169] WLH[170]
+       WLH[171] WLH[172] WLH[173] WLH[174] WLH[175] WLH[176] WLH[177] WLH[178]
+       WLH[179] WLH[180] WLH[181] WLH[182] WLH[183] WLH[184] WLH[185] WLH[186]
+       WLH[187] WLH[188] WLH[189] WLH[190] WLH[191] WLH[192] WLH[193] WLH[194]
+       WLH[195] WLH[196] WLH[197] WLH[198] WLH[199] WLH[200] WLH[201] WLH[202]
+       WLH[203] WLH[204] WLH[205] WLH[206] WLH[207] WLH[208] WLH[209] WLH[210]
+       WLH[211] WLH[212] WLH[213] WLH[214] WLH[215] WLH[216] WLH[217] WLH[218]
+       WLH[219] WLH[220] WLH[221] WLH[222] WLH[223] WLH[224] WLH[225] WLH[226]
+       WLH[227] WLH[228] WLH[229] WLH[230] WLH[231] WLH[232] WLH[233] WLH[234]
+       WLH[235] WLH[236] WLH[237] WLH[238] WLH[239] WLH[240] WLH[241] WLH[242]
+       WLH[243] WLH[244] WLH[245] WLH[246] WLH[247] WLH[248] WLH[249] WLH[250]
+       WLH[251] WLH[252] WLH[253] WLH[254] WLH[255]
X_ary_buf_col ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB EDGET LCGTH LOG0 LOG1 RASSIST[0]
+   RASSIST[1] RASSISTBH[0] RASSISTBH[1] VBA VBN VBP VDDA VDDP VDDPI VDDWL VSS
+   WLH[0] WLH[1] WLH[2] WLH[3] WLH[4] WLH[5] WLH[6] WLH[7] WLH[8] WLH[9]
+   WLH[10] WLH[11] WLH[12] WLH[13] WLH[14] WLH[15] WLH[16] WLH[17] WLH[18]
+   WLH[19] WLH[20] WLH[21] WLH[22] WLH[23] WLH[24] WLH[25] WLH[26] WLH[27]
+   WLH[28] WLH[29] WLH[30] WLH[31] WLH[32] WLH[33] WLH[34] WLH[35] WLH[36]
+   WLH[37] WLH[38] WLH[39] WLH[40] WLH[41] WLH[42] WLH[43] WLH[44] WLH[45]
+   WLH[46] WLH[47] WLH[48] WLH[49] WLH[50] WLH[51] WLH[52] WLH[53] WLH[54]
+   WLH[55] WLH[56] WLH[57] WLH[58] WLH[59] WLH[60] WLH[61] WLH[62] WLH[63]
+   WLH[64] WLH[65] WLH[66] WLH[67] WLH[68] WLH[69] WLH[70] WLH[71] WLH[72]
+   WLH[73] WLH[74] WLH[75] WLH[76] WLH[77] WLH[78] WLH[79] WLH[80] WLH[81]
+   WLH[82] WLH[83] WLH[84] WLH[85] WLH[86] WLH[87] WLH[88] WLH[89] WLH[90]
+   WLH[91] WLH[92] WLH[93] WLH[94] WLH[95] WLH[96] WLH[97] WLH[98] WLH[99]
+   WLH[100] WLH[101] WLH[102] WLH[103] WLH[104] WLH[105] WLH[106] WLH[107]
+   WLH[108] WLH[109] WLH[110] WLH[111] WLH[112] WLH[113] WLH[114] WLH[115]
+   WLH[116] WLH[117] WLH[118] WLH[119] WLH[120] WLH[121] WLH[122] WLH[123]
+   WLH[124] WLH[125] WLH[126] WLH[127] WLH[128] WLH[129] WLH[130] WLH[131]
+   WLH[132] WLH[133] WLH[134] WLH[135] WLH[136] WLH[137] WLH[138] WLH[139]
+   WLH[140] WLH[141] WLH[142] WLH[143] WLH[144] WLH[145] WLH[146] WLH[147]
+   WLH[148] WLH[149] WLH[150] WLH[151] WLH[152] WLH[153] WLH[154] WLH[155]
+   WLH[156] WLH[157] WLH[158] WLH[159] WLH[160] WLH[161] WLH[162] WLH[163]
+   WLH[164] WLH[165] WLH[166] WLH[167] WLH[168] WLH[169] WLH[170] WLH[171]
+   WLH[172] WLH[173] WLH[174] WLH[175] WLH[176] WLH[177] WLH[178] WLH[179]
+   WLH[180] WLH[181] WLH[182] WLH[183] WLH[184] WLH[185] WLH[186] WLH[187]
+   WLH[188] WLH[189] WLH[190] WLH[191] WLH[192] WLH[193] WLH[194] WLH[195]
+   WLH[196] WLH[197] WLH[198] WLH[199] WLH[200] WLH[201] WLH[202] WLH[203]
+   WLH[204] WLH[205] WLH[206] WLH[207] WLH[208] WLH[209] WLH[210] WLH[211]
+   WLH[212] WLH[213] WLH[214] WLH[215] WLH[216] WLH[217] WLH[218] WLH[219]
+   WLH[220] WLH[221] WLH[222] WLH[223] WLH[224] WLH[225] WLH[226] WLH[227]
+   WLH[228] WLH[229] WLH[230] WLH[231] WLH[232] WLH[233] WLH[234] WLH[235]
+   WLH[236] WLH[237] WLH[238] WLH[239] WLH[240] WLH[241] WLH[242] WLH[243]
+   WLH[244] WLH[245] WLH[246] WLH[247] WLH[248] WLH[249] WLH[250] WLH[251]
+   WLH[252] WLH[253] WLH[254] WLH[255] WLBH[0] WLBH[1] WLBH[2] WLBH[3] WLBH[4]
+   WLBH[5] WLBH[6] WLBH[7] WLBH[8] WLBH[9] WLBH[10] WLBH[11] WLBH[12] WLBH[13]
+   WLBH[14] WLBH[15] WLBH[16] WLBH[17] WLBH[18] WLBH[19] WLBH[20] WLBH[21]
+   WLBH[22] WLBH[23] WLBH[24] WLBH[25] WLBH[26] WLBH[27] WLBH[28] WLBH[29]
+   WLBH[30] WLBH[31] WLBH[32] WLBH[33] WLBH[34] WLBH[35] WLBH[36] WLBH[37]
+   WLBH[38] WLBH[39] WLBH[40] WLBH[41] WLBH[42] WLBH[43] WLBH[44] WLBH[45]
+   WLBH[46] WLBH[47] WLBH[48] WLBH[49] WLBH[50] WLBH[51] WLBH[52] WLBH[53]
+   WLBH[54] WLBH[55] WLBH[56] WLBH[57] WLBH[58] WLBH[59] WLBH[60] WLBH[61]
+   WLBH[62] WLBH[63] WLBH[64] WLBH[65] WLBH[66] WLBH[67] WLBH[68] WLBH[69]
+   WLBH[70] WLBH[71] WLBH[72] WLBH[73] WLBH[74] WLBH[75] WLBH[76] WLBH[77]
+   WLBH[78] WLBH[79] WLBH[80] WLBH[81] WLBH[82] WLBH[83] WLBH[84] WLBH[85]
+   WLBH[86] WLBH[87] WLBH[88] WLBH[89] WLBH[90] WLBH[91] WLBH[92] WLBH[93]
+   WLBH[94] WLBH[95] WLBH[96] WLBH[97] WLBH[98] WLBH[99] WLBH[100] WLBH[101]
+   WLBH[102] WLBH[103] WLBH[104] WLBH[105] WLBH[106] WLBH[107] WLBH[108]
+   WLBH[109] WLBH[110] WLBH[111] WLBH[112] WLBH[113] WLBH[114] WLBH[115]
+   WLBH[116] WLBH[117] WLBH[118] WLBH[119] WLBH[120] WLBH[121] WLBH[122]
+   WLBH[123] WLBH[124] WLBH[125] WLBH[126] WLBH[127] WLBH[128] WLBH[129]
+   WLBH[130] WLBH[131] WLBH[132] WLBH[133] WLBH[134] WLBH[135] WLBH[136]
+   WLBH[137] WLBH[138] WLBH[139] WLBH[140] WLBH[141] WLBH[142] WLBH[143]
+   WLBH[144] WLBH[145] WLBH[146] WLBH[147] WLBH[148] WLBH[149] WLBH[150]
+   WLBH[151] WLBH[152] WLBH[153] WLBH[154] WLBH[155] WLBH[156] WLBH[157]
+   WLBH[158] WLBH[159] WLBH[160] WLBH[161] WLBH[162] WLBH[163] WLBH[164]
+   WLBH[165] WLBH[166] WLBH[167] WLBH[168] WLBH[169] WLBH[170] WLBH[171]
+   WLBH[172] WLBH[173] WLBH[174] WLBH[175] WLBH[176] WLBH[177] WLBH[178]
+   WLBH[179] WLBH[180] WLBH[181] WLBH[182] WLBH[183] WLBH[184] WLBH[185]
+   WLBH[186] WLBH[187] WLBH[188] WLBH[189] WLBH[190] WLBH[191] WLBH[192]
+   WLBH[193] WLBH[194] WLBH[195] WLBH[196] WLBH[197] WLBH[198] WLBH[199]
+   WLBH[200] WLBH[201] WLBH[202] WLBH[203] WLBH[204] WLBH[205] WLBH[206]
+   WLBH[207] WLBH[208] WLBH[209] WLBH[210] WLBH[211] WLBH[212] WLBH[213]
+   WLBH[214] WLBH[215] WLBH[216] WLBH[217] WLBH[218] WLBH[219] WLBH[220]
+   WLBH[221] WLBH[222] WLBH[223] WLBH[224] WLBH[225] WLBH[226] WLBH[227]
+   WLBH[228] WLBH[229] WLBH[230] WLBH[231] WLBH[232] WLBH[233] WLBH[234]
+   WLBH[235] WLBH[236] WLBH[237] WLBH[238] WLBH[239] WLBH[240] WLBH[241]
+   WLBH[242] WLBH[243] WLBH[244] WLBH[245] WLBH[246] WLBH[247] WLBH[248]
+   WLBH[249] WLBH[250] WLBH[251] WLBH[252] WLBH[253] WLBH[254] WLBH[255]
+   SNPS_SP_HD_16Kx8_ary_buf_col
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ary_cnt ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1]
+       ARYSD_BC2[0] ARYSD_BC2[1] B BYP_VLOAD C CENDP DEF_MODE EDGEB[0] EDGEB[1]
+       EDGET[0] EDGET[1] FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR0
+       LBKADR1 LCGTH[0] LCGTH[1] LDFTX LITESLP LMATCH LMATCHB LOG0[0] LOG0[1]
+       LOG0[2] LOG1[0] LOG1[1] LOG1[2] LWEIB LXADR[0] LXADR[1] LXADR[2]
+       LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0]
+       PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+       PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] RASSIST[0] RASSIST[1] RASSIST[2]
+       RASSIST[3] RASSISTBH[0] RASSISTBH[1] RASSISTBL[0] RASSISTBL[1] RBLRD
+       RBLWA RBLWR RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T
+       TEST_RNMB VBA[0] VBA[1] VBN[0] VBN[1] VBN[2] VBP[0] VBP[1] VBP[2]
+       VDDA[0] VDDA[1] VDDA[2] VDDMINB VDDP[0] VDDP[1] VDDP[2] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDWL[0] VDDWL[1] VSS[0] VSS[1] VSS[2] VSSC_WL_L
+       VSSC_WL_R WABUF[0] WABUF[1] WABUF[2] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+       WLH[0] WLH[1] WLH[2] WLH[3] WLH[4] WLH[5] WLH[6] WLH[7] WLH[8] WLH[9]
+       WLH[10] WLH[11] WLH[12] WLH[13] WLH[14] WLH[15] WLH[16] WLH[17] WLH[18]
+       WLH[19] WLH[20] WLH[21] WLH[22] WLH[23] WLH[24] WLH[25] WLH[26] WLH[27]
+       WLH[28] WLH[29] WLH[30] WLH[31] WLH[32] WLH[33] WLH[34] WLH[35] WLH[36]
+       WLH[37] WLH[38] WLH[39] WLH[40] WLH[41] WLH[42] WLH[43] WLH[44] WLH[45]
+       WLH[46] WLH[47] WLH[48] WLH[49] WLH[50] WLH[51] WLH[52] WLH[53] WLH[54]
+       WLH[55] WLH[56] WLH[57] WLH[58] WLH[59] WLH[60] WLH[61] WLH[62] WLH[63]
+       WLH[64] WLH[65] WLH[66] WLH[67] WLH[68] WLH[69] WLH[70] WLH[71] WLH[72]
+       WLH[73] WLH[74] WLH[75] WLH[76] WLH[77] WLH[78] WLH[79] WLH[80] WLH[81]
+       WLH[82] WLH[83] WLH[84] WLH[85] WLH[86] WLH[87] WLH[88] WLH[89] WLH[90]
+       WLH[91] WLH[92] WLH[93] WLH[94] WLH[95] WLH[96] WLH[97] WLH[98] WLH[99]
+       WLH[100] WLH[101] WLH[102] WLH[103] WLH[104] WLH[105] WLH[106] WLH[107]
+       WLH[108] WLH[109] WLH[110] WLH[111] WLH[112] WLH[113] WLH[114] WLH[115]
+       WLH[116] WLH[117] WLH[118] WLH[119] WLH[120] WLH[121] WLH[122] WLH[123]
+       WLH[124] WLH[125] WLH[126] WLH[127] WLH[128] WLH[129] WLH[130] WLH[131]
+       WLH[132] WLH[133] WLH[134] WLH[135] WLH[136] WLH[137] WLH[138] WLH[139]
+       WLH[140] WLH[141] WLH[142] WLH[143] WLH[144] WLH[145] WLH[146] WLH[147]
+       WLH[148] WLH[149] WLH[150] WLH[151] WLH[152] WLH[153] WLH[154] WLH[155]
+       WLH[156] WLH[157] WLH[158] WLH[159] WLH[160] WLH[161] WLH[162] WLH[163]
+       WLH[164] WLH[165] WLH[166] WLH[167] WLH[168] WLH[169] WLH[170] WLH[171]
+       WLH[172] WLH[173] WLH[174] WLH[175] WLH[176] WLH[177] WLH[178] WLH[179]
+       WLH[180] WLH[181] WLH[182] WLH[183] WLH[184] WLH[185] WLH[186] WLH[187]
+       WLH[188] WLH[189] WLH[190] WLH[191] WLH[192] WLH[193] WLH[194] WLH[195]
+       WLH[196] WLH[197] WLH[198] WLH[199] WLH[200] WLH[201] WLH[202] WLH[203]
+       WLH[204] WLH[205] WLH[206] WLH[207] WLH[208] WLH[209] WLH[210] WLH[211]
+       WLH[212] WLH[213] WLH[214] WLH[215] WLH[216] WLH[217] WLH[218] WLH[219]
+       WLH[220] WLH[221] WLH[222] WLH[223] WLH[224] WLH[225] WLH[226] WLH[227]
+       WLH[228] WLH[229] WLH[230] WLH[231] WLH[232] WLH[233] WLH[234] WLH[235]
+       WLH[236] WLH[237] WLH[238] WLH[239] WLH[240] WLH[241] WLH[242] WLH[243]
+       WLH[244] WLH[245] WLH[246] WLH[247] WLH[248] WLH[249] WLH[250] WLH[251]
+       WLH[252] WLH[253] WLH[254] WLH[255] WLL[0] WLL[1] WLL[2] WLL[3] WLL[4]
+       WLL[5] WLL[6] WLL[7] WLL[8] WLL[9] WLL[10] WLL[11] WLL[12] WLL[13]
+       WLL[14] WLL[15] WLL[16] WLL[17] WLL[18] WLL[19] WLL[20] WLL[21] WLL[22]
+       WLL[23] WLL[24] WLL[25] WLL[26] WLL[27] WLL[28] WLL[29] WLL[30] WLL[31]
+       WLL[32] WLL[33] WLL[34] WLL[35] WLL[36] WLL[37] WLL[38] WLL[39] WLL[40]
+       WLL[41] WLL[42] WLL[43] WLL[44] WLL[45] WLL[46] WLL[47] WLL[48] WLL[49]
+       WLL[50] WLL[51] WLL[52] WLL[53] WLL[54] WLL[55] WLL[56] WLL[57] WLL[58]
+       WLL[59] WLL[60] WLL[61] WLL[62] WLL[63] WLL[64] WLL[65] WLL[66] WLL[67]
+       WLL[68] WLL[69] WLL[70] WLL[71] WLL[72] WLL[73] WLL[74] WLL[75] WLL[76]
+       WLL[77] WLL[78] WLL[79] WLL[80] WLL[81] WLL[82] WLL[83] WLL[84] WLL[85]
+       WLL[86] WLL[87] WLL[88] WLL[89] WLL[90] WLL[91] WLL[92] WLL[93] WLL[94]
+       WLL[95] WLL[96] WLL[97] WLL[98] WLL[99] WLL[100] WLL[101] WLL[102]
+       WLL[103] WLL[104] WLL[105] WLL[106] WLL[107] WLL[108] WLL[109] WLL[110]
+       WLL[111] WLL[112] WLL[113] WLL[114] WLL[115] WLL[116] WLL[117] WLL[118]
+       WLL[119] WLL[120] WLL[121] WLL[122] WLL[123] WLL[124] WLL[125] WLL[126]
+       WLL[127] WLL[128] WLL[129] WLL[130] WLL[131] WLL[132] WLL[133] WLL[134]
+       WLL[135] WLL[136] WLL[137] WLL[138] WLL[139] WLL[140] WLL[141] WLL[142]
+       WLL[143] WLL[144] WLL[145] WLL[146] WLL[147] WLL[148] WLL[149] WLL[150]
+       WLL[151] WLL[152] WLL[153] WLL[154] WLL[155] WLL[156] WLL[157] WLL[158]
+       WLL[159] WLL[160] WLL[161] WLL[162] WLL[163] WLL[164] WLL[165] WLL[166]
+       WLL[167] WLL[168] WLL[169] WLL[170] WLL[171] WLL[172] WLL[173] WLL[174]
+       WLL[175] WLL[176] WLL[177] WLL[178] WLL[179] WLL[180] WLL[181] WLL[182]
+       WLL[183] WLL[184] WLL[185] WLL[186] WLL[187] WLL[188] WLL[189] WLL[190]
+       WLL[191] WLL[192] WLL[193] WLL[194] WLL[195] WLL[196] WLL[197] WLL[198]
+       WLL[199] WLL[200] WLL[201] WLL[202] WLL[203] WLL[204] WLL[205] WLL[206]
+       WLL[207] WLL[208] WLL[209] WLL[210] WLL[211] WLL[212] WLL[213] WLL[214]
+       WLL[215] WLL[216] WLL[217] WLL[218] WLL[219] WLL[220] WLL[221] WLL[222]
+       WLL[223] WLL[224] WLL[225] WLL[226] WLL[227] WLL[228] WLL[229] WLL[230]
+       WLL[231] WLL[232] WLL[233] WLL[234] WLL[235] WLL[236] WLL[237] WLL[238]
+       WLL[239] WLL[240] WLL[241] WLL[242] WLL[243] WLL[244] WLL[245] WLL[246]
+       WLL[247] WLL[248] WLL[249] WLL[250] WLL[251] WLL[252] WLL[253] WLL[254]
+       WLL[255] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]
X_ary_buf_lsh_l ARYSD[0] ARYSD_BC1[0] ARYSD_BC2[0] EDGEB[0] EDGET[0] LCGTH[0]
+   LOG0[0] LOG1[0] RASSIST[0] RASSIST[1] RASSISTBL[0] RASSISTBL[1] VBA[0]
+   VBN[0] VBP[0] VDDA[0] VDDP[0] VDDPI[0] VDDWL[0] VSS[0] WLBL[0] WLBL[1]
+   WLBL[2] WLBL[3] WLBL[4] WLBL[5] WLBL[6] WLBL[7] WLBL[8] WLBL[9] WLBL[10]
+   WLBL[11] WLBL[12] WLBL[13] WLBL[14] WLBL[15] WLBL[16] WLBL[17] WLBL[18]
+   WLBL[19] WLBL[20] WLBL[21] WLBL[22] WLBL[23] WLBL[24] WLBL[25] WLBL[26]
+   WLBL[27] WLBL[28] WLBL[29] WLBL[30] WLBL[31] WLBL[32] WLBL[33] WLBL[34]
+   WLBL[35] WLBL[36] WLBL[37] WLBL[38] WLBL[39] WLBL[40] WLBL[41] WLBL[42]
+   WLBL[43] WLBL[44] WLBL[45] WLBL[46] WLBL[47] WLBL[48] WLBL[49] WLBL[50]
+   WLBL[51] WLBL[52] WLBL[53] WLBL[54] WLBL[55] WLBL[56] WLBL[57] WLBL[58]
+   WLBL[59] WLBL[60] WLBL[61] WLBL[62] WLBL[63] WLBL[64] WLBL[65] WLBL[66]
+   WLBL[67] WLBL[68] WLBL[69] WLBL[70] WLBL[71] WLBL[72] WLBL[73] WLBL[74]
+   WLBL[75] WLBL[76] WLBL[77] WLBL[78] WLBL[79] WLBL[80] WLBL[81] WLBL[82]
+   WLBL[83] WLBL[84] WLBL[85] WLBL[86] WLBL[87] WLBL[88] WLBL[89] WLBL[90]
+   WLBL[91] WLBL[92] WLBL[93] WLBL[94] WLBL[95] WLBL[96] WLBL[97] WLBL[98]
+   WLBL[99] WLBL[100] WLBL[101] WLBL[102] WLBL[103] WLBL[104] WLBL[105]
+   WLBL[106] WLBL[107] WLBL[108] WLBL[109] WLBL[110] WLBL[111] WLBL[112]
+   WLBL[113] WLBL[114] WLBL[115] WLBL[116] WLBL[117] WLBL[118] WLBL[119]
+   WLBL[120] WLBL[121] WLBL[122] WLBL[123] WLBL[124] WLBL[125] WLBL[126]
+   WLBL[127] WLBL[128] WLBL[129] WLBL[130] WLBL[131] WLBL[132] WLBL[133]
+   WLBL[134] WLBL[135] WLBL[136] WLBL[137] WLBL[138] WLBL[139] WLBL[140]
+   WLBL[141] WLBL[142] WLBL[143] WLBL[144] WLBL[145] WLBL[146] WLBL[147]
+   WLBL[148] WLBL[149] WLBL[150] WLBL[151] WLBL[152] WLBL[153] WLBL[154]
+   WLBL[155] WLBL[156] WLBL[157] WLBL[158] WLBL[159] WLBL[160] WLBL[161]
+   WLBL[162] WLBL[163] WLBL[164] WLBL[165] WLBL[166] WLBL[167] WLBL[168]
+   WLBL[169] WLBL[170] WLBL[171] WLBL[172] WLBL[173] WLBL[174] WLBL[175]
+   WLBL[176] WLBL[177] WLBL[178] WLBL[179] WLBL[180] WLBL[181] WLBL[182]
+   WLBL[183] WLBL[184] WLBL[185] WLBL[186] WLBL[187] WLBL[188] WLBL[189]
+   WLBL[190] WLBL[191] WLBL[192] WLBL[193] WLBL[194] WLBL[195] WLBL[196]
+   WLBL[197] WLBL[198] WLBL[199] WLBL[200] WLBL[201] WLBL[202] WLBL[203]
+   WLBL[204] WLBL[205] WLBL[206] WLBL[207] WLBL[208] WLBL[209] WLBL[210]
+   WLBL[211] WLBL[212] WLBL[213] WLBL[214] WLBL[215] WLBL[216] WLBL[217]
+   WLBL[218] WLBL[219] WLBL[220] WLBL[221] WLBL[222] WLBL[223] WLBL[224]
+   WLBL[225] WLBL[226] WLBL[227] WLBL[228] WLBL[229] WLBL[230] WLBL[231]
+   WLBL[232] WLBL[233] WLBL[234] WLBL[235] WLBL[236] WLBL[237] WLBL[238]
+   WLBL[239] WLBL[240] WLBL[241] WLBL[242] WLBL[243] WLBL[244] WLBL[245]
+   WLBL[246] WLBL[247] WLBL[248] WLBL[249] WLBL[250] WLBL[251] WLBL[252]
+   WLBL[253] WLBL[254] WLBL[255] WLL[0] WLL[1] WLL[2] WLL[3] WLL[4] WLL[5]
+   WLL[6] WLL[7] WLL[8] WLL[9] WLL[10] WLL[11] WLL[12] WLL[13] WLL[14] WLL[15]
+   WLL[16] WLL[17] WLL[18] WLL[19] WLL[20] WLL[21] WLL[22] WLL[23] WLL[24]
+   WLL[25] WLL[26] WLL[27] WLL[28] WLL[29] WLL[30] WLL[31] WLL[32] WLL[33]
+   WLL[34] WLL[35] WLL[36] WLL[37] WLL[38] WLL[39] WLL[40] WLL[41] WLL[42]
+   WLL[43] WLL[44] WLL[45] WLL[46] WLL[47] WLL[48] WLL[49] WLL[50] WLL[51]
+   WLL[52] WLL[53] WLL[54] WLL[55] WLL[56] WLL[57] WLL[58] WLL[59] WLL[60]
+   WLL[61] WLL[62] WLL[63] WLL[64] WLL[65] WLL[66] WLL[67] WLL[68] WLL[69]
+   WLL[70] WLL[71] WLL[72] WLL[73] WLL[74] WLL[75] WLL[76] WLL[77] WLL[78]
+   WLL[79] WLL[80] WLL[81] WLL[82] WLL[83] WLL[84] WLL[85] WLL[86] WLL[87]
+   WLL[88] WLL[89] WLL[90] WLL[91] WLL[92] WLL[93] WLL[94] WLL[95] WLL[96]
+   WLL[97] WLL[98] WLL[99] WLL[100] WLL[101] WLL[102] WLL[103] WLL[104]
+   WLL[105] WLL[106] WLL[107] WLL[108] WLL[109] WLL[110] WLL[111] WLL[112]
+   WLL[113] WLL[114] WLL[115] WLL[116] WLL[117] WLL[118] WLL[119] WLL[120]
+   WLL[121] WLL[122] WLL[123] WLL[124] WLL[125] WLL[126] WLL[127] WLL[128]
+   WLL[129] WLL[130] WLL[131] WLL[132] WLL[133] WLL[134] WLL[135] WLL[136]
+   WLL[137] WLL[138] WLL[139] WLL[140] WLL[141] WLL[142] WLL[143] WLL[144]
+   WLL[145] WLL[146] WLL[147] WLL[148] WLL[149] WLL[150] WLL[151] WLL[152]
+   WLL[153] WLL[154] WLL[155] WLL[156] WLL[157] WLL[158] WLL[159] WLL[160]
+   WLL[161] WLL[162] WLL[163] WLL[164] WLL[165] WLL[166] WLL[167] WLL[168]
+   WLL[169] WLL[170] WLL[171] WLL[172] WLL[173] WLL[174] WLL[175] WLL[176]
+   WLL[177] WLL[178] WLL[179] WLL[180] WLL[181] WLL[182] WLL[183] WLL[184]
+   WLL[185] WLL[186] WLL[187] WLL[188] WLL[189] WLL[190] WLL[191] WLL[192]
+   WLL[193] WLL[194] WLL[195] WLL[196] WLL[197] WLL[198] WLL[199] WLL[200]
+   WLL[201] WLL[202] WLL[203] WLL[204] WLL[205] WLL[206] WLL[207] WLL[208]
+   WLL[209] WLL[210] WLL[211] WLL[212] WLL[213] WLL[214] WLL[215] WLL[216]
+   WLL[217] WLL[218] WLL[219] WLL[220] WLL[221] WLL[222] WLL[223] WLL[224]
+   WLL[225] WLL[226] WLL[227] WLL[228] WLL[229] WLL[230] WLL[231] WLL[232]
+   WLL[233] WLL[234] WLL[235] WLL[236] WLL[237] WLL[238] WLL[239] WLL[240]
+   WLL[241] WLL[242] WLL[243] WLL[244] WLL[245] WLL[246] WLL[247] WLL[248]
+   WLL[249] WLL[250] WLL[251] WLL[252] WLL[253] WLL[254] WLL[255]
+   SNPS_SP_HD_16Kx8_ary_buf_lsh_l
X_ary_xdec B BYP_VLOAD C CENDP DECH[0] DECH[1] DECH[2] DECH[3] DECH[4] DECH[5]
+   DECH[6] DECH[7] DECH[8] DECH[9] DECH[10] DECH[11] DECH[12] DECH[13] DECH[14]
+   DECH[15] DECH[16] DECH[17] DECH[18] DECH[19] DECH[20] DECH[21] DECH[22]
+   DECH[23] DECH[24] DECH[25] DECH[26] DECH[27] DECH[28] DECH[29] DECH[30]
+   DECH[31] DECH[32] DECH[33] DECH[34] DECH[35] DECH[36] DECH[37] DECH[38]
+   DECH[39] DECH[40] DECH[41] DECH[42] DECH[43] DECH[44] DECH[45] DECH[46]
+   DECH[47] DECH[48] DECH[49] DECH[50] DECH[51] DECH[52] DECH[53] DECH[54]
+   DECH[55] DECH[56] DECH[57] DECH[58] DECH[59] DECH[60] DECH[61] DECH[62]
+   DECH[63] DECH[0] DECH[1] DECH[2] DECH[3] DECH[4] DECH[5] DECH[6] DECH[7]
+   DECH[8] DECH[9] DECH[10] DECH[11] DECH[12] DECH[13] DECH[14] DECH[15]
+   DECH[16] DECH[17] DECH[18] DECH[19] DECH[20] DECH[21] DECH[22] DECH[23]
+   DECH[24] DECH[25] DECH[26] DECH[27] DECH[28] DECH[29] DECH[30] DECH[31]
+   DECH[32] DECH[33] DECH[34] DECH[35] DECH[36] DECH[37] DECH[38] DECH[39]
+   DECH[40] DECH[41] DECH[42] DECH[43] DECH[44] DECH[45] DECH[46] DECH[47]
+   DECH[48] DECH[49] DECH[50] DECH[51] DECH[52] DECH[53] DECH[54] DECH[55]
+   DECH[56] DECH[57] DECH[58] DECH[59] DECH[60] DECH[61] DECH[62] DECH[63]
+   DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR0 LBKADR1 LDFTX
+   LITESLP LMATCH LMATCHB LOG0[1] LOG1[1] LWEIB LXADR[0] LXADR[1] LXADR[2]
+   LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1]
+   PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4]
+   PCB[5] PCB[6] PCB[7] RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT RMT[0] RMT[1]
+   RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB VBN[1] VBP[1] VDDA[1] VDDMINB VDDP[1]
+   VDDPI[1] VSS[1] VSSC_WL_L VSSC_WL_R WABUF[0] WABUF[1] WABUF[2] WCLKB[0]
+   WCLKB[1] WCLKB[2] WCLKB[3] WLBH[0] WLBH[1] WLBH[2] WLBH[3] WLBH[4] WLBH[5]
+   WLBH[6] WLBH[7] WLBH[8] WLBH[9] WLBH[10] WLBH[11] WLBH[12] WLBH[13] WLBH[14]
+   WLBH[15] WLBH[16] WLBH[17] WLBH[18] WLBH[19] WLBH[20] WLBH[21] WLBH[22]
+   WLBH[23] WLBH[24] WLBH[25] WLBH[26] WLBH[27] WLBH[28] WLBH[29] WLBH[30]
+   WLBH[31] WLBH[32] WLBH[33] WLBH[34] WLBH[35] WLBH[36] WLBH[37] WLBH[38]
+   WLBH[39] WLBH[40] WLBH[41] WLBH[42] WLBH[43] WLBH[44] WLBH[45] WLBH[46]
+   WLBH[47] WLBH[48] WLBH[49] WLBH[50] WLBH[51] WLBH[52] WLBH[53] WLBH[54]
+   WLBH[55] WLBH[56] WLBH[57] WLBH[58] WLBH[59] WLBH[60] WLBH[61] WLBH[62]
+   WLBH[63] WLBH[64] WLBH[65] WLBH[66] WLBH[67] WLBH[68] WLBH[69] WLBH[70]
+   WLBH[71] WLBH[72] WLBH[73] WLBH[74] WLBH[75] WLBH[76] WLBH[77] WLBH[78]
+   WLBH[79] WLBH[80] WLBH[81] WLBH[82] WLBH[83] WLBH[84] WLBH[85] WLBH[86]
+   WLBH[87] WLBH[88] WLBH[89] WLBH[90] WLBH[91] WLBH[92] WLBH[93] WLBH[94]
+   WLBH[95] WLBH[96] WLBH[97] WLBH[98] WLBH[99] WLBH[100] WLBH[101] WLBH[102]
+   WLBH[103] WLBH[104] WLBH[105] WLBH[106] WLBH[107] WLBH[108] WLBH[109]
+   WLBH[110] WLBH[111] WLBH[112] WLBH[113] WLBH[114] WLBH[115] WLBH[116]
+   WLBH[117] WLBH[118] WLBH[119] WLBH[120] WLBH[121] WLBH[122] WLBH[123]
+   WLBH[124] WLBH[125] WLBH[126] WLBH[127] WLBH[128] WLBH[129] WLBH[130]
+   WLBH[131] WLBH[132] WLBH[133] WLBH[134] WLBH[135] WLBH[136] WLBH[137]
+   WLBH[138] WLBH[139] WLBH[140] WLBH[141] WLBH[142] WLBH[143] WLBH[144]
+   WLBH[145] WLBH[146] WLBH[147] WLBH[148] WLBH[149] WLBH[150] WLBH[151]
+   WLBH[152] WLBH[153] WLBH[154] WLBH[155] WLBH[156] WLBH[157] WLBH[158]
+   WLBH[159] WLBH[160] WLBH[161] WLBH[162] WLBH[163] WLBH[164] WLBH[165]
+   WLBH[166] WLBH[167] WLBH[168] WLBH[169] WLBH[170] WLBH[171] WLBH[172]
+   WLBH[173] WLBH[174] WLBH[175] WLBH[176] WLBH[177] WLBH[178] WLBH[179]
+   WLBH[180] WLBH[181] WLBH[182] WLBH[183] WLBH[184] WLBH[185] WLBH[186]
+   WLBH[187] WLBH[188] WLBH[189] WLBH[190] WLBH[191] WLBH[192] WLBH[193]
+   WLBH[194] WLBH[195] WLBH[196] WLBH[197] WLBH[198] WLBH[199] WLBH[200]
+   WLBH[201] WLBH[202] WLBH[203] WLBH[204] WLBH[205] WLBH[206] WLBH[207]
+   WLBH[208] WLBH[209] WLBH[210] WLBH[211] WLBH[212] WLBH[213] WLBH[214]
+   WLBH[215] WLBH[216] WLBH[217] WLBH[218] WLBH[219] WLBH[220] WLBH[221]
+   WLBH[222] WLBH[223] WLBH[224] WLBH[225] WLBH[226] WLBH[227] WLBH[228]
+   WLBH[229] WLBH[230] WLBH[231] WLBH[232] WLBH[233] WLBH[234] WLBH[235]
+   WLBH[236] WLBH[237] WLBH[238] WLBH[239] WLBH[240] WLBH[241] WLBH[242]
+   WLBH[243] WLBH[244] WLBH[245] WLBH[246] WLBH[247] WLBH[248] WLBH[249]
+   WLBH[250] WLBH[251] WLBH[252] WLBH[253] WLBH[254] WLBH[255] WLBL[0] WLBL[1]
+   WLBL[2] WLBL[3] WLBL[4] WLBL[5] WLBL[6] WLBL[7] WLBL[8] WLBL[9] WLBL[10]
+   WLBL[11] WLBL[12] WLBL[13] WLBL[14] WLBL[15] WLBL[16] WLBL[17] WLBL[18]
+   WLBL[19] WLBL[20] WLBL[21] WLBL[22] WLBL[23] WLBL[24] WLBL[25] WLBL[26]
+   WLBL[27] WLBL[28] WLBL[29] WLBL[30] WLBL[31] WLBL[32] WLBL[33] WLBL[34]
+   WLBL[35] WLBL[36] WLBL[37] WLBL[38] WLBL[39] WLBL[40] WLBL[41] WLBL[42]
+   WLBL[43] WLBL[44] WLBL[45] WLBL[46] WLBL[47] WLBL[48] WLBL[49] WLBL[50]
+   WLBL[51] WLBL[52] WLBL[53] WLBL[54] WLBL[55] WLBL[56] WLBL[57] WLBL[58]
+   WLBL[59] WLBL[60] WLBL[61] WLBL[62] WLBL[63] WLBL[64] WLBL[65] WLBL[66]
+   WLBL[67] WLBL[68] WLBL[69] WLBL[70] WLBL[71] WLBL[72] WLBL[73] WLBL[74]
+   WLBL[75] WLBL[76] WLBL[77] WLBL[78] WLBL[79] WLBL[80] WLBL[81] WLBL[82]
+   WLBL[83] WLBL[84] WLBL[85] WLBL[86] WLBL[87] WLBL[88] WLBL[89] WLBL[90]
+   WLBL[91] WLBL[92] WLBL[93] WLBL[94] WLBL[95] WLBL[96] WLBL[97] WLBL[98]
+   WLBL[99] WLBL[100] WLBL[101] WLBL[102] WLBL[103] WLBL[104] WLBL[105]
+   WLBL[106] WLBL[107] WLBL[108] WLBL[109] WLBL[110] WLBL[111] WLBL[112]
+   WLBL[113] WLBL[114] WLBL[115] WLBL[116] WLBL[117] WLBL[118] WLBL[119]
+   WLBL[120] WLBL[121] WLBL[122] WLBL[123] WLBL[124] WLBL[125] WLBL[126]
+   WLBL[127] WLBL[128] WLBL[129] WLBL[130] WLBL[131] WLBL[132] WLBL[133]
+   WLBL[134] WLBL[135] WLBL[136] WLBL[137] WLBL[138] WLBL[139] WLBL[140]
+   WLBL[141] WLBL[142] WLBL[143] WLBL[144] WLBL[145] WLBL[146] WLBL[147]
+   WLBL[148] WLBL[149] WLBL[150] WLBL[151] WLBL[152] WLBL[153] WLBL[154]
+   WLBL[155] WLBL[156] WLBL[157] WLBL[158] WLBL[159] WLBL[160] WLBL[161]
+   WLBL[162] WLBL[163] WLBL[164] WLBL[165] WLBL[166] WLBL[167] WLBL[168]
+   WLBL[169] WLBL[170] WLBL[171] WLBL[172] WLBL[173] WLBL[174] WLBL[175]
+   WLBL[176] WLBL[177] WLBL[178] WLBL[179] WLBL[180] WLBL[181] WLBL[182]
+   WLBL[183] WLBL[184] WLBL[185] WLBL[186] WLBL[187] WLBL[188] WLBL[189]
+   WLBL[190] WLBL[191] WLBL[192] WLBL[193] WLBL[194] WLBL[195] WLBL[196]
+   WLBL[197] WLBL[198] WLBL[199] WLBL[200] WLBL[201] WLBL[202] WLBL[203]
+   WLBL[204] WLBL[205] WLBL[206] WLBL[207] WLBL[208] WLBL[209] WLBL[210]
+   WLBL[211] WLBL[212] WLBL[213] WLBL[214] WLBL[215] WLBL[216] WLBL[217]
+   WLBL[218] WLBL[219] WLBL[220] WLBL[221] WLBL[222] WLBL[223] WLBL[224]
+   WLBL[225] WLBL[226] WLBL[227] WLBL[228] WLBL[229] WLBL[230] WLBL[231]
+   WLBL[232] WLBL[233] WLBL[234] WLBL[235] WLBL[236] WLBL[237] WLBL[238]
+   WLBL[239] WLBL[240] WLBL[241] WLBL[242] WLBL[243] WLBL[244] WLBL[245]
+   WLBL[246] WLBL[247] WLBL[248] WLBL[249] WLBL[250] WLBL[251] WLBL[252]
+   WLBL[253] WLBL[254] WLBL[255] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] SNPS_SP_HD_16Kx8_ary_xdec
X_ary_buf_lsh ARYSD[1] ARYSD_BC1[1] ARYSD_BC2[1] EDGEB[1] EDGET[1] LCGTH[1]
+   LOG0[2] LOG1[2] RASSIST[2] RASSIST[3] RASSISTBH[0] RASSISTBH[1] VBA[1]
+   VBN[2] VBP[2] VDDA[2] VDDP[2] VDDPI[2] VDDWL[1] VSS[2] WLBH[0] WLBH[1]
+   WLBH[2] WLBH[3] WLBH[4] WLBH[5] WLBH[6] WLBH[7] WLBH[8] WLBH[9] WLBH[10]
+   WLBH[11] WLBH[12] WLBH[13] WLBH[14] WLBH[15] WLBH[16] WLBH[17] WLBH[18]
+   WLBH[19] WLBH[20] WLBH[21] WLBH[22] WLBH[23] WLBH[24] WLBH[25] WLBH[26]
+   WLBH[27] WLBH[28] WLBH[29] WLBH[30] WLBH[31] WLBH[32] WLBH[33] WLBH[34]
+   WLBH[35] WLBH[36] WLBH[37] WLBH[38] WLBH[39] WLBH[40] WLBH[41] WLBH[42]
+   WLBH[43] WLBH[44] WLBH[45] WLBH[46] WLBH[47] WLBH[48] WLBH[49] WLBH[50]
+   WLBH[51] WLBH[52] WLBH[53] WLBH[54] WLBH[55] WLBH[56] WLBH[57] WLBH[58]
+   WLBH[59] WLBH[60] WLBH[61] WLBH[62] WLBH[63] WLBH[64] WLBH[65] WLBH[66]
+   WLBH[67] WLBH[68] WLBH[69] WLBH[70] WLBH[71] WLBH[72] WLBH[73] WLBH[74]
+   WLBH[75] WLBH[76] WLBH[77] WLBH[78] WLBH[79] WLBH[80] WLBH[81] WLBH[82]
+   WLBH[83] WLBH[84] WLBH[85] WLBH[86] WLBH[87] WLBH[88] WLBH[89] WLBH[90]
+   WLBH[91] WLBH[92] WLBH[93] WLBH[94] WLBH[95] WLBH[96] WLBH[97] WLBH[98]
+   WLBH[99] WLBH[100] WLBH[101] WLBH[102] WLBH[103] WLBH[104] WLBH[105]
+   WLBH[106] WLBH[107] WLBH[108] WLBH[109] WLBH[110] WLBH[111] WLBH[112]
+   WLBH[113] WLBH[114] WLBH[115] WLBH[116] WLBH[117] WLBH[118] WLBH[119]
+   WLBH[120] WLBH[121] WLBH[122] WLBH[123] WLBH[124] WLBH[125] WLBH[126]
+   WLBH[127] WLBH[128] WLBH[129] WLBH[130] WLBH[131] WLBH[132] WLBH[133]
+   WLBH[134] WLBH[135] WLBH[136] WLBH[137] WLBH[138] WLBH[139] WLBH[140]
+   WLBH[141] WLBH[142] WLBH[143] WLBH[144] WLBH[145] WLBH[146] WLBH[147]
+   WLBH[148] WLBH[149] WLBH[150] WLBH[151] WLBH[152] WLBH[153] WLBH[154]
+   WLBH[155] WLBH[156] WLBH[157] WLBH[158] WLBH[159] WLBH[160] WLBH[161]
+   WLBH[162] WLBH[163] WLBH[164] WLBH[165] WLBH[166] WLBH[167] WLBH[168]
+   WLBH[169] WLBH[170] WLBH[171] WLBH[172] WLBH[173] WLBH[174] WLBH[175]
+   WLBH[176] WLBH[177] WLBH[178] WLBH[179] WLBH[180] WLBH[181] WLBH[182]
+   WLBH[183] WLBH[184] WLBH[185] WLBH[186] WLBH[187] WLBH[188] WLBH[189]
+   WLBH[190] WLBH[191] WLBH[192] WLBH[193] WLBH[194] WLBH[195] WLBH[196]
+   WLBH[197] WLBH[198] WLBH[199] WLBH[200] WLBH[201] WLBH[202] WLBH[203]
+   WLBH[204] WLBH[205] WLBH[206] WLBH[207] WLBH[208] WLBH[209] WLBH[210]
+   WLBH[211] WLBH[212] WLBH[213] WLBH[214] WLBH[215] WLBH[216] WLBH[217]
+   WLBH[218] WLBH[219] WLBH[220] WLBH[221] WLBH[222] WLBH[223] WLBH[224]
+   WLBH[225] WLBH[226] WLBH[227] WLBH[228] WLBH[229] WLBH[230] WLBH[231]
+   WLBH[232] WLBH[233] WLBH[234] WLBH[235] WLBH[236] WLBH[237] WLBH[238]
+   WLBH[239] WLBH[240] WLBH[241] WLBH[242] WLBH[243] WLBH[244] WLBH[245]
+   WLBH[246] WLBH[247] WLBH[248] WLBH[249] WLBH[250] WLBH[251] WLBH[252]
+   WLBH[253] WLBH[254] WLBH[255] WLH[0] WLH[1] WLH[2] WLH[3] WLH[4] WLH[5]
+   WLH[6] WLH[7] WLH[8] WLH[9] WLH[10] WLH[11] WLH[12] WLH[13] WLH[14] WLH[15]
+   WLH[16] WLH[17] WLH[18] WLH[19] WLH[20] WLH[21] WLH[22] WLH[23] WLH[24]
+   WLH[25] WLH[26] WLH[27] WLH[28] WLH[29] WLH[30] WLH[31] WLH[32] WLH[33]
+   WLH[34] WLH[35] WLH[36] WLH[37] WLH[38] WLH[39] WLH[40] WLH[41] WLH[42]
+   WLH[43] WLH[44] WLH[45] WLH[46] WLH[47] WLH[48] WLH[49] WLH[50] WLH[51]
+   WLH[52] WLH[53] WLH[54] WLH[55] WLH[56] WLH[57] WLH[58] WLH[59] WLH[60]
+   WLH[61] WLH[62] WLH[63] WLH[64] WLH[65] WLH[66] WLH[67] WLH[68] WLH[69]
+   WLH[70] WLH[71] WLH[72] WLH[73] WLH[74] WLH[75] WLH[76] WLH[77] WLH[78]
+   WLH[79] WLH[80] WLH[81] WLH[82] WLH[83] WLH[84] WLH[85] WLH[86] WLH[87]
+   WLH[88] WLH[89] WLH[90] WLH[91] WLH[92] WLH[93] WLH[94] WLH[95] WLH[96]
+   WLH[97] WLH[98] WLH[99] WLH[100] WLH[101] WLH[102] WLH[103] WLH[104]
+   WLH[105] WLH[106] WLH[107] WLH[108] WLH[109] WLH[110] WLH[111] WLH[112]
+   WLH[113] WLH[114] WLH[115] WLH[116] WLH[117] WLH[118] WLH[119] WLH[120]
+   WLH[121] WLH[122] WLH[123] WLH[124] WLH[125] WLH[126] WLH[127] WLH[128]
+   WLH[129] WLH[130] WLH[131] WLH[132] WLH[133] WLH[134] WLH[135] WLH[136]
+   WLH[137] WLH[138] WLH[139] WLH[140] WLH[141] WLH[142] WLH[143] WLH[144]
+   WLH[145] WLH[146] WLH[147] WLH[148] WLH[149] WLH[150] WLH[151] WLH[152]
+   WLH[153] WLH[154] WLH[155] WLH[156] WLH[157] WLH[158] WLH[159] WLH[160]
+   WLH[161] WLH[162] WLH[163] WLH[164] WLH[165] WLH[166] WLH[167] WLH[168]
+   WLH[169] WLH[170] WLH[171] WLH[172] WLH[173] WLH[174] WLH[175] WLH[176]
+   WLH[177] WLH[178] WLH[179] WLH[180] WLH[181] WLH[182] WLH[183] WLH[184]
+   WLH[185] WLH[186] WLH[187] WLH[188] WLH[189] WLH[190] WLH[191] WLH[192]
+   WLH[193] WLH[194] WLH[195] WLH[196] WLH[197] WLH[198] WLH[199] WLH[200]
+   WLH[201] WLH[202] WLH[203] WLH[204] WLH[205] WLH[206] WLH[207] WLH[208]
+   WLH[209] WLH[210] WLH[211] WLH[212] WLH[213] WLH[214] WLH[215] WLH[216]
+   WLH[217] WLH[218] WLH[219] WLH[220] WLH[221] WLH[222] WLH[223] WLH[224]
+   WLH[225] WLH[226] WLH[227] WLH[228] WLH[229] WLH[230] WLH[231] WLH[232]
+   WLH[233] WLH[234] WLH[235] WLH[236] WLH[237] WLH[238] WLH[239] WLH[240]
+   WLH[241] WLH[242] WLH[243] WLH[244] WLH[245] WLH[246] WLH[247] WLH[248]
+   WLH[249] WLH[250] WLH[251] WLH[252] WLH[253] WLH[254] WLH[255]
+   SNPS_SP_HD_16Kx8_ary_buf_lsh
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ary_rt BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7]
+       BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17]
+       BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27]
+       BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37]
+       BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47]
+       BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57]
+       BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1] BT[2] BT[3] BT[4]
+       BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15]
+       BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25]
+       BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+       BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45]
+       BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55]
+       BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB EDGET LOG0
+       LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9]
+       QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4]
+       QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15]
+       SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9]
+       SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2]
+       VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12]
+       VBA[13] VBA[14] VBA[15] VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4]
+       VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13]
+       VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+       VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15]
+       VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+       VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+       VDDA[16] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6]
+       VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14]
+       VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5]
+       VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+       VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+       VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+       VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4]
+       WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13]
+       WBI[14] WBI[15] WL[0] WL[1] WL[2] WL[3] WTI[0] WTI[1] WTI[2] WTI[3]
+       WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12]
+       WTI[13] WTI[14] WTI[15]
X_ary_lt_seg1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] QB[0] QB[1] QB[2] QB[3] QB[4]
+   QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15]
+   QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11]
+   QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+   SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] VBA[0]
+   VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10]
+   VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4]
+   VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14]
+   VBN[15] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8]
+   VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VDDA[0] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10]
+   VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1
+   VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1
+   VDDAIR1 VDDAIR1 VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5]
+   VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14]
+   VDDP[15] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6]
+   VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+   VDDPI[15] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+   VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] WBI[0] WBI[1] WBI[2]
+   WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12]
+   WBI[13] WBI[14] WBI[15] WL[0] WL[1] WL[2] WL[3] WTI[0] WTI[1] WTI[2] WTI[3]
+   WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13]
+   WTI[14] WTI[15] SNPS_SP_HD_16Kx8_ary_lt_seg1
X_mm16a05_u_hdsp_plus_edge4 VDDA[16] VDDP[16] VDDPI[16] VSS[16] VBP[16] VBN[16]
+   EDGEB EDGET LOG0 LOG1 PGIOI VBA[16] VEDGE WL[0] WL[1] WL[2] WL[3]
+   mm16a05_u_hdsp_plus_edge4
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ary_right_strap BB[0] BB[1] BB[2] BB[3] BB[4] BB[5]
+       BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+       BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+       BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+       BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1] BT[2] BT[3]
+       BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14]
+       BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+       BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34]
+       BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44]
+       BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54]
+       BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[0]
+       EDGET[63] LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6]
+       QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1]
+       QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12]
+       QT[13] QT[14] QT[15] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+       SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15]
+       VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9]
+       VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16] VBN[0] VBN[1]
+       VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11]
+       VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2] VBP[3]
+       VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+       VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4]
+       VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+       VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20]
+       VDDA[21] VDDA[22] VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28]
+       VDDA[29] VDDA[30] VDDA[31] VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36]
+       VDDA[37] VDDA[38] VDDA[39] VDDA[40] VDDA[41] VDDA[42] VDDA[43] VDDA[44]
+       VDDA[45] VDDA[46] VDDA[47] VDDA[48] VDDA[49] VDDA[50] VDDA[51] VDDA[52]
+       VDDA[53] VDDA[54] VDDA[55] VDDA[56] VDDA[57] VDDA[58] VDDA[59] VDDA[60]
+       VDDA[61] VDDA[62] VDDA[63] VDDA[64] VDDA[65] VDDA[66] VDDA[67] VDDA[68]
+       VDDA[69] VDDA[70] VDDA[71] VDDA[72] VDDA[73] VDDA[74] VDDA[75] VDDA[76]
+       VDDA[77] VDDA[78] VDDA[79] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+       VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11]
+       VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2]
+       VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+       VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0]
+       VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+       VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2]
+       WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12]
+       WBI[13] WBI[14] WBI[15] WL[0] WL[1] WL[2] WL[3] WL[4] WL[5] WL[6] WL[7]
+       WL[8] WL[9] WL[10] WL[11] WL[12] WL[13] WL[14] WL[15] WL[16] WL[17]
+       WL[18] WL[19] WL[20] WL[21] WL[22] WL[23] WL[24] WL[25] WL[26] WL[27]
+       WL[28] WL[29] WL[30] WL[31] WL[32] WL[33] WL[34] WL[35] WL[36] WL[37]
+       WL[38] WL[39] WL[40] WL[41] WL[42] WL[43] WL[44] WL[45] WL[46] WL[47]
+       WL[48] WL[49] WL[50] WL[51] WL[52] WL[53] WL[54] WL[55] WL[56] WL[57]
+       WL[58] WL[59] WL[60] WL[61] WL[62] WL[63] WL[64] WL[65] WL[66] WL[67]
+       WL[68] WL[69] WL[70] WL[71] WL[72] WL[73] WL[74] WL[75] WL[76] WL[77]
+       WL[78] WL[79] WL[80] WL[81] WL[82] WL[83] WL[84] WL[85] WL[86] WL[87]
+       WL[88] WL[89] WL[90] WL[91] WL[92] WL[93] WL[94] WL[95] WL[96] WL[97]
+       WL[98] WL[99] WL[100] WL[101] WL[102] WL[103] WL[104] WL[105] WL[106]
+       WL[107] WL[108] WL[109] WL[110] WL[111] WL[112] WL[113] WL[114] WL[115]
+       WL[116] WL[117] WL[118] WL[119] WL[120] WL[121] WL[122] WL[123] WL[124]
+       WL[125] WL[126] WL[127] WL[128] WL[129] WL[130] WL[131] WL[132] WL[133]
+       WL[134] WL[135] WL[136] WL[137] WL[138] WL[139] WL[140] WL[141] WL[142]
+       WL[143] WL[144] WL[145] WL[146] WL[147] WL[148] WL[149] WL[150] WL[151]
+       WL[152] WL[153] WL[154] WL[155] WL[156] WL[157] WL[158] WL[159] WL[160]
+       WL[161] WL[162] WL[163] WL[164] WL[165] WL[166] WL[167] WL[168] WL[169]
+       WL[170] WL[171] WL[172] WL[173] WL[174] WL[175] WL[176] WL[177] WL[178]
+       WL[179] WL[180] WL[181] WL[182] WL[183] WL[184] WL[185] WL[186] WL[187]
+       WL[188] WL[189] WL[190] WL[191] WL[192] WL[193] WL[194] WL[195] WL[196]
+       WL[197] WL[198] WL[199] WL[200] WL[201] WL[202] WL[203] WL[204] WL[205]
+       WL[206] WL[207] WL[208] WL[209] WL[210] WL[211] WL[212] WL[213] WL[214]
+       WL[215] WL[216] WL[217] WL[218] WL[219] WL[220] WL[221] WL[222] WL[223]
+       WL[224] WL[225] WL[226] WL[227] WL[228] WL[229] WL[230] WL[231] WL[232]
+       WL[233] WL[234] WL[235] WL[236] WL[237] WL[238] WL[239] WL[240] WL[241]
+       WL[242] WL[243] WL[244] WL[245] WL[246] WL[247] WL[248] WL[249] WL[250]
+       WL[251] WL[252] WL[253] WL[254] WL[255] WTI[0] WTI[1] WTI[2] WTI[3]
+       WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12]
+       WTI[13] WTI[14] WTI[15]
X_ary_rt_S0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[0] EDGET[0] LOG0 LOG1 PGIOI
+   QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+   QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+   QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+   SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2]
+   VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+   VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4]
+   VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13]
+   VDDA[14] VDDA[15] VDDA[16] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+   VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+   VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2] VSS[3]
+   VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13]
+   VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+   WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WL[0]
+   WL[1] WL[2] WL[3] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[1] EDGET[1] LOG0 LOG1 PGIOI
+   QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+   QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+   QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+   SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2]
+   VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+   VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4]
+   VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13]
+   VDDA[14] VDDA[15] VDDA[17] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+   VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+   VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2] VSS[3]
+   VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13]
+   VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+   WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WL[4]
+   WL[5] WL[6] WL[7] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S2 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[2] EDGET[2] LOG0 LOG1 PGIOI
+   QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+   QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+   QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+   SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2]
+   VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+   VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4]
+   VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13]
+   VDDA[14] VDDA[15] VDDA[18] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+   VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+   VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2] VSS[3]
+   VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13]
+   VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+   WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WL[8]
+   WL[9] WL[10] WL[11] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S3 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[3] EDGET[3] LOG0 LOG1 PGIOI
+   QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+   QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+   QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+   SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2]
+   VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+   VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4]
+   VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13]
+   VDDA[14] VDDA[15] VDDA[19] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+   VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+   VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2] VSS[3]
+   VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13]
+   VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+   WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WL[12]
+   WL[13] WL[14] WL[15] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S4 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[4] EDGET[4] LOG0 LOG1 PGIOI
+   QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+   QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+   QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+   SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2]
+   VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+   VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4]
+   VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13]
+   VDDA[14] VDDA[15] VDDA[20] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+   VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+   VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2] VSS[3]
+   VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13]
+   VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+   WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WL[16]
+   WL[17] WL[18] WL[19] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S5 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[5] EDGET[5] LOG0 LOG1 PGIOI
+   QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+   QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+   QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+   SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2]
+   VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+   VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4]
+   VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13]
+   VDDA[14] VDDA[15] VDDA[21] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+   VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+   VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2] VSS[3]
+   VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13]
+   VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+   WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WL[20]
+   WL[21] WL[22] WL[23] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S6 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[6] EDGET[6] LOG0 LOG1 PGIOI
+   QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+   QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+   QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+   SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2]
+   VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+   VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4]
+   VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13]
+   VDDA[14] VDDA[15] VDDA[22] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+   VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+   VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2] VSS[3]
+   VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13]
+   VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+   WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WL[24]
+   WL[25] WL[26] WL[27] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S7 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[7] EDGET[7] LOG0 LOG1 PGIOI
+   QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+   QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+   QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+   SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2]
+   VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+   VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4]
+   VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13]
+   VDDA[14] VDDA[15] VDDA[23] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+   VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+   VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2] VSS[3]
+   VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13]
+   VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+   WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WL[28]
+   WL[29] WL[30] WL[31] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S8 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[8] EDGET[8] LOG0 LOG1 PGIOI
+   QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+   QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+   QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+   SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2]
+   VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+   VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4]
+   VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13]
+   VDDA[14] VDDA[15] VDDA[24] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+   VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+   VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2] VSS[3]
+   VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13]
+   VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+   WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WL[32]
+   WL[33] WL[34] WL[35] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S9 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[9] EDGET[9] LOG0 LOG1 PGIOI
+   QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+   QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+   QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+   SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2]
+   VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+   VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4]
+   VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13]
+   VDDA[14] VDDA[15] VDDA[25] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+   VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+   VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2] VSS[3]
+   VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13]
+   VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+   WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WL[36]
+   WL[37] WL[38] WL[39] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S10 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[10] EDGET[10] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[26] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[40] WL[41] WL[42] WL[43] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S11 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[11] EDGET[11] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[27] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[44] WL[45] WL[46] WL[47] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S12 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[12] EDGET[12] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[28] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[48] WL[49] WL[50] WL[51] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S13 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[13] EDGET[13] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[29] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[52] WL[53] WL[54] WL[55] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S14 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[14] EDGET[14] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[30] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[56] WL[57] WL[58] WL[59] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S15 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[15] EDGET[15] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[31] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[60] WL[61] WL[62] WL[63] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S16 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[16] EDGET[16] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[32] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[64] WL[65] WL[66] WL[67] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S17 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[17] EDGET[17] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[33] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[68] WL[69] WL[70] WL[71] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S18 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[18] EDGET[18] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[34] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[72] WL[73] WL[74] WL[75] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S19 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[19] EDGET[19] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[35] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[76] WL[77] WL[78] WL[79] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S20 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[20] EDGET[20] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[36] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[80] WL[81] WL[82] WL[83] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S21 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[21] EDGET[21] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[37] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[84] WL[85] WL[86] WL[87] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S22 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[22] EDGET[22] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[38] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[88] WL[89] WL[90] WL[91] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S23 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[23] EDGET[23] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[39] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[92] WL[93] WL[94] WL[95] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S24 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[24] EDGET[24] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[40] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[96] WL[97] WL[98] WL[99] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S25 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[25] EDGET[25] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[41] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[100] WL[101] WL[102] WL[103] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S26 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[26] EDGET[26] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[42] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[104] WL[105] WL[106] WL[107] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S27 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[27] EDGET[27] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[43] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[108] WL[109] WL[110] WL[111] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S28 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[28] EDGET[28] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[44] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[112] WL[113] WL[114] WL[115] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S29 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[29] EDGET[29] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[45] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[116] WL[117] WL[118] WL[119] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S30 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[30] EDGET[30] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[46] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[120] WL[121] WL[122] WL[123] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_S31 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[31] EDGET[31] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[47] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[124] WL[125] WL[126] WL[127] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F31 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[32] EDGET[32] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[48] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[128] WL[129] WL[130] WL[131] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F30 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[33] EDGET[33] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[49] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[132] WL[133] WL[134] WL[135] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F29 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[34] EDGET[34] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[50] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[136] WL[137] WL[138] WL[139] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F28 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[35] EDGET[35] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[51] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[140] WL[141] WL[142] WL[143] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F27 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[36] EDGET[36] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[52] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[144] WL[145] WL[146] WL[147] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F26 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[37] EDGET[37] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[53] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[148] WL[149] WL[150] WL[151] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F25 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[38] EDGET[38] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[54] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[152] WL[153] WL[154] WL[155] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F24 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[39] EDGET[39] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[55] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[156] WL[157] WL[158] WL[159] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F23 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[40] EDGET[40] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[56] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[160] WL[161] WL[162] WL[163] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F22 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[41] EDGET[41] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[57] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[164] WL[165] WL[166] WL[167] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F21 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[42] EDGET[42] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[58] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[168] WL[169] WL[170] WL[171] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F20 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[43] EDGET[43] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[59] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[172] WL[173] WL[174] WL[175] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F19 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[44] EDGET[44] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[60] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[176] WL[177] WL[178] WL[179] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F18 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[45] EDGET[45] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[61] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[180] WL[181] WL[182] WL[183] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F17 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[46] EDGET[46] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[62] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[184] WL[185] WL[186] WL[187] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F16 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[47] EDGET[47] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[63] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[188] WL[189] WL[190] WL[191] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F15 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[48] EDGET[48] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[64] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[192] WL[193] WL[194] WL[195] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F14 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[49] EDGET[49] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[65] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[196] WL[197] WL[198] WL[199] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F13 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[50] EDGET[50] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[66] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[200] WL[201] WL[202] WL[203] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F12 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[51] EDGET[51] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[67] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[204] WL[205] WL[206] WL[207] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F11 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[52] EDGET[52] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[68] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[208] WL[209] WL[210] WL[211] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F10 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[53] EDGET[53] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[69] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[212] WL[213] WL[214] WL[215] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F9 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[54] EDGET[54] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[70] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[216] WL[217] WL[218] WL[219] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F8 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[55] EDGET[55] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[71] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[220] WL[221] WL[222] WL[223] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F7 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[56] EDGET[56] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[72] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[224] WL[225] WL[226] WL[227] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F6 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[57] EDGET[57] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[73] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[228] WL[229] WL[230] WL[231] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F5 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[58] EDGET[58] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[74] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[232] WL[233] WL[234] WL[235] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F4 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[59] EDGET[59] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[75] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[236] WL[237] WL[238] WL[239] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F3 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[60] EDGET[60] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[76] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[240] WL[241] WL[242] WL[243] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F2 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[61] EDGET[61] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[77] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[244] WL[245] WL[246] WL[247] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[62] EDGET[62] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[78] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[248] WL[249] WL[250] WL[251] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
X_ary_rt_F0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[63] EDGET[63] LOG0 LOG1
+   PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+   VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[79] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WL[252] WL[253] WL[254] WL[255] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ary_rt
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ary_r_mx_2 ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1]
+       ARYSD_BC2[0] ARYSD_BC2[1] B BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+       BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+       BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+       BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BB[64] BB[65] BB[66]
+       BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75] BB[76]
+       BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83] BB[84] BB[85] BB[86]
+       BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95] BB[96]
+       BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103] BB[104] BB[105]
+       BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BB[112] BB[113] BB[114]
+       BB[115] BB[116] BB[117] BB[118] BB[119] BB[120] BB[121] BB[122] BB[123]
+       BB[124] BB[125] BB[126] BB[127] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+       BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16]
+       BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26]
+       BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35] BT[36]
+       BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+       BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56]
+       BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66]
+       BT[67] BT[68] BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76]
+       BT[77] BT[78] BT[79] BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86]
+       BT[87] BT[88] BT[89] BT[90] BT[91] BT[92] BT[93] BT[94] BT[95] BT[96]
+       BT[97] BT[98] BT[99] BT[100] BT[101] BT[102] BT[103] BT[104] BT[105]
+       BT[106] BT[107] BT[108] BT[109] BT[110] BT[111] BT[112] BT[113] BT[114]
+       BT[115] BT[116] BT[117] BT[118] BT[119] BT[120] BT[121] BT[122] BT[123]
+       BT[124] BT[125] BT[126] BT[127] BYP_VLOAD C CENDP DEF_MODE EDGEB[0]
+       EDGEB[1] EDGEB[2] EDGEB[3] EDGET[0] EDGET[1] EDGET[2] EDGET[3]
+       FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR0 LBKADR1 LCGTH[0]
+       LCGTH[1] LDFTX LITESLP LMATCH LMATCHB LOG0[0] LOG0[1] LOG0[2] LOG0[3]
+       LOG0[4] LOG1[0] LOG1[1] LOG1[2] LOG1[3] LOG1[4] LWEIB LXADR[0] LXADR[1]
+       LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+       PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1]
+       PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] PGIOI[0] PGIOI[1] QB[0] QB[1]
+       QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12]
+       QB[13] QB[14] QB[15] QB[16] QB[17] QB[18] QB[19] QB[20] QB[21] QB[22]
+       QB[23] QB[24] QB[25] QB[26] QB[27] QB[28] QB[29] QB[30] QB[31] QT[0]
+       QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11]
+       QT[12] QT[13] QT[14] QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21]
+       QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28] QT[29] QT[30] QT[31]
+       RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RASSISTBH[0] RASSISTBH[1]
+       RASSISTBL[0] RASSISTBL[1] RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT RMT[0]
+       RMT[1] RMT[2] RMT[3] RWLB_SAC SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5]
+       SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14]
+       SEL[15] SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21] SEL[22] SEL[23]
+       SEL[24] SEL[25] SEL[26] SEL[27] SEL[28] SEL[29] SEL[30] SEL[31] T1T
+       TEST_RNMB VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8]
+       VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16] VBA[17]
+       VBA[18] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23] VBA[24] VBA[25] VBA[26]
+       VBA[27] VBA[28] VBA[29] VBA[30] VBA[31] VBA[32] VBA[33] VBA[34] VBA[35]
+       VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+       VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18]
+       VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27]
+       VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35] VBN[36]
+       VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9]
+       VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18]
+       VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25] VBP[26] VBP[27]
+       VBP[28] VBP[29] VBP[30] VBP[31] VBP[32] VBP[33] VBP[34] VBP[35] VBP[36]
+       VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8]
+       VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16]
+       VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24]
+       VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31] VDDA[32]
+       VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39] VDDA[40]
+       VDDA[41] VDDA[42] VDDA[43] VDDA[44] VDDA[45] VDDA[46] VDDA[47] VDDA[48]
+       VDDA[49] VDDA[50] VDDA[51] VDDA[52] VDDA[53] VDDA[54] VDDA[55] VDDA[56]
+       VDDA[57] VDDA[58] VDDA[59] VDDA[60] VDDA[61] VDDA[62] VDDA[63] VDDA[64]
+       VDDA[65] VDDA[66] VDDA[67] VDDA[68] VDDA[69] VDDA[70] VDDA[71] VDDA[72]
+       VDDA[73] VDDA[74] VDDA[75] VDDA[76] VDDA[77] VDDA[78] VDDA[79] VDDA[80]
+       VDDA[81] VDDA[82] VDDA[83] VDDA[84] VDDA[85] VDDA[86] VDDA[87] VDDA[88]
+       VDDA[89] VDDA[90] VDDA[91] VDDA[92] VDDA[93] VDDA[94] VDDA[95] VDDA[96]
+       VDDA[97] VDDA[98] VDDA[99] VDDA[100] VDDA[101] VDDA[102] VDDA[103]
+       VDDA[104] VDDA[105] VDDA[106] VDDA[107] VDDA[108] VDDA[109] VDDA[110]
+       VDDA[111] VDDA[112] VDDA[113] VDDA[114] VDDA[115] VDDA[116] VDDA[117]
+       VDDA[118] VDDA[119] VDDA[120] VDDA[121] VDDA[122] VDDA[123] VDDA[124]
+       VDDA[125] VDDA[126] VDDA[127] VDDA[128] VDDA[129] VDDA[130] VDDA[131]
+       VDDA[132] VDDA[133] VDDA[134] VDDA[135] VDDA[136] VDDA[137] VDDA[138]
+       VDDA[139] VDDA[140] VDDA[141] VDDA[142] VDDA[143] VDDA[144] VDDA[145]
+       VDDA[146] VDDA[147] VDDA[148] VDDA[149] VDDA[150] VDDA[151] VDDA[152]
+       VDDA[153] VDDA[154] VDDA[155] VDDA[156] VDDA[157] VDDA[158] VDDA[159]
+       VDDA[160] VDDA[161] VDDA[162] VDDAIL1 VDDAIR1 VDDMINB VDDP[0] VDDP[1]
+       VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+       VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+       VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+       VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+       VDDP[35] VDDP[36] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5]
+       VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+       VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19]
+       VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26]
+       VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33]
+       VDDPI[34] VDDPI[35] VDDPI[36] VDDWL[0] VDDWL[1] VEDGE[0] VEDGE[1] VSS[0]
+       VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+       VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19]
+       VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28]
+       VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34] VSS[35] VSS[36]
+       VSSC_WL_L VSSC_WL_R WABUF[0] WABUF[1] WABUF[2] WBI[0] WBI[1] WBI[2]
+       WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12]
+       WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21]
+       WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27] WBI[28] WBI[29] WBI[30]
+       WBI[31] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] WLH[0] WLH[1] WLH[2] WLH[3]
+       WLH[4] WLH[5] WLH[6] WLH[7] WLH[8] WLH[9] WLH[10] WLH[11] WLH[12]
+       WLH[13] WLH[14] WLH[15] WLH[16] WLH[17] WLH[18] WLH[19] WLH[20] WLH[21]
+       WLH[22] WLH[23] WLH[24] WLH[25] WLH[26] WLH[27] WLH[28] WLH[29] WLH[30]
+       WLH[31] WLH[32] WLH[33] WLH[34] WLH[35] WLH[36] WLH[37] WLH[38] WLH[39]
+       WLH[40] WLH[41] WLH[42] WLH[43] WLH[44] WLH[45] WLH[46] WLH[47] WLH[48]
+       WLH[49] WLH[50] WLH[51] WLH[52] WLH[53] WLH[54] WLH[55] WLH[56] WLH[57]
+       WLH[58] WLH[59] WLH[60] WLH[61] WLH[62] WLH[63] WLH[64] WLH[65] WLH[66]
+       WLH[67] WLH[68] WLH[69] WLH[70] WLH[71] WLH[72] WLH[73] WLH[74] WLH[75]
+       WLH[76] WLH[77] WLH[78] WLH[79] WLH[80] WLH[81] WLH[82] WLH[83] WLH[84]
+       WLH[85] WLH[86] WLH[87] WLH[88] WLH[89] WLH[90] WLH[91] WLH[92] WLH[93]
+       WLH[94] WLH[95] WLH[96] WLH[97] WLH[98] WLH[99] WLH[100] WLH[101]
+       WLH[102] WLH[103] WLH[104] WLH[105] WLH[106] WLH[107] WLH[108] WLH[109]
+       WLH[110] WLH[111] WLH[112] WLH[113] WLH[114] WLH[115] WLH[116] WLH[117]
+       WLH[118] WLH[119] WLH[120] WLH[121] WLH[122] WLH[123] WLH[124] WLH[125]
+       WLH[126] WLH[127] WLH[128] WLH[129] WLH[130] WLH[131] WLH[132] WLH[133]
+       WLH[134] WLH[135] WLH[136] WLH[137] WLH[138] WLH[139] WLH[140] WLH[141]
+       WLH[142] WLH[143] WLH[144] WLH[145] WLH[146] WLH[147] WLH[148] WLH[149]
+       WLH[150] WLH[151] WLH[152] WLH[153] WLH[154] WLH[155] WLH[156] WLH[157]
+       WLH[158] WLH[159] WLH[160] WLH[161] WLH[162] WLH[163] WLH[164] WLH[165]
+       WLH[166] WLH[167] WLH[168] WLH[169] WLH[170] WLH[171] WLH[172] WLH[173]
+       WLH[174] WLH[175] WLH[176] WLH[177] WLH[178] WLH[179] WLH[180] WLH[181]
+       WLH[182] WLH[183] WLH[184] WLH[185] WLH[186] WLH[187] WLH[188] WLH[189]
+       WLH[190] WLH[191] WLH[192] WLH[193] WLH[194] WLH[195] WLH[196] WLH[197]
+       WLH[198] WLH[199] WLH[200] WLH[201] WLH[202] WLH[203] WLH[204] WLH[205]
+       WLH[206] WLH[207] WLH[208] WLH[209] WLH[210] WLH[211] WLH[212] WLH[213]
+       WLH[214] WLH[215] WLH[216] WLH[217] WLH[218] WLH[219] WLH[220] WLH[221]
+       WLH[222] WLH[223] WLH[224] WLH[225] WLH[226] WLH[227] WLH[228] WLH[229]
+       WLH[230] WLH[231] WLH[232] WLH[233] WLH[234] WLH[235] WLH[236] WLH[237]
+       WLH[238] WLH[239] WLH[240] WLH[241] WLH[242] WLH[243] WLH[244] WLH[245]
+       WLH[246] WLH[247] WLH[248] WLH[249] WLH[250] WLH[251] WLH[252] WLH[253]
+       WLH[254] WLH[255] WLL[0] WLL[1] WLL[2] WLL[3] WLL[4] WLL[5] WLL[6]
+       WLL[7] WLL[8] WLL[9] WLL[10] WLL[11] WLL[12] WLL[13] WLL[14] WLL[15]
+       WLL[16] WLL[17] WLL[18] WLL[19] WLL[20] WLL[21] WLL[22] WLL[23] WLL[24]
+       WLL[25] WLL[26] WLL[27] WLL[28] WLL[29] WLL[30] WLL[31] WLL[32] WLL[33]
+       WLL[34] WLL[35] WLL[36] WLL[37] WLL[38] WLL[39] WLL[40] WLL[41] WLL[42]
+       WLL[43] WLL[44] WLL[45] WLL[46] WLL[47] WLL[48] WLL[49] WLL[50] WLL[51]
+       WLL[52] WLL[53] WLL[54] WLL[55] WLL[56] WLL[57] WLL[58] WLL[59] WLL[60]
+       WLL[61] WLL[62] WLL[63] WLL[64] WLL[65] WLL[66] WLL[67] WLL[68] WLL[69]
+       WLL[70] WLL[71] WLL[72] WLL[73] WLL[74] WLL[75] WLL[76] WLL[77] WLL[78]
+       WLL[79] WLL[80] WLL[81] WLL[82] WLL[83] WLL[84] WLL[85] WLL[86] WLL[87]
+       WLL[88] WLL[89] WLL[90] WLL[91] WLL[92] WLL[93] WLL[94] WLL[95] WLL[96]
+       WLL[97] WLL[98] WLL[99] WLL[100] WLL[101] WLL[102] WLL[103] WLL[104]
+       WLL[105] WLL[106] WLL[107] WLL[108] WLL[109] WLL[110] WLL[111] WLL[112]
+       WLL[113] WLL[114] WLL[115] WLL[116] WLL[117] WLL[118] WLL[119] WLL[120]
+       WLL[121] WLL[122] WLL[123] WLL[124] WLL[125] WLL[126] WLL[127] WLL[128]
+       WLL[129] WLL[130] WLL[131] WLL[132] WLL[133] WLL[134] WLL[135] WLL[136]
+       WLL[137] WLL[138] WLL[139] WLL[140] WLL[141] WLL[142] WLL[143] WLL[144]
+       WLL[145] WLL[146] WLL[147] WLL[148] WLL[149] WLL[150] WLL[151] WLL[152]
+       WLL[153] WLL[154] WLL[155] WLL[156] WLL[157] WLL[158] WLL[159] WLL[160]
+       WLL[161] WLL[162] WLL[163] WLL[164] WLL[165] WLL[166] WLL[167] WLL[168]
+       WLL[169] WLL[170] WLL[171] WLL[172] WLL[173] WLL[174] WLL[175] WLL[176]
+       WLL[177] WLL[178] WLL[179] WLL[180] WLL[181] WLL[182] WLL[183] WLL[184]
+       WLL[185] WLL[186] WLL[187] WLL[188] WLL[189] WLL[190] WLL[191] WLL[192]
+       WLL[193] WLL[194] WLL[195] WLL[196] WLL[197] WLL[198] WLL[199] WLL[200]
+       WLL[201] WLL[202] WLL[203] WLL[204] WLL[205] WLL[206] WLL[207] WLL[208]
+       WLL[209] WLL[210] WLL[211] WLL[212] WLL[213] WLL[214] WLL[215] WLL[216]
+       WLL[217] WLL[218] WLL[219] WLL[220] WLL[221] WLL[222] WLL[223] WLL[224]
+       WLL[225] WLL[226] WLL[227] WLL[228] WLL[229] WLL[230] WLL[231] WLL[232]
+       WLL[233] WLL[234] WLL[235] WLL[236] WLL[237] WLL[238] WLL[239] WLL[240]
+       WLL[241] WLL[242] WLL[243] WLL[244] WLL[245] WLL[246] WLL[247] WLL[248]
+       WLL[249] WLL[250] WLL[251] WLL[252] WLL[253] WLL[254] WLL[255] WMT[0]
+       WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WTI[0] WTI[1] WTI[2]
+       WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12]
+       WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21]
+       WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27] WTI[28] WTI[29] WTI[30]
+       WTI[31]
X_ary_left_strap BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9]
+   BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20]
+   BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31]
+   BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42]
+   BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53]
+   BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34]
+   BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45]
+   BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56]
+   BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] EDGEB[0] EDGET[0] LOG0[0]
+   LOG1[0] PGIOI[0] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9]
+   QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4]
+   QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15]
+   SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9]
+   SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3]
+   VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13]
+   VBA[14] VBA[15] VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+   VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+   VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9]
+   VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10]
+   VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17] VDDA[18]
+   VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24] VDDA[25] VDDA[26]
+   VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31] VDDA[32] VDDA[33] VDDA[34]
+   VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39] VDDA[40] VDDA[41] VDDA[42]
+   VDDA[43] VDDA[44] VDDA[45] VDDA[46] VDDA[47] VDDA[48] VDDA[49] VDDA[50]
+   VDDA[51] VDDA[52] VDDA[53] VDDA[54] VDDA[55] VDDA[56] VDDA[57] VDDA[58]
+   VDDA[59] VDDA[60] VDDA[61] VDDA[62] VDDA[63] VDDA[64] VDDA[65] VDDA[66]
+   VDDA[67] VDDA[68] VDDA[69] VDDA[70] VDDA[71] VDDA[72] VDDA[73] VDDA[74]
+   VDDA[75] VDDA[76] VDDA[77] VDDA[78] VDDA[79] VDDAIL1 VDDP[0] VDDP[1] VDDP[2]
+   VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11]
+   VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2]
+   VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+   VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE[0] VSS[0]
+   VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+   VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1] WBI[2] WBI[3]
+   WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13]
+   WBI[14] WBI[15] WLL[0] WLL[1] WLL[2] WLL[3] WLL[4] WLL[5] WLL[6] WLL[7]
+   WLL[8] WLL[9] WLL[10] WLL[11] WLL[12] WLL[13] WLL[14] WLL[15] WLL[16]
+   WLL[17] WLL[18] WLL[19] WLL[20] WLL[21] WLL[22] WLL[23] WLL[24] WLL[25]
+   WLL[26] WLL[27] WLL[28] WLL[29] WLL[30] WLL[31] WLL[32] WLL[33] WLL[34]
+   WLL[35] WLL[36] WLL[37] WLL[38] WLL[39] WLL[40] WLL[41] WLL[42] WLL[43]
+   WLL[44] WLL[45] WLL[46] WLL[47] WLL[48] WLL[49] WLL[50] WLL[51] WLL[52]
+   WLL[53] WLL[54] WLL[55] WLL[56] WLL[57] WLL[58] WLL[59] WLL[60] WLL[61]
+   WLL[62] WLL[63] WLL[64] WLL[65] WLL[66] WLL[67] WLL[68] WLL[69] WLL[70]
+   WLL[71] WLL[72] WLL[73] WLL[74] WLL[75] WLL[76] WLL[77] WLL[78] WLL[79]
+   WLL[80] WLL[81] WLL[82] WLL[83] WLL[84] WLL[85] WLL[86] WLL[87] WLL[88]
+   WLL[89] WLL[90] WLL[91] WLL[92] WLL[93] WLL[94] WLL[95] WLL[96] WLL[97]
+   WLL[98] WLL[99] WLL[100] WLL[101] WLL[102] WLL[103] WLL[104] WLL[105]
+   WLL[106] WLL[107] WLL[108] WLL[109] WLL[110] WLL[111] WLL[112] WLL[113]
+   WLL[114] WLL[115] WLL[116] WLL[117] WLL[118] WLL[119] WLL[120] WLL[121]
+   WLL[122] WLL[123] WLL[124] WLL[125] WLL[126] WLL[127] WLL[128] WLL[129]
+   WLL[130] WLL[131] WLL[132] WLL[133] WLL[134] WLL[135] WLL[136] WLL[137]
+   WLL[138] WLL[139] WLL[140] WLL[141] WLL[142] WLL[143] WLL[144] WLL[145]
+   WLL[146] WLL[147] WLL[148] WLL[149] WLL[150] WLL[151] WLL[152] WLL[153]
+   WLL[154] WLL[155] WLL[156] WLL[157] WLL[158] WLL[159] WLL[160] WLL[161]
+   WLL[162] WLL[163] WLL[164] WLL[165] WLL[166] WLL[167] WLL[168] WLL[169]
+   WLL[170] WLL[171] WLL[172] WLL[173] WLL[174] WLL[175] WLL[176] WLL[177]
+   WLL[178] WLL[179] WLL[180] WLL[181] WLL[182] WLL[183] WLL[184] WLL[185]
+   WLL[186] WLL[187] WLL[188] WLL[189] WLL[190] WLL[191] WLL[192] WLL[193]
+   WLL[194] WLL[195] WLL[196] WLL[197] WLL[198] WLL[199] WLL[200] WLL[201]
+   WLL[202] WLL[203] WLL[204] WLL[205] WLL[206] WLL[207] WLL[208] WLL[209]
+   WLL[210] WLL[211] WLL[212] WLL[213] WLL[214] WLL[215] WLL[216] WLL[217]
+   WLL[218] WLL[219] WLL[220] WLL[221] WLL[222] WLL[223] WLL[224] WLL[225]
+   WLL[226] WLL[227] WLL[228] WLL[229] WLL[230] WLL[231] WLL[232] WLL[233]
+   WLL[234] WLL[235] WLL[236] WLL[237] WLL[238] WLL[239] WLL[240] WLL[241]
+   WLL[242] WLL[243] WLL[244] WLL[245] WLL[246] WLL[247] WLL[248] WLL[249]
+   WLL[250] WLL[251] WLL[252] WLL[253] WLL[254] WLL[255] WTI[0] WTI[1] WTI[2]
+   WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12]
+   WTI[13] WTI[14] WTI[15] SNPS_SP_HD_16Kx8_ary_left_strap
X_ary_cnt ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1]
+   B BYP_VLOAD C CENDP DEF_MODE EDGEB[1] EDGEB[2] EDGET[1] EDGET[2] FAST1_MODE
+   FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR0 LBKADR1 LCGTH[0] LCGTH[1] LDFTX
+   LITESLP LMATCH LMATCHB LOG0[1] LOG0[2] LOG0[3] LOG1[1] LOG1[2] LOG1[3] LWEIB
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] RASSIST[0]
+   RASSIST[1] RASSIST[2] RASSIST[3] RASSISTBH[0] RASSISTBH[1] RASSISTBL[0]
+   RASSISTBL[1] RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3]
+   RWLB_SAC T1T TEST_RNMB VBA[17] VBA[18] VBN[17] VBN[18] VBN[19] VBP[17]
+   VBP[18] VBP[19] VDDA[80] VDDA[81] VDDA[82] VDDMINB VDDP[17] VDDP[18]
+   VDDP[19] VDDPI[17] VDDPI[18] VDDPI[19] VDDWL[0] VDDWL[1] VSS[17] VSS[18]
+   VSS[19] VSSC_WL_L VSSC_WL_R WABUF[0] WABUF[1] WABUF[2] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] WLH[0] WLH[1] WLH[2] WLH[3] WLH[4] WLH[5] WLH[6] WLH[7]
+   WLH[8] WLH[9] WLH[10] WLH[11] WLH[12] WLH[13] WLH[14] WLH[15] WLH[16]
+   WLH[17] WLH[18] WLH[19] WLH[20] WLH[21] WLH[22] WLH[23] WLH[24] WLH[25]
+   WLH[26] WLH[27] WLH[28] WLH[29] WLH[30] WLH[31] WLH[32] WLH[33] WLH[34]
+   WLH[35] WLH[36] WLH[37] WLH[38] WLH[39] WLH[40] WLH[41] WLH[42] WLH[43]
+   WLH[44] WLH[45] WLH[46] WLH[47] WLH[48] WLH[49] WLH[50] WLH[51] WLH[52]
+   WLH[53] WLH[54] WLH[55] WLH[56] WLH[57] WLH[58] WLH[59] WLH[60] WLH[61]
+   WLH[62] WLH[63] WLH[64] WLH[65] WLH[66] WLH[67] WLH[68] WLH[69] WLH[70]
+   WLH[71] WLH[72] WLH[73] WLH[74] WLH[75] WLH[76] WLH[77] WLH[78] WLH[79]
+   WLH[80] WLH[81] WLH[82] WLH[83] WLH[84] WLH[85] WLH[86] WLH[87] WLH[88]
+   WLH[89] WLH[90] WLH[91] WLH[92] WLH[93] WLH[94] WLH[95] WLH[96] WLH[97]
+   WLH[98] WLH[99] WLH[100] WLH[101] WLH[102] WLH[103] WLH[104] WLH[105]
+   WLH[106] WLH[107] WLH[108] WLH[109] WLH[110] WLH[111] WLH[112] WLH[113]
+   WLH[114] WLH[115] WLH[116] WLH[117] WLH[118] WLH[119] WLH[120] WLH[121]
+   WLH[122] WLH[123] WLH[124] WLH[125] WLH[126] WLH[127] WLH[128] WLH[129]
+   WLH[130] WLH[131] WLH[132] WLH[133] WLH[134] WLH[135] WLH[136] WLH[137]
+   WLH[138] WLH[139] WLH[140] WLH[141] WLH[142] WLH[143] WLH[144] WLH[145]
+   WLH[146] WLH[147] WLH[148] WLH[149] WLH[150] WLH[151] WLH[152] WLH[153]
+   WLH[154] WLH[155] WLH[156] WLH[157] WLH[158] WLH[159] WLH[160] WLH[161]
+   WLH[162] WLH[163] WLH[164] WLH[165] WLH[166] WLH[167] WLH[168] WLH[169]
+   WLH[170] WLH[171] WLH[172] WLH[173] WLH[174] WLH[175] WLH[176] WLH[177]
+   WLH[178] WLH[179] WLH[180] WLH[181] WLH[182] WLH[183] WLH[184] WLH[185]
+   WLH[186] WLH[187] WLH[188] WLH[189] WLH[190] WLH[191] WLH[192] WLH[193]
+   WLH[194] WLH[195] WLH[196] WLH[197] WLH[198] WLH[199] WLH[200] WLH[201]
+   WLH[202] WLH[203] WLH[204] WLH[205] WLH[206] WLH[207] WLH[208] WLH[209]
+   WLH[210] WLH[211] WLH[212] WLH[213] WLH[214] WLH[215] WLH[216] WLH[217]
+   WLH[218] WLH[219] WLH[220] WLH[221] WLH[222] WLH[223] WLH[224] WLH[225]
+   WLH[226] WLH[227] WLH[228] WLH[229] WLH[230] WLH[231] WLH[232] WLH[233]
+   WLH[234] WLH[235] WLH[236] WLH[237] WLH[238] WLH[239] WLH[240] WLH[241]
+   WLH[242] WLH[243] WLH[244] WLH[245] WLH[246] WLH[247] WLH[248] WLH[249]
+   WLH[250] WLH[251] WLH[252] WLH[253] WLH[254] WLH[255] WLL[0] WLL[1] WLL[2]
+   WLL[3] WLL[4] WLL[5] WLL[6] WLL[7] WLL[8] WLL[9] WLL[10] WLL[11] WLL[12]
+   WLL[13] WLL[14] WLL[15] WLL[16] WLL[17] WLL[18] WLL[19] WLL[20] WLL[21]
+   WLL[22] WLL[23] WLL[24] WLL[25] WLL[26] WLL[27] WLL[28] WLL[29] WLL[30]
+   WLL[31] WLL[32] WLL[33] WLL[34] WLL[35] WLL[36] WLL[37] WLL[38] WLL[39]
+   WLL[40] WLL[41] WLL[42] WLL[43] WLL[44] WLL[45] WLL[46] WLL[47] WLL[48]
+   WLL[49] WLL[50] WLL[51] WLL[52] WLL[53] WLL[54] WLL[55] WLL[56] WLL[57]
+   WLL[58] WLL[59] WLL[60] WLL[61] WLL[62] WLL[63] WLL[64] WLL[65] WLL[66]
+   WLL[67] WLL[68] WLL[69] WLL[70] WLL[71] WLL[72] WLL[73] WLL[74] WLL[75]
+   WLL[76] WLL[77] WLL[78] WLL[79] WLL[80] WLL[81] WLL[82] WLL[83] WLL[84]
+   WLL[85] WLL[86] WLL[87] WLL[88] WLL[89] WLL[90] WLL[91] WLL[92] WLL[93]
+   WLL[94] WLL[95] WLL[96] WLL[97] WLL[98] WLL[99] WLL[100] WLL[101] WLL[102]
+   WLL[103] WLL[104] WLL[105] WLL[106] WLL[107] WLL[108] WLL[109] WLL[110]
+   WLL[111] WLL[112] WLL[113] WLL[114] WLL[115] WLL[116] WLL[117] WLL[118]
+   WLL[119] WLL[120] WLL[121] WLL[122] WLL[123] WLL[124] WLL[125] WLL[126]
+   WLL[127] WLL[128] WLL[129] WLL[130] WLL[131] WLL[132] WLL[133] WLL[134]
+   WLL[135] WLL[136] WLL[137] WLL[138] WLL[139] WLL[140] WLL[141] WLL[142]
+   WLL[143] WLL[144] WLL[145] WLL[146] WLL[147] WLL[148] WLL[149] WLL[150]
+   WLL[151] WLL[152] WLL[153] WLL[154] WLL[155] WLL[156] WLL[157] WLL[158]
+   WLL[159] WLL[160] WLL[161] WLL[162] WLL[163] WLL[164] WLL[165] WLL[166]
+   WLL[167] WLL[168] WLL[169] WLL[170] WLL[171] WLL[172] WLL[173] WLL[174]
+   WLL[175] WLL[176] WLL[177] WLL[178] WLL[179] WLL[180] WLL[181] WLL[182]
+   WLL[183] WLL[184] WLL[185] WLL[186] WLL[187] WLL[188] WLL[189] WLL[190]
+   WLL[191] WLL[192] WLL[193] WLL[194] WLL[195] WLL[196] WLL[197] WLL[198]
+   WLL[199] WLL[200] WLL[201] WLL[202] WLL[203] WLL[204] WLL[205] WLL[206]
+   WLL[207] WLL[208] WLL[209] WLL[210] WLL[211] WLL[212] WLL[213] WLL[214]
+   WLL[215] WLL[216] WLL[217] WLL[218] WLL[219] WLL[220] WLL[221] WLL[222]
+   WLL[223] WLL[224] WLL[225] WLL[226] WLL[227] WLL[228] WLL[229] WLL[230]
+   WLL[231] WLL[232] WLL[233] WLL[234] WLL[235] WLL[236] WLL[237] WLL[238]
+   WLL[239] WLL[240] WLL[241] WLL[242] WLL[243] WLL[244] WLL[245] WLL[246]
+   WLL[247] WLL[248] WLL[249] WLL[250] WLL[251] WLL[252] WLL[253] WLL[254]
+   WLL[255] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]
+   SNPS_SP_HD_16Kx8_ary_cnt
X_ary_right_strap BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71] BB[72]
+   BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83]
+   BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94]
+   BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103] BB[104]
+   BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BB[112] BB[113]
+   BB[114] BB[115] BB[116] BB[117] BB[118] BB[119] BB[120] BB[121] BB[122]
+   BB[123] BB[124] BB[125] BB[126] BB[127] BT[64] BT[65] BT[66] BT[67] BT[68]
+   BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79]
+   BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89] BT[90]
+   BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99] BT[100]
+   BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108] BT[109]
+   BT[110] BT[111] BT[112] BT[113] BT[114] BT[115] BT[116] BT[117] BT[118]
+   BT[119] BT[120] BT[121] BT[122] BT[123] BT[124] BT[125] BT[126] BT[127]
+   EDGEB[3] EDGET[3] LOG0[4] LOG1[4] PGIOI[1] QB[16] QB[17] QB[18] QB[19]
+   QB[20] QB[21] QB[22] QB[23] QB[24] QB[25] QB[26] QB[27] QB[28] QB[29] QB[30]
+   QB[31] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] SEL[16] SEL[17] SEL[18] SEL[19]
+   SEL[20] SEL[21] SEL[22] SEL[23] SEL[24] SEL[25] SEL[26] SEL[27] SEL[28]
+   SEL[29] SEL[30] SEL[31] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23] VBA[24]
+   VBA[25] VBA[26] VBA[27] VBA[28] VBA[29] VBA[30] VBA[31] VBA[32] VBA[33]
+   VBA[34] VBA[35] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+   VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+   VBN[36] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25] VBP[26] VBP[27]
+   VBP[28] VBP[29] VBP[30] VBP[31] VBP[32] VBP[33] VBP[34] VBP[35] VBP[36]
+   VDDA[83] VDDA[84] VDDA[85] VDDA[86] VDDA[87] VDDA[88] VDDA[89] VDDA[90]
+   VDDA[91] VDDA[92] VDDA[93] VDDA[94] VDDA[95] VDDA[96] VDDA[97] VDDA[98]
+   VDDA[99] VDDA[100] VDDA[101] VDDA[102] VDDA[103] VDDA[104] VDDA[105]
+   VDDA[106] VDDA[107] VDDA[108] VDDA[109] VDDA[110] VDDA[111] VDDA[112]
+   VDDA[113] VDDA[114] VDDA[115] VDDA[116] VDDA[117] VDDA[118] VDDA[119]
+   VDDA[120] VDDA[121] VDDA[122] VDDA[123] VDDA[124] VDDA[125] VDDA[126]
+   VDDA[127] VDDA[128] VDDA[129] VDDA[130] VDDA[131] VDDA[132] VDDA[133]
+   VDDA[134] VDDA[135] VDDA[136] VDDA[137] VDDA[138] VDDA[139] VDDA[140]
+   VDDA[141] VDDA[142] VDDA[143] VDDA[144] VDDA[145] VDDA[146] VDDA[147]
+   VDDA[148] VDDA[149] VDDA[150] VDDA[151] VDDA[152] VDDA[153] VDDA[154]
+   VDDA[155] VDDA[156] VDDA[157] VDDA[158] VDDA[159] VDDA[160] VDDA[161]
+   VDDA[162] VDDAIR1 VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25]
+   VDDP[26] VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33]
+   VDDP[34] VDDP[35] VDDP[36] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24]
+   VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31]
+   VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36] VEDGE[1] VSS[20] VSS[21]
+   VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28] VSS[29] VSS[30]
+   VSS[31] VSS[32] VSS[33] VSS[34] VSS[35] VSS[36] WBI[16] WBI[17] WBI[18]
+   WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27]
+   WBI[28] WBI[29] WBI[30] WBI[31] WLH[0] WLH[1] WLH[2] WLH[3] WLH[4] WLH[5]
+   WLH[6] WLH[7] WLH[8] WLH[9] WLH[10] WLH[11] WLH[12] WLH[13] WLH[14] WLH[15]
+   WLH[16] WLH[17] WLH[18] WLH[19] WLH[20] WLH[21] WLH[22] WLH[23] WLH[24]
+   WLH[25] WLH[26] WLH[27] WLH[28] WLH[29] WLH[30] WLH[31] WLH[32] WLH[33]
+   WLH[34] WLH[35] WLH[36] WLH[37] WLH[38] WLH[39] WLH[40] WLH[41] WLH[42]
+   WLH[43] WLH[44] WLH[45] WLH[46] WLH[47] WLH[48] WLH[49] WLH[50] WLH[51]
+   WLH[52] WLH[53] WLH[54] WLH[55] WLH[56] WLH[57] WLH[58] WLH[59] WLH[60]
+   WLH[61] WLH[62] WLH[63] WLH[64] WLH[65] WLH[66] WLH[67] WLH[68] WLH[69]
+   WLH[70] WLH[71] WLH[72] WLH[73] WLH[74] WLH[75] WLH[76] WLH[77] WLH[78]
+   WLH[79] WLH[80] WLH[81] WLH[82] WLH[83] WLH[84] WLH[85] WLH[86] WLH[87]
+   WLH[88] WLH[89] WLH[90] WLH[91] WLH[92] WLH[93] WLH[94] WLH[95] WLH[96]
+   WLH[97] WLH[98] WLH[99] WLH[100] WLH[101] WLH[102] WLH[103] WLH[104]
+   WLH[105] WLH[106] WLH[107] WLH[108] WLH[109] WLH[110] WLH[111] WLH[112]
+   WLH[113] WLH[114] WLH[115] WLH[116] WLH[117] WLH[118] WLH[119] WLH[120]
+   WLH[121] WLH[122] WLH[123] WLH[124] WLH[125] WLH[126] WLH[127] WLH[128]
+   WLH[129] WLH[130] WLH[131] WLH[132] WLH[133] WLH[134] WLH[135] WLH[136]
+   WLH[137] WLH[138] WLH[139] WLH[140] WLH[141] WLH[142] WLH[143] WLH[144]
+   WLH[145] WLH[146] WLH[147] WLH[148] WLH[149] WLH[150] WLH[151] WLH[152]
+   WLH[153] WLH[154] WLH[155] WLH[156] WLH[157] WLH[158] WLH[159] WLH[160]
+   WLH[161] WLH[162] WLH[163] WLH[164] WLH[165] WLH[166] WLH[167] WLH[168]
+   WLH[169] WLH[170] WLH[171] WLH[172] WLH[173] WLH[174] WLH[175] WLH[176]
+   WLH[177] WLH[178] WLH[179] WLH[180] WLH[181] WLH[182] WLH[183] WLH[184]
+   WLH[185] WLH[186] WLH[187] WLH[188] WLH[189] WLH[190] WLH[191] WLH[192]
+   WLH[193] WLH[194] WLH[195] WLH[196] WLH[197] WLH[198] WLH[199] WLH[200]
+   WLH[201] WLH[202] WLH[203] WLH[204] WLH[205] WLH[206] WLH[207] WLH[208]
+   WLH[209] WLH[210] WLH[211] WLH[212] WLH[213] WLH[214] WLH[215] WLH[216]
+   WLH[217] WLH[218] WLH[219] WLH[220] WLH[221] WLH[222] WLH[223] WLH[224]
+   WLH[225] WLH[226] WLH[227] WLH[228] WLH[229] WLH[230] WLH[231] WLH[232]
+   WLH[233] WLH[234] WLH[235] WLH[236] WLH[237] WLH[238] WLH[239] WLH[240]
+   WLH[241] WLH[242] WLH[243] WLH[244] WLH[245] WLH[246] WLH[247] WLH[248]
+   WLH[249] WLH[250] WLH[251] WLH[252] WLH[253] WLH[254] WLH[255] WTI[16]
+   WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25]
+   WTI[26] WTI[27] WTI[28] WTI[29] WTI[30] WTI[31]
+   SNPS_SP_HD_16Kx8_ary_right_strap
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ary_row_mx_2 ARYSD[0] ARYSD[1] ARYSD_BC1[0]
+       ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1] B BB[0] BB[1] BB[2] BB[3] BB[4]
+       BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15]
+       BB[16] BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25]
+       BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35]
+       BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45]
+       BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55]
+       BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BB[64] BB[65]
+       BB[66] BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75]
+       BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83] BB[84] BB[85]
+       BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95]
+       BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103] BB[104]
+       BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BB[112] BB[113]
+       BB[114] BB[115] BB[116] BB[117] BB[118] BB[119] BB[120] BB[121] BB[122]
+       BB[123] BB[124] BB[125] BB[126] BB[127] BT[0] BT[1] BT[2] BT[3] BT[4]
+       BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15]
+       BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25]
+       BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+       BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45]
+       BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55]
+       BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65]
+       BT[66] BT[67] BT[68] BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75]
+       BT[76] BT[77] BT[78] BT[79] BT[80] BT[81] BT[82] BT[83] BT[84] BT[85]
+       BT[86] BT[87] BT[88] BT[89] BT[90] BT[91] BT[92] BT[93] BT[94] BT[95]
+       BT[96] BT[97] BT[98] BT[99] BT[100] BT[101] BT[102] BT[103] BT[104]
+       BT[105] BT[106] BT[107] BT[108] BT[109] BT[110] BT[111] BT[112] BT[113]
+       BT[114] BT[115] BT[116] BT[117] BT[118] BT[119] BT[120] BT[121] BT[122]
+       BT[123] BT[124] BT[125] BT[126] BT[127] BYP_VLOAD C CENDP DEF_MODE
+       EDGEB[0] EDGEB[1] EDGEB[2] EDGEB[3] EDGET[0] EDGET[1] EDGET[2] EDGET[3]
+       FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR0 LBKADR1 LCGTH[0]
+       LCGTH[1] LDFTX LITESLP LMATCH LMATCHB LOG0 LOG1 LWEIB LXADR[0] LXADR[1]
+       LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+       PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1]
+       PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] PWDO[0] PWDO[1] QB[0] QB[1]
+       QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12]
+       QB[13] QB[14] QB[15] QB[16] QB[17] QB[18] QB[19] QB[20] QB[21] QB[22]
+       QB[23] QB[24] QB[25] QB[26] QB[27] QB[28] QB[29] QB[30] QB[31] QT[0]
+       QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11]
+       QT[12] QT[13] QT[14] QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21]
+       QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28] QT[29] QT[30] QT[31]
+       RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RASSISTBH[0] RASSISTBH[1]
+       RASSISTBL[0] RASSISTBL[1] RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT RMT[0]
+       RMT[1] RMT[2] RMT[3] RWLB_SAC SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5]
+       SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14]
+       SEL[15] SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21] SEL[22] SEL[23]
+       SEL[24] SEL[25] SEL[26] SEL[27] SEL[28] SEL[29] SEL[30] SEL[31] T1T
+       TEST_RNMB VBA VBN VBP VDDA VDDAIL1 VDDAIR1 VDDMINB VDDP VDDPI VDDWL[0]
+       VDDWL[1] VEDGE[0] VEDGE[1] VSS VSSC_WL_L VSSC_WL_R WABUF[0] WABUF[1]
+       WABUF[2] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6]
+       WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13]
+       WB_IN[14] WB_IN[15] WB_IN[16] WB_IN[17] WB_IN[18] WB_IN[19] WB_IN[20]
+       WB_IN[21] WB_IN[22] WB_IN[23] WB_IN[24] WB_IN[25] WB_IN[26] WB_IN[27]
+       WB_IN[28] WB_IN[29] WB_IN[30] WB_IN[31] WCLKB[0] WCLKB[1] WCLKB[2]
+       WCLKB[3] WLH[0] WLH[1] WLH[2] WLH[3] WLH[4] WLH[5] WLH[6] WLH[7] WLH[8]
+       WLH[9] WLH[10] WLH[11] WLH[12] WLH[13] WLH[14] WLH[15] WLH[16] WLH[17]
+       WLH[18] WLH[19] WLH[20] WLH[21] WLH[22] WLH[23] WLH[24] WLH[25] WLH[26]
+       WLH[27] WLH[28] WLH[29] WLH[30] WLH[31] WLH[32] WLH[33] WLH[34] WLH[35]
+       WLH[36] WLH[37] WLH[38] WLH[39] WLH[40] WLH[41] WLH[42] WLH[43] WLH[44]
+       WLH[45] WLH[46] WLH[47] WLH[48] WLH[49] WLH[50] WLH[51] WLH[52] WLH[53]
+       WLH[54] WLH[55] WLH[56] WLH[57] WLH[58] WLH[59] WLH[60] WLH[61] WLH[62]
+       WLH[63] WLH[64] WLH[65] WLH[66] WLH[67] WLH[68] WLH[69] WLH[70] WLH[71]
+       WLH[72] WLH[73] WLH[74] WLH[75] WLH[76] WLH[77] WLH[78] WLH[79] WLH[80]
+       WLH[81] WLH[82] WLH[83] WLH[84] WLH[85] WLH[86] WLH[87] WLH[88] WLH[89]
+       WLH[90] WLH[91] WLH[92] WLH[93] WLH[94] WLH[95] WLH[96] WLH[97] WLH[98]
+       WLH[99] WLH[100] WLH[101] WLH[102] WLH[103] WLH[104] WLH[105] WLH[106]
+       WLH[107] WLH[108] WLH[109] WLH[110] WLH[111] WLH[112] WLH[113] WLH[114]
+       WLH[115] WLH[116] WLH[117] WLH[118] WLH[119] WLH[120] WLH[121] WLH[122]
+       WLH[123] WLH[124] WLH[125] WLH[126] WLH[127] WLH[128] WLH[129] WLH[130]
+       WLH[131] WLH[132] WLH[133] WLH[134] WLH[135] WLH[136] WLH[137] WLH[138]
+       WLH[139] WLH[140] WLH[141] WLH[142] WLH[143] WLH[144] WLH[145] WLH[146]
+       WLH[147] WLH[148] WLH[149] WLH[150] WLH[151] WLH[152] WLH[153] WLH[154]
+       WLH[155] WLH[156] WLH[157] WLH[158] WLH[159] WLH[160] WLH[161] WLH[162]
+       WLH[163] WLH[164] WLH[165] WLH[166] WLH[167] WLH[168] WLH[169] WLH[170]
+       WLH[171] WLH[172] WLH[173] WLH[174] WLH[175] WLH[176] WLH[177] WLH[178]
+       WLH[179] WLH[180] WLH[181] WLH[182] WLH[183] WLH[184] WLH[185] WLH[186]
+       WLH[187] WLH[188] WLH[189] WLH[190] WLH[191] WLH[192] WLH[193] WLH[194]
+       WLH[195] WLH[196] WLH[197] WLH[198] WLH[199] WLH[200] WLH[201] WLH[202]
+       WLH[203] WLH[204] WLH[205] WLH[206] WLH[207] WLH[208] WLH[209] WLH[210]
+       WLH[211] WLH[212] WLH[213] WLH[214] WLH[215] WLH[216] WLH[217] WLH[218]
+       WLH[219] WLH[220] WLH[221] WLH[222] WLH[223] WLH[224] WLH[225] WLH[226]
+       WLH[227] WLH[228] WLH[229] WLH[230] WLH[231] WLH[232] WLH[233] WLH[234]
+       WLH[235] WLH[236] WLH[237] WLH[238] WLH[239] WLH[240] WLH[241] WLH[242]
+       WLH[243] WLH[244] WLH[245] WLH[246] WLH[247] WLH[248] WLH[249] WLH[250]
+       WLH[251] WLH[252] WLH[253] WLH[254] WLH[255] WLL[0] WLL[1] WLL[2] WLL[3]
+       WLL[4] WLL[5] WLL[6] WLL[7] WLL[8] WLL[9] WLL[10] WLL[11] WLL[12]
+       WLL[13] WLL[14] WLL[15] WLL[16] WLL[17] WLL[18] WLL[19] WLL[20] WLL[21]
+       WLL[22] WLL[23] WLL[24] WLL[25] WLL[26] WLL[27] WLL[28] WLL[29] WLL[30]
+       WLL[31] WLL[32] WLL[33] WLL[34] WLL[35] WLL[36] WLL[37] WLL[38] WLL[39]
+       WLL[40] WLL[41] WLL[42] WLL[43] WLL[44] WLL[45] WLL[46] WLL[47] WLL[48]
+       WLL[49] WLL[50] WLL[51] WLL[52] WLL[53] WLL[54] WLL[55] WLL[56] WLL[57]
+       WLL[58] WLL[59] WLL[60] WLL[61] WLL[62] WLL[63] WLL[64] WLL[65] WLL[66]
+       WLL[67] WLL[68] WLL[69] WLL[70] WLL[71] WLL[72] WLL[73] WLL[74] WLL[75]
+       WLL[76] WLL[77] WLL[78] WLL[79] WLL[80] WLL[81] WLL[82] WLL[83] WLL[84]
+       WLL[85] WLL[86] WLL[87] WLL[88] WLL[89] WLL[90] WLL[91] WLL[92] WLL[93]
+       WLL[94] WLL[95] WLL[96] WLL[97] WLL[98] WLL[99] WLL[100] WLL[101]
+       WLL[102] WLL[103] WLL[104] WLL[105] WLL[106] WLL[107] WLL[108] WLL[109]
+       WLL[110] WLL[111] WLL[112] WLL[113] WLL[114] WLL[115] WLL[116] WLL[117]
+       WLL[118] WLL[119] WLL[120] WLL[121] WLL[122] WLL[123] WLL[124] WLL[125]
+       WLL[126] WLL[127] WLL[128] WLL[129] WLL[130] WLL[131] WLL[132] WLL[133]
+       WLL[134] WLL[135] WLL[136] WLL[137] WLL[138] WLL[139] WLL[140] WLL[141]
+       WLL[142] WLL[143] WLL[144] WLL[145] WLL[146] WLL[147] WLL[148] WLL[149]
+       WLL[150] WLL[151] WLL[152] WLL[153] WLL[154] WLL[155] WLL[156] WLL[157]
+       WLL[158] WLL[159] WLL[160] WLL[161] WLL[162] WLL[163] WLL[164] WLL[165]
+       WLL[166] WLL[167] WLL[168] WLL[169] WLL[170] WLL[171] WLL[172] WLL[173]
+       WLL[174] WLL[175] WLL[176] WLL[177] WLL[178] WLL[179] WLL[180] WLL[181]
+       WLL[182] WLL[183] WLL[184] WLL[185] WLL[186] WLL[187] WLL[188] WLL[189]
+       WLL[190] WLL[191] WLL[192] WLL[193] WLL[194] WLL[195] WLL[196] WLL[197]
+       WLL[198] WLL[199] WLL[200] WLL[201] WLL[202] WLL[203] WLL[204] WLL[205]
+       WLL[206] WLL[207] WLL[208] WLL[209] WLL[210] WLL[211] WLL[212] WLL[213]
+       WLL[214] WLL[215] WLL[216] WLL[217] WLL[218] WLL[219] WLL[220] WLL[221]
+       WLL[222] WLL[223] WLL[224] WLL[225] WLL[226] WLL[227] WLL[228] WLL[229]
+       WLL[230] WLL[231] WLL[232] WLL[233] WLL[234] WLL[235] WLL[236] WLL[237]
+       WLL[238] WLL[239] WLL[240] WLL[241] WLL[242] WLL[243] WLL[244] WLL[245]
+       WLL[246] WLL[247] WLL[248] WLL[249] WLL[250] WLL[251] WLL[252] WLL[253]
+       WLL[254] WLL[255] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]
+       WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7]
+       WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14]
+       WT_IN[15] WT_IN[16] WT_IN[17] WT_IN[18] WT_IN[19] WT_IN[20] WT_IN[21]
+       WT_IN[22] WT_IN[23] WT_IN[24] WT_IN[25] WT_IN[26] WT_IN[27] WT_IN[28]
+       WT_IN[29] WT_IN[30] WT_IN[31]
X_ary_r_mx_2 ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+   ARYSD_BC2[1] B BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9]
+   BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20]
+   BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31]
+   BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42]
+   BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53]
+   BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BB[64]
+   BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75]
+   BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83] BB[84] BB[85] BB[86]
+   BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95] BB[96] BB[97]
+   BB[98] BB[99] BB[100] BB[101] BB[102] BB[103] BB[104] BB[105] BB[106]
+   BB[107] BB[108] BB[109] BB[110] BB[111] BB[112] BB[113] BB[114] BB[115]
+   BB[116] BB[117] BB[118] BB[119] BB[120] BB[121] BB[122] BB[123] BB[124]
+   BB[125] BB[126] BB[127] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7]
+   BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16] BT[17] BT[18]
+   BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28] BT[29]
+   BT[30] BT[31] BT[32] BT[33] BT[34] BT[35] BT[36] BT[37] BT[38] BT[39] BT[40]
+   BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51]
+   BT[52] BT[53] BT[54] BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62]
+   BT[63] BT[64] BT[65] BT[66] BT[67] BT[68] BT[69] BT[70] BT[71] BT[72] BT[73]
+   BT[74] BT[75] BT[76] BT[77] BT[78] BT[79] BT[80] BT[81] BT[82] BT[83] BT[84]
+   BT[85] BT[86] BT[87] BT[88] BT[89] BT[90] BT[91] BT[92] BT[93] BT[94] BT[95]
+   BT[96] BT[97] BT[98] BT[99] BT[100] BT[101] BT[102] BT[103] BT[104] BT[105]
+   BT[106] BT[107] BT[108] BT[109] BT[110] BT[111] BT[112] BT[113] BT[114]
+   BT[115] BT[116] BT[117] BT[118] BT[119] BT[120] BT[121] BT[122] BT[123]
+   BT[124] BT[125] BT[126] BT[127] BYP_VLOAD C CENDP DEF_MODE EDGEB[0] EDGEB[1]
+   EDGEB[2] EDGEB[3] EDGET[0] EDGET[1] EDGET[2] EDGET[3] FAST1_MODE FAST2_MODE
+   FLOAT FLOATT FLOAT_RET LBKADR0 LBKADR1 LCGTH[0] LCGTH[1] LDFTX LITESLP
+   LMATCH LMATCHB LOG0 LOG0 LOG0 LOG0 LOG0 LOG1 LOG1 LOG1 LOG1 LOG1 LWEIB
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7]
+   PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] PWDO[0] PWDO[1]
+   QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+   QB[12] QB[13] QB[14] QB[15] QB[16] QB[17] QB[18] QB[19] QB[20] QB[21] QB[22]
+   QB[23] QB[24] QB[25] QB[26] QB[27] QB[28] QB[29] QB[30] QB[31] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13]
+   QT[14] QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24]
+   QT[25] QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] RASSIST[0] RASSIST[1]
+   RASSIST[2] RASSIST[3] RASSISTBH[0] RASSISTBH[1] RASSISTBL[0] RASSISTBL[1]
+   RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC
+   SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9]
+   SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] SEL[16] SEL[17] SEL[18]
+   SEL[19] SEL[20] SEL[21] SEL[22] SEL[23] SEL[24] SEL[25] SEL[26] SEL[27]
+   SEL[28] SEL[29] SEL[30] SEL[31] T1T TEST_RNMB VBA VBA VBA VBA VBA VBA VBA
+   VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA
+   VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDAIL1 VDDAIR1 VDDMINB VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDWL[0] VDDWL[1] VEDGE[0] VEDGE[1] VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSSC_WL_L VSSC_WL_R WABUF[0]
+   WABUF[1] WABUF[2] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5]
+   WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13]
+   WB_IN[14] WB_IN[15] WB_IN[16] WB_IN[17] WB_IN[18] WB_IN[19] WB_IN[20]
+   WB_IN[21] WB_IN[22] WB_IN[23] WB_IN[24] WB_IN[25] WB_IN[26] WB_IN[27]
+   WB_IN[28] WB_IN[29] WB_IN[30] WB_IN[31] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   WLH[0] WLH[1] WLH[2] WLH[3] WLH[4] WLH[5] WLH[6] WLH[7] WLH[8] WLH[9]
+   WLH[10] WLH[11] WLH[12] WLH[13] WLH[14] WLH[15] WLH[16] WLH[17] WLH[18]
+   WLH[19] WLH[20] WLH[21] WLH[22] WLH[23] WLH[24] WLH[25] WLH[26] WLH[27]
+   WLH[28] WLH[29] WLH[30] WLH[31] WLH[32] WLH[33] WLH[34] WLH[35] WLH[36]
+   WLH[37] WLH[38] WLH[39] WLH[40] WLH[41] WLH[42] WLH[43] WLH[44] WLH[45]
+   WLH[46] WLH[47] WLH[48] WLH[49] WLH[50] WLH[51] WLH[52] WLH[53] WLH[54]
+   WLH[55] WLH[56] WLH[57] WLH[58] WLH[59] WLH[60] WLH[61] WLH[62] WLH[63]
+   WLH[64] WLH[65] WLH[66] WLH[67] WLH[68] WLH[69] WLH[70] WLH[71] WLH[72]
+   WLH[73] WLH[74] WLH[75] WLH[76] WLH[77] WLH[78] WLH[79] WLH[80] WLH[81]
+   WLH[82] WLH[83] WLH[84] WLH[85] WLH[86] WLH[87] WLH[88] WLH[89] WLH[90]
+   WLH[91] WLH[92] WLH[93] WLH[94] WLH[95] WLH[96] WLH[97] WLH[98] WLH[99]
+   WLH[100] WLH[101] WLH[102] WLH[103] WLH[104] WLH[105] WLH[106] WLH[107]
+   WLH[108] WLH[109] WLH[110] WLH[111] WLH[112] WLH[113] WLH[114] WLH[115]
+   WLH[116] WLH[117] WLH[118] WLH[119] WLH[120] WLH[121] WLH[122] WLH[123]
+   WLH[124] WLH[125] WLH[126] WLH[127] WLH[128] WLH[129] WLH[130] WLH[131]
+   WLH[132] WLH[133] WLH[134] WLH[135] WLH[136] WLH[137] WLH[138] WLH[139]
+   WLH[140] WLH[141] WLH[142] WLH[143] WLH[144] WLH[145] WLH[146] WLH[147]
+   WLH[148] WLH[149] WLH[150] WLH[151] WLH[152] WLH[153] WLH[154] WLH[155]
+   WLH[156] WLH[157] WLH[158] WLH[159] WLH[160] WLH[161] WLH[162] WLH[163]
+   WLH[164] WLH[165] WLH[166] WLH[167] WLH[168] WLH[169] WLH[170] WLH[171]
+   WLH[172] WLH[173] WLH[174] WLH[175] WLH[176] WLH[177] WLH[178] WLH[179]
+   WLH[180] WLH[181] WLH[182] WLH[183] WLH[184] WLH[185] WLH[186] WLH[187]
+   WLH[188] WLH[189] WLH[190] WLH[191] WLH[192] WLH[193] WLH[194] WLH[195]
+   WLH[196] WLH[197] WLH[198] WLH[199] WLH[200] WLH[201] WLH[202] WLH[203]
+   WLH[204] WLH[205] WLH[206] WLH[207] WLH[208] WLH[209] WLH[210] WLH[211]
+   WLH[212] WLH[213] WLH[214] WLH[215] WLH[216] WLH[217] WLH[218] WLH[219]
+   WLH[220] WLH[221] WLH[222] WLH[223] WLH[224] WLH[225] WLH[226] WLH[227]
+   WLH[228] WLH[229] WLH[230] WLH[231] WLH[232] WLH[233] WLH[234] WLH[235]
+   WLH[236] WLH[237] WLH[238] WLH[239] WLH[240] WLH[241] WLH[242] WLH[243]
+   WLH[244] WLH[245] WLH[246] WLH[247] WLH[248] WLH[249] WLH[250] WLH[251]
+   WLH[252] WLH[253] WLH[254] WLH[255] WLL[0] WLL[1] WLL[2] WLL[3] WLL[4]
+   WLL[5] WLL[6] WLL[7] WLL[8] WLL[9] WLL[10] WLL[11] WLL[12] WLL[13] WLL[14]
+   WLL[15] WLL[16] WLL[17] WLL[18] WLL[19] WLL[20] WLL[21] WLL[22] WLL[23]
+   WLL[24] WLL[25] WLL[26] WLL[27] WLL[28] WLL[29] WLL[30] WLL[31] WLL[32]
+   WLL[33] WLL[34] WLL[35] WLL[36] WLL[37] WLL[38] WLL[39] WLL[40] WLL[41]
+   WLL[42] WLL[43] WLL[44] WLL[45] WLL[46] WLL[47] WLL[48] WLL[49] WLL[50]
+   WLL[51] WLL[52] WLL[53] WLL[54] WLL[55] WLL[56] WLL[57] WLL[58] WLL[59]
+   WLL[60] WLL[61] WLL[62] WLL[63] WLL[64] WLL[65] WLL[66] WLL[67] WLL[68]
+   WLL[69] WLL[70] WLL[71] WLL[72] WLL[73] WLL[74] WLL[75] WLL[76] WLL[77]
+   WLL[78] WLL[79] WLL[80] WLL[81] WLL[82] WLL[83] WLL[84] WLL[85] WLL[86]
+   WLL[87] WLL[88] WLL[89] WLL[90] WLL[91] WLL[92] WLL[93] WLL[94] WLL[95]
+   WLL[96] WLL[97] WLL[98] WLL[99] WLL[100] WLL[101] WLL[102] WLL[103] WLL[104]
+   WLL[105] WLL[106] WLL[107] WLL[108] WLL[109] WLL[110] WLL[111] WLL[112]
+   WLL[113] WLL[114] WLL[115] WLL[116] WLL[117] WLL[118] WLL[119] WLL[120]
+   WLL[121] WLL[122] WLL[123] WLL[124] WLL[125] WLL[126] WLL[127] WLL[128]
+   WLL[129] WLL[130] WLL[131] WLL[132] WLL[133] WLL[134] WLL[135] WLL[136]
+   WLL[137] WLL[138] WLL[139] WLL[140] WLL[141] WLL[142] WLL[143] WLL[144]
+   WLL[145] WLL[146] WLL[147] WLL[148] WLL[149] WLL[150] WLL[151] WLL[152]
+   WLL[153] WLL[154] WLL[155] WLL[156] WLL[157] WLL[158] WLL[159] WLL[160]
+   WLL[161] WLL[162] WLL[163] WLL[164] WLL[165] WLL[166] WLL[167] WLL[168]
+   WLL[169] WLL[170] WLL[171] WLL[172] WLL[173] WLL[174] WLL[175] WLL[176]
+   WLL[177] WLL[178] WLL[179] WLL[180] WLL[181] WLL[182] WLL[183] WLL[184]
+   WLL[185] WLL[186] WLL[187] WLL[188] WLL[189] WLL[190] WLL[191] WLL[192]
+   WLL[193] WLL[194] WLL[195] WLL[196] WLL[197] WLL[198] WLL[199] WLL[200]
+   WLL[201] WLL[202] WLL[203] WLL[204] WLL[205] WLL[206] WLL[207] WLL[208]
+   WLL[209] WLL[210] WLL[211] WLL[212] WLL[213] WLL[214] WLL[215] WLL[216]
+   WLL[217] WLL[218] WLL[219] WLL[220] WLL[221] WLL[222] WLL[223] WLL[224]
+   WLL[225] WLL[226] WLL[227] WLL[228] WLL[229] WLL[230] WLL[231] WLL[232]
+   WLL[233] WLL[234] WLL[235] WLL[236] WLL[237] WLL[238] WLL[239] WLL[240]
+   WLL[241] WLL[242] WLL[243] WLL[244] WLL[245] WLL[246] WLL[247] WLL[248]
+   WLL[249] WLL[250] WLL[251] WLL[252] WLL[253] WLL[254] WLL[255] WMT[0] WMT[1]
+   WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3]
+   WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11]
+   WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15] WT_IN[16] WT_IN[17] WT_IN[18]
+   WT_IN[19] WT_IN[20] WT_IN[21] WT_IN[22] WT_IN[23] WT_IN[24] WT_IN[25]
+   WT_IN[26] WT_IN[27] WT_IN[28] WT_IN[29] WT_IN[30] WT_IN[31]
+   SNPS_SP_HD_16Kx8_ary_r_mx_2
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_cmux_tile BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1]
+       BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+       BT[13] BT[14] BT[15] CKPRCH LOG0 LOG1 PO[0] PO[1] POWINT[0] POWINT[1]
+       PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+       PRCHWRB[2] PRCHWRB[3] QB[0] QB[1] QB[2] QB[3] QT[0] QT[1] QT[2] QT[3]
+       RB[0] RB[1] RB[2] RB[3] RT[0] RT[1] RT[2] RT[3] SEL[0] SEL[1] SEL[2]
+       SEL[3] VBA[0] VBA[1] VBA[2] VBA[3] VBN[0] VBN[1] VBN[2] VBN[3] VBP[0]
+       VBP[1] VBP[2] VBP[3] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDAI[0] VDDAI[1]
+       VDDAI[2] VDDAI[3] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDPI[0] VDDPI[1]
+       VDDPI[2] VDDPI[3] VSS[0] VSS[1] VSS[2] VSS[3] WB[0] WB[1] WB[2] WB[3]
+       WBI[0] WBI[1] WBI[2] WBI[3] WT[0] WT[1] WT[2] WT[3] WTI[0] WTI[1] WTI[2]
+       WTI[3]

*** Jumper Report ***
* Jumper: VBA[0] VSS[0]
* Jumper: VBA[1] VSS[1]
* Jumper: VBA[2] VSS[2]
* Jumper: VBA[3] VSS[3]
* Jumper: VDDA[0] VDDP[0] VDDPI[0]
* Jumper: VDDA[1] VDDP[1] VDDPI[1]
* Jumper: VDDA[2] VDDP[2] VDDPI[2]
* Jumper: VDDA[3] VDDP[3] VDDPI[3]

X_mm16a05_u_hdsp_plus_hc_cmux4x1_S0 VDDA[0] VDDAI[0] VDDP[0] VDDPI[0] VSS[0]
+   VBP[0] VBN[0] BB[0] BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3] LOG0 LOG1
+   PO[0] PO[1] POWINT[0] POWINT[1] QB[0] QT[0] RB[0] RT[0] VBA[0] WB[0] WBI[0]
+   WT[0] WTI[0] CKPRCH PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0]
+   PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] SEL[0] mm16a05_u_hdsp_plus_hc_cmux4x1
X_mm16a05_u_hdsp_plus_hc_cmux4x1_S1 VDDA[1] VDDAI[1] VDDP[1] VDDPI[1] VSS[1]
+   VBP[1] VBN[1] BB[4] BB[5] BB[6] BB[7] BT[4] BT[5] BT[6] BT[7] LOG0 LOG1
+   PO[0] PO[1] POWINT[0] POWINT[1] QB[1] QT[1] RB[1] RT[1] VBA[1] WB[1] WBI[1]
+   WT[1] WTI[1] CKPRCH PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0]
+   PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] SEL[1] mm16a05_u_hdsp_plus_hc_cmux4x1
X_mm16a05_u_hdsp_plus_hc_cmux4x1_F1 VDDA[2] VDDAI[2] VDDP[2] VDDPI[2] VSS[2]
+   VBP[2] VBN[2] BB[8] BB[9] BB[10] BB[11] BT[8] BT[9] BT[10] BT[11] LOG0 LOG1
+   PO[0] PO[1] POWINT[0] POWINT[1] QB[2] QT[2] RB[2] RT[2] VBA[2] WB[2] WBI[2]
+   WT[2] WTI[2] CKPRCH PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0]
+   PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] SEL[2] mm16a05_u_hdsp_plus_hc_cmux4x1
X_mm16a05_u_hdsp_plus_hc_cmux4x1_F0 VDDA[3] VDDAI[3] VDDP[3] VDDPI[3] VSS[3]
+   VBP[3] VBN[3] BB[12] BB[13] BB[14] BB[15] BT[12] BT[13] BT[14] BT[15] LOG0
+   LOG1 PO[0] PO[1] POWINT[0] POWINT[1] QB[3] QT[3] RB[3] RT[3] VBA[3] WB[3]
+   WBI[3] WT[3] WTI[3] CKPRCH PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3]
+   PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] SEL[3]
+   mm16a05_u_hdsp_plus_hc_cmux4x1
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_mux_lt_seg1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+       BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+       BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+       BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1] BT[2] BT[3]
+       BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14]
+       BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+       BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34]
+       BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44]
+       BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54]
+       BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] CKPRCH
+       LOG0 LOG1 PO[0] PO[1] POWINT[0] POWINT[1] PRCHRDB[0] PRCHRDB[1]
+       PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] QB[0]
+       QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+       QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+       QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] RB[0] RB[1]
+       RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12]
+       RB[13] RB[14] RB[15] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7]
+       RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15] SEL[0] SEL[1]
+       SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+       SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4]
+       VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13]
+       VBA[14] VBA[15] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7]
+       VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBP[0]
+       VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10]
+       VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+       VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11]
+       VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDAI[0] VDDAI[1] VDDAI[2] VDDAI[3]
+       VDDAI[4] VDDAI[5] VDDAI[6] VDDAI[7] VDDAI[8] VDDAI[9] VDDAI[10]
+       VDDAI[11] VDDAI[12] VDDAI[13] VDDAI[14] VDDAI[15] VDDP[0] VDDP[1]
+       VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+       VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDPI[0] VDDPI[1] VDDPI[2]
+       VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+       VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VSS[0] VSS[1] VSS[2]
+       VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+       VSS[13] VSS[14] VSS[15] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7]
+       WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WBI[0] WBI[1]
+       WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11]
+       WBI[12] WBI[13] WBI[14] WBI[15] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5]
+       WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WTI[0]
+       WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10]
+       WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
X_cmux_tile_S0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9]
+   BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4]
+   BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15]
+   CKPRCH LOG0 LOG1 PO[0] PO[1] POWINT[0] POWINT[1] PRCHRDB[0] PRCHRDB[1]
+   PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] QB[0]
+   QB[1] QB[2] QB[3] QT[0] QT[1] QT[2] QT[3] RB[0] RB[1] RB[2] RB[3] RT[0]
+   RT[1] RT[2] RT[3] SEL[0] SEL[1] SEL[2] SEL[3] VBA[0] VBA[1] VBA[2] VBA[3]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBP[0] VBP[1] VBP[2] VBP[3] VDDA[0] VDDA[1]
+   VDDA[2] VDDA[3] VDDAI[0] VDDAI[1] VDDAI[2] VDDAI[3] VDDP[0] VDDP[1] VDDP[2]
+   VDDP[3] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VSS[0] VSS[1] VSS[2] VSS[3]
+   WB[0] WB[1] WB[2] WB[3] WBI[0] WBI[1] WBI[2] WBI[3] WT[0] WT[1] WT[2] WT[3]
+   WTI[0] WTI[1] WTI[2] WTI[3] SNPS_SP_HD_16Kx8_cmux_tile
X_cmux_tile_S1 BB[16] BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24]
+   BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[16] BT[17] BT[18] BT[19]
+   BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30]
+   BT[31] CKPRCH LOG0 LOG1 PO[0] PO[1] POWINT[0] POWINT[1] PRCHRDB[0]
+   PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3]
+   QB[4] QB[5] QB[6] QB[7] QT[4] QT[5] QT[6] QT[7] RB[4] RB[5] RB[6] RB[7]
+   RT[4] RT[5] RT[6] RT[7] SEL[4] SEL[5] SEL[6] SEL[7] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBN[4] VBN[5] VBN[6] VBN[7] VBP[4] VBP[5] VBP[6] VBP[7] VDDA[4]
+   VDDA[5] VDDA[6] VDDA[7] VDDAI[4] VDDAI[5] VDDAI[6] VDDAI[7] VDDP[4] VDDP[5]
+   VDDP[6] VDDP[7] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VSS[4] VSS[5] VSS[6]
+   VSS[7] WB[4] WB[5] WB[6] WB[7] WBI[4] WBI[5] WBI[6] WBI[7] WT[4] WT[5] WT[6]
+   WT[7] WTI[4] WTI[5] WTI[6] WTI[7] SNPS_SP_HD_16Kx8_cmux_tile
X_cmux_tile_F1 BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40]
+   BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] CKPRCH LOG0 LOG1 PO[0] PO[1] POWINT[0] POWINT[1] PRCHRDB[0]
+   PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3]
+   QB[8] QB[9] QB[10] QB[11] QT[8] QT[9] QT[10] QT[11] RB[8] RB[9] RB[10]
+   RB[11] RT[8] RT[9] RT[10] RT[11] SEL[8] SEL[9] SEL[10] SEL[11] VBA[8] VBA[9]
+   VBA[10] VBA[11] VBN[8] VBN[9] VBN[10] VBN[11] VBP[8] VBP[9] VBP[10] VBP[11]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDAI[8] VDDAI[9] VDDAI[10] VDDAI[11]
+   VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VSS[8] VSS[9] VSS[10] VSS[11] WB[8] WB[9] WB[10] WB[11] WBI[8] WBI[9]
+   WBI[10] WBI[11] WT[8] WT[9] WT[10] WT[11] WTI[8] WTI[9] WTI[10] WTI[11]
+   SNPS_SP_HD_16Kx8_cmux_tile
X_cmux_tile_F0 BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+   BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[48] BT[49] BT[50] BT[51]
+   BT[52] BT[53] BT[54] BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62]
+   BT[63] CKPRCH LOG0 LOG1 PO[0] PO[1] POWINT[0] POWINT[1] PRCHRDB[0]
+   PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3]
+   QB[12] QB[13] QB[14] QB[15] QT[12] QT[13] QT[14] QT[15] RB[12] RB[13] RB[14]
+   RB[15] RT[12] RT[13] RT[14] RT[15] SEL[12] SEL[13] SEL[14] SEL[15] VBA[12]
+   VBA[13] VBA[14] VBA[15] VBN[12] VBN[13] VBN[14] VBN[15] VBP[12] VBP[13]
+   VBP[14] VBP[15] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDAI[12] VDDAI[13]
+   VDDAI[14] VDDAI[15] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDPI[12] VDDPI[13]
+   VDDPI[14] VDDPI[15] VSS[12] VSS[13] VSS[14] VSS[15] WB[12] WB[13] WB[14]
+   WB[15] WBI[12] WBI[13] WBI[14] WBI[15] WT[12] WT[13] WT[14] WT[15] WTI[12]
+   WTI[13] WTI[14] WTI[15] SNPS_SP_HD_16Kx8_cmux_tile
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_mux_lt BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7]
+       BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17]
+       BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27]
+       BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37]
+       BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47]
+       BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57]
+       BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BOTEDGE BT[0] BT[1] BT[2]
+       BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+       BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+       BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33]
+       BT[34] BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43]
+       BT[44] BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53]
+       BT[54] BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63]
+       CKPRCH LOG0 LOG1 PGIOI PO POWINT[0] POWINT[1] PRCHRDB[0] PRCHRDB[1]
+       PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] QB[0]
+       QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+       QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+       QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] RB[0] RB[1]
+       RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12]
+       RB[13] RB[14] RB[15] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7]
+       RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15] SEL[0] SEL[1]
+       SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+       SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4]
+       VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13]
+       VBA[14] VBA[15] VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+       VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15]
+       VBN[16] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8]
+       VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0]
+       VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9]
+       VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIL1
+       VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8]
+       VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16]
+       VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+       VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+       VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+       VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14]
+       VSS[15] VSS[16] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8]
+       WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WBI[0] WBI[1] WBI[2]
+       WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12]
+       WBI[13] WBI[14] WBI[15] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7]
+       WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WTI[0] WTI[1]
+       WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11]
+       WTI[12] WTI[13] WTI[14] WTI[15]

*** Jumper Report ***
* Jumper: VDDA[0] VDDP[0] VDDPI[0]

X_mm16a05_u_hdsp_plus_capmux VDDA[0] VDDP[0] VDDPI[0] VSS[0] VBP[0] VBN[0]
+   BOTEDGE LOG0 LOG1 PGIOI PO VBA[0] VEDGE mm16a05_u_hdsp_plus_capmux
X_mux_lt_seg1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] CKPRCH LOG0 LOG1 PO PO POWINT[0]
+   POWINT[1] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+   PRCHWRB[2] PRCHWRB[3] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8]
+   QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3]
+   QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10]
+   RB[11] RB[12] RB[13] RB[14] RB[15] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6]
+   RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10]
+   VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[1] VBP[2] VBP[3] VBP[4]
+   VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14]
+   VBP[15] VBP[16] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+   VDDA[16] VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1
+   VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[1] VDDPI[2]
+   VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+   VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6]
+   WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WBI[0] WBI[1]
+   WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11]
+   WBI[12] WBI[13] WBI[14] WBI[15] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6]
+   WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WTI[0] WTI[1]
+   WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11]
+   WTI[12] WTI[13] WTI[14] WTI[15] SNPS_SP_HD_16Kx8_mux_lt_seg1
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_mux_cnt ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1]
+       ARYSD_BC2[0] ARYSD_BC2[1] BOTEDGE[0] BOTEDGE[1] BYP_VLOAD CENDP CKPRCHH
+       CKPRCHL DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR0
+       LBKADR1 LCGTH[0] LCGTH[1] LCGTH_PCHG LDFTX LITESLP LMATCH LMATCHB LOG0
+       LOG1 LWEIB LWERD LWEWR LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+       LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3]
+       PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5]
+       PCB[6] PCB[7] PM[0] PM[1] PM[2] PM[3] PO[0] PO[1] PRCHRDBH[0]
+       PRCHRDBH[1] PRCHRDBH[2] PRCHRDBH[3] PRCHRDBL[0] PRCHRDBL[1] PRCHRDBL[2]
+       PRCHRDBL[3] PRCHWRBH[0] PRCHWRBH[1] PRCHWRBH[2] PRCHWRBH[3] PRCHWRBL[0]
+       PRCHWRBL[1] PRCHWRBL[2] PRCHWRBL[3] PRCKE_B RASSIST[0] RASSIST[1]
+       RASSIST[2] RASSIST[3] RASSISTBH[0] RASSISTBH[1] RASSISTBL[0]
+       RASSISTBL[1] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3]
+       RWLB_SAC T1T TEST_RNMB VBA[0] VBA[1] VBN[0] VBN[1] VBN[2] VBP[0] VBP[1]
+       VBP[2] VDDA[0] VDDA[1] VDDA[2] VDDMINB VDDP[0] VDDP[1] VDDP[2] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDWL[0] VDDWL[1] VSS[0] VSS[1] VSS[2] VSSC_WL_L
+       VSSC_WL_R WABUF[0] WABUF[1] WABUF[2] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+       WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]

*** Jumper Report ***
* Jumper: CLK_WLBH CLK_WLBL
* Jumper: LOG1 LMATCHB
* Jumper: PRCHWR[0] PRCHWRH[0]
* Jumper: PRCHWR[1] PRCHWRH[1]
* Jumper: PRCHWR[2] PRCHWRH[2]
* Jumper: PRCHWR[3] PRCHWRH[3]
* Jumper: VDDA[0] VDDP[0] VDDPI[0]
* Jumper: VDDA[1] VDDP[1] VDDPI[1]
* Jumper: VDDA[2] VDDP[2] VDDPI[2]
* Jumper: XPRBH[0] XPRBL[0]
* Jumper: XPRBH[1] XPRBL[1]
* Jumper: XPRBH[2] XPRBL[2]
* Jumper: XPRBH[3] XPRBL[3]

X_mm16a05_u_hdsp_plus_lcenbuf_left VDDA[0] VDDP[0] VDDPI[0] VDDWL[0] VSS[0]
+   VBP[0] VBN[0] CKPRCHL LCGTHB[0] PRCHRDBL[0] PRCHRDBL[1] PRCHRDBL[2]
+   PRCHRDBL[3] PRCHWRBL[0] PRCHWRBL[1] PRCHWRBL[2] PRCHWRBL[3] RASSISTBL[0]
+   RASSISTBL[1] ARYSD[0] ARYSD_BC1[0] ARYSD_BC2[0] BOTEDGE[0] PO[0] VBA[0]
+   CKPRCHB LCGTH[0] LOG0 LOG1 PRCHRD[0] PRCHRD[1] PRCHRD[2] PRCHRD[3] PRCHWR[0]
+   PRCHWR[1] PRCHWR[2] PRCHWR[3] RASSIST[0] RASSIST[1]
+   mm16a05_u_hdsp_plus_lcenbuf
X_mm16a05_u_hdsp_plus_lcen VDDA[1] VDDMINB VDDP[1] VDDPI[1] VSS[1] VSSC_WL_L
+   VSSC_WL_R VBP[1] VBN[1] CKPRCHB LMATCH PBB[0] PBB[1] PBB[2] PBB[3] PBB[4]
+   PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7]
+   PRCHRD[0] PRCHRD[1] PRCHRD[2] PRCHRD[3] PRCHWR[0] PRCHWR[1] PRCHWR[2]
+   PRCHWR[3] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] BYP_VLOAD CENDP CLK_WLBH
+   CLK_WLBH DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LDFTX LITESLP
+   LOG0 LOG1 LWEIB LWERD LWEWR PRCHWR[0] PRCHWR[1] PRCHWR[2] PRCHWR[3] RBLRD
+   RBLWA RBLWR RWLB_SAC WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3]
+   WPBUF[0] WPBUF[1] WPBUF[2] XPRBH[0] XPRBH[1] XPRBH[2] XPRBH[3] XPRBH[0]
+   XPRBH[1] XPRBH[2] XPRBH[3] LBKADR0 LBKADR1 LBKADR LCGTHB[1] LCGTH_PCHG
+   LMATCHB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6]
+   LXADR[7] LYADR[0] LYADR[1] PM[0] PM[1] PM[2] PM[3] PRCKE_B RM3CNT RMT[0]
+   RMT[1] RMT[2] RMT[3] T1T TEST_RNMB mm16a05_u_hdsp_plus_lcen
X_mm16a05_u_hdsp_plus_lcenbuf VDDA[2] VDDP[2] VDDPI[2] VDDWL[1] VSS[2] VBP[2]
+   VBN[2] CKPRCHH LCGTHB[1] PRCHRDBH[0] PRCHRDBH[1] PRCHRDBH[2] PRCHRDBH[3]
+   PRCHWRBH[0] PRCHWRBH[1] PRCHWRBH[2] PRCHWRBH[3] RASSISTBH[0] RASSISTBH[1]
+   ARYSD[1] ARYSD_BC1[1] ARYSD_BC2[1] BOTEDGE[1] PO[1] VBA[1] CKPRCHB LCGTH[1]
+   LOG0 LOG1 PRCHRD[0] PRCHRD[1] PRCHRD[2] PRCHRD[3] PRCHWR[0] PRCHWR[1]
+   PRCHWR[2] PRCHWR[3] RASSIST[2] RASSIST[3] mm16a05_u_hdsp_plus_lcenbuf
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_mux_rt BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7]
+       BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17]
+       BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27]
+       BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37]
+       BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47]
+       BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56] BB[57]
+       BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BOTEDGE BT[0] BT[1] BT[2]
+       BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+       BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+       BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33]
+       BT[34] BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43]
+       BT[44] BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53]
+       BT[54] BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63]
+       CKPRCH LOG0 LOG1 PGIOI PO POWINT[0] POWINT[1] PRCHRDB[0] PRCHRDB[1]
+       PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] QB[0]
+       QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+       QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+       QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] RB[0] RB[1]
+       RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12]
+       RB[13] RB[14] RB[15] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7]
+       RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15] SEL[0] SEL[1]
+       SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+       SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4]
+       VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13]
+       VBA[14] VBA[15] VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+       VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15]
+       VBN[16] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8]
+       VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0]
+       VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9]
+       VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDAIR1
+       VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8]
+       VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16]
+       VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+       VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+       VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+       VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14]
+       VSS[15] VSS[16] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8]
+       WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WBI[0] WBI[1] WBI[2]
+       WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12]
+       WBI[13] WBI[14] WBI[15] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7]
+       WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WTI[0] WTI[1]
+       WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11]
+       WTI[12] WTI[13] WTI[14] WTI[15]

*** Jumper Report ***
* Jumper: VDDA[16] VDDP[16] VDDPI[16]

X_mux_lt_seg1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] CKPRCH LOG0 LOG1 PO PO POWINT[0]
+   POWINT[1] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+   PRCHWRB[2] PRCHWRB[3] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8]
+   QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3]
+   QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10]
+   RB[11] RB[12] RB[13] RB[14] RB[15] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6]
+   RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6]
+   VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+   VDDA[15] VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1
+   VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9]
+   VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDPI[0] VDDPI[1]
+   VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9]
+   VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VSS[0] VSS[1]
+   VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11]
+   VSS[12] VSS[13] VSS[14] VSS[15] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6]
+   WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WBI[0] WBI[1]
+   WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11]
+   WBI[12] WBI[13] WBI[14] WBI[15] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6]
+   WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WTI[0] WTI[1]
+   WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11]
+   WTI[12] WTI[13] WTI[14] WTI[15] SNPS_SP_HD_16Kx8_mux_lt_seg1
X_mm16a05_u_hdsp_plus_capmux VDDA[16] VDDP[16] VDDPI[16] VSS[16] VBP[16] VBN[16]
+   BOTEDGE LOG0 LOG1 PGIOI PO VBA[16] VEDGE mm16a05_u_hdsp_plus_capmux
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_mux_row_b ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1]
+       ARYSD_BC2[0] ARYSD_BC2[1] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+       BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+       BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+       BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BB[64] BB[65] BB[66]
+       BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75] BB[76]
+       BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83] BB[84] BB[85] BB[86]
+       BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95] BB[96]
+       BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103] BB[104] BB[105]
+       BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BB[112] BB[113] BB[114]
+       BB[115] BB[116] BB[117] BB[118] BB[119] BB[120] BB[121] BB[122] BB[123]
+       BB[124] BB[125] BB[126] BB[127] BOTEDGE[0] BOTEDGE[1] BOTEDGE[2]
+       BOTEDGE[3] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9]
+       BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19]
+       BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28] BT[29]
+       BT[30] BT[31] BT[32] BT[33] BT[34] BT[35] BT[36] BT[37] BT[38] BT[39]
+       BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47] BT[48] BT[49]
+       BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57] BT[58] BT[59]
+       BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68] BT[69]
+       BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79]
+       BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89]
+       BT[90] BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99]
+       BT[100] BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108]
+       BT[109] BT[110] BT[111] BT[112] BT[113] BT[114] BT[115] BT[116] BT[117]
+       BT[118] BT[119] BT[120] BT[121] BT[122] BT[123] BT[124] BT[125] BT[126]
+       BT[127] BYP_VLOAD CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT
+       FLOAT_RET LBKADR0 LBKADR1 LCGTH[0] LCGTH[1] LCGTH_PCHG LDFTX LITESLP
+       LMATCH LMATCHB LOG0 LOG1 LWEIB LWERD LWEWR LXADR[0] LXADR[1] LXADR[2]
+       LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0]
+       PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+       PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] PGIOI[0] PGIOI[1] PM[0] PM[1] PM[2]
+       PM[3] PRCKE_B QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8]
+       QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QB[16] QB[17] QB[18]
+       QB[19] QB[20] QB[21] QB[22] QB[23] QB[24] QB[25] QB[26] QB[27] QB[28]
+       QB[29] QB[30] QB[31] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+       QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17]
+       QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27]
+       QT[28] QT[29] QT[30] QT[31] RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3]
+       RASSISTBH[0] RASSISTBH[1] RASSISTBL[0] RASSISTBL[1] RB[0] RB[1] RB[2]
+       RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13]
+       RB[14] RB[15] RB[16] RB[17] RB[18] RB[19] RB[20] RB[21] RB[22] RB[23]
+       RB[24] RB[25] RB[26] RB[27] RB[28] RB[29] RB[30] RB[31] RBLRD RBLWA
+       RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RT[0] RT[1] RT[2] RT[3] RT[4]
+       RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15]
+       RT[16] RT[17] RT[18] RT[19] RT[20] RT[21] RT[22] RT[23] RT[24] RT[25]
+       RT[26] RT[27] RT[28] RT[29] RT[30] RT[31] RWLB_SAC SEL[0] SEL[1] SEL[2]
+       SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+       SEL[13] SEL[14] SEL[15] SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21]
+       SEL[22] SEL[23] SEL[24] SEL[25] SEL[26] SEL[27] SEL[28] SEL[29] SEL[30]
+       SEL[31] T1T TEST_RNMB VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+       VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+       VBA[16] VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23] VBA[24]
+       VBA[25] VBA[26] VBA[27] VBA[28] VBA[29] VBA[30] VBA[31] VBA[32] VBA[33]
+       VBA[34] VBA[35] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7]
+       VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+       VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25]
+       VBN[26] VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34]
+       VBN[35] VBN[36] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7]
+       VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+       VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+       VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32] VBP[33] VBP[34]
+       VBP[35] VBP[36] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6]
+       VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+       VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22]
+       VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30]
+       VDDA[31] VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDAIL1 VDDAIR1
+       VDDMINB VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7]
+       VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15]
+       VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23]
+       VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31]
+       VDDP[32] VDDP[33] VDDP[34] VDDP[35] VDDP[36] VDDPI[0] VDDPI[1] VDDPI[2]
+       VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+       VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17]
+       VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24]
+       VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31]
+       VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36] VDDWL[0] VDDWL[1]
+       VEDGE[0] VEDGE[1] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6]
+       VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15]
+       VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24]
+       VSS[25] VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33]
+       VSS[34] VSS[35] VSS[36] VSSC_WL_L VSSC_WL_R WABUF[0] WABUF[1] WABUF[2]
+       WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10]
+       WB[11] WB[12] WB[13] WB[14] WB[15] WB[16] WB[17] WB[18] WB[19] WB[20]
+       WB[21] WB[22] WB[23] WB[24] WB[25] WB[26] WB[27] WB[28] WB[29] WB[30]
+       WB[31] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8]
+       WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17]
+       WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26]
+       WBI[27] WBI[28] WBI[29] WBI[30] WBI[31] WCLKB[0] WCLKB[1] WCLKB[2]
+       WCLKB[3] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT[0]
+       WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11]
+       WT[12] WT[13] WT[14] WT[15] WT[16] WT[17] WT[18] WT[19] WT[20] WT[21]
+       WT[22] WT[23] WT[24] WT[25] WT[26] WT[27] WT[28] WT[29] WT[30] WT[31]
+       WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9]
+       WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18]
+       WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27]
+       WTI[28] WTI[29] WTI[30] WTI[31]
X_mux_lt BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BOTEDGE[0]
+   BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11]
+   BT[12] BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22]
+   BT[23] BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33]
+   BT[34] BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44]
+   BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55]
+   BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] CKPRCHL LOG0 LOG1
+   PGIOI[0] PO[0] POWINT[0] POWINT[1] PRCHRDBL[0] PRCHRDBL[1] PRCHRDBL[2]
+   PRCHRDBL[3] PRCHWRBL[0] PRCHWRBL[1] PRCHWRBL[2] PRCHWRBL[3] QB[0] QB[1]
+   QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13]
+   QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9]
+   QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] RB[0] RB[1] RB[2] RB[3] RB[4]
+   RB[5] RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15]
+   RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11]
+   RT[12] RT[13] RT[14] RT[15] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+   SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] VBA[0]
+   VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10]
+   VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16] VBN[0] VBN[1] VBN[2] VBN[3]
+   VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13]
+   VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+   VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+   VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8]
+   VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16]
+   VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7]
+   VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15]
+   VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6]
+   VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+   VDDPI[15] VDDPI[16] VEDGE[0] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+   VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15]
+   VSS[16] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10]
+   WB[11] WB[12] WB[13] WB[14] WB[15] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11]
+   WT[12] WT[13] WT[14] WT[15] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_mux_lt
X_mux_cnt ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1]
+   BOTEDGE[1] BOTEDGE[2] BYP_VLOAD CENDP CKPRCHH CKPRCHL DEF_MODE FAST1_MODE
+   FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR0 LBKADR1 LCGTH[0] LCGTH[1]
+   LCGTH_PCHG LDFTX LITESLP LMATCH LMATCHB LOG0 LOG1 LWEIB LWERD LWEWR LXADR[0]
+   LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+   LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0]
+   PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] PM[0] PM[1] PM[2] PM[3]
+   PO[0] PO[1] PRCHRDBH[0] PRCHRDBH[1] PRCHRDBH[2] PRCHRDBH[3] PRCHRDBL[0]
+   PRCHRDBL[1] PRCHRDBL[2] PRCHRDBL[3] PRCHWRBH[0] PRCHWRBH[1] PRCHWRBH[2]
+   PRCHWRBH[3] PRCHWRBL[0] PRCHWRBL[1] PRCHWRBL[2] PRCHWRBL[3] PRCKE_B
+   RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RASSISTBH[0] RASSISTBH[1]
+   RASSISTBL[0] RASSISTBL[1] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2]
+   RMT[3] RWLB_SAC T1T TEST_RNMB VBA[17] VBA[18] VBN[17] VBN[18] VBN[19]
+   VBP[17] VBP[18] VBP[19] VDDA[17] VDDA[18] VDDA[19] VDDMINB VDDP[17] VDDP[18]
+   VDDP[19] VDDPI[17] VDDPI[18] VDDPI[19] VDDWL[0] VDDWL[1] VSS[17] VSS[18]
+   VSS[19] VSSC_WL_L VSSC_WL_R WABUF[0] WABUF[1] WABUF[2] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]
+   SNPS_SP_HD_16Kx8_mux_cnt
X_mux_rt BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73]
+   BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83] BB[84]
+   BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95]
+   BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103] BB[104] BB[105]
+   BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BB[112] BB[113] BB[114]
+   BB[115] BB[116] BB[117] BB[118] BB[119] BB[120] BB[121] BB[122] BB[123]
+   BB[124] BB[125] BB[126] BB[127] BOTEDGE[3] BT[64] BT[65] BT[66] BT[67]
+   BT[68] BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78]
+   BT[79] BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89]
+   BT[90] BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99]
+   BT[100] BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108]
+   BT[109] BT[110] BT[111] BT[112] BT[113] BT[114] BT[115] BT[116] BT[117]
+   BT[118] BT[119] BT[120] BT[121] BT[122] BT[123] BT[124] BT[125] BT[126]
+   BT[127] CKPRCHH LOG0 LOG1 PGIOI[1] PO[1] POWINT[2] POWINT[3] PRCHRDBH[0]
+   PRCHRDBH[1] PRCHRDBH[2] PRCHRDBH[3] PRCHWRBH[0] PRCHWRBH[1] PRCHWRBH[2]
+   PRCHWRBH[3] QB[16] QB[17] QB[18] QB[19] QB[20] QB[21] QB[22] QB[23] QB[24]
+   QB[25] QB[26] QB[27] QB[28] QB[29] QB[30] QB[31] QT[16] QT[17] QT[18] QT[19]
+   QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28] QT[29] QT[30]
+   QT[31] RB[16] RB[17] RB[18] RB[19] RB[20] RB[21] RB[22] RB[23] RB[24] RB[25]
+   RB[26] RB[27] RB[28] RB[29] RB[30] RB[31] RT[16] RT[17] RT[18] RT[19] RT[20]
+   RT[21] RT[22] RT[23] RT[24] RT[25] RT[26] RT[27] RT[28] RT[29] RT[30] RT[31]
+   SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21] SEL[22] SEL[23] SEL[24]
+   SEL[25] SEL[26] SEL[27] SEL[28] SEL[29] SEL[30] SEL[31] VBA[19] VBA[20]
+   VBA[21] VBA[22] VBA[23] VBA[24] VBA[25] VBA[26] VBA[27] VBA[28] VBA[29]
+   VBA[30] VBA[31] VBA[32] VBA[33] VBA[34] VBA[35] VBN[20] VBN[21] VBN[22]
+   VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28] VBN[29] VBN[30] VBN[31]
+   VBN[32] VBN[33] VBN[34] VBN[35] VBN[36] VBP[20] VBP[21] VBP[22] VBP[23]
+   VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32]
+   VBP[33] VBP[34] VBP[35] VBP[36] VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24]
+   VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31] VDDA[32]
+   VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDAIR1 VDDP[20] VDDP[21] VDDP[22]
+   VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDP[29] VDDP[30]
+   VDDP[31] VDDP[32] VDDP[33] VDDP[34] VDDP[35] VDDP[36] VDDPI[20] VDDPI[21]
+   VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28]
+   VDDPI[29] VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35]
+   VDDPI[36] VEDGE[1] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26]
+   VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34] VSS[35]
+   VSS[36] WB[16] WB[17] WB[18] WB[19] WB[20] WB[21] WB[22] WB[23] WB[24]
+   WB[25] WB[26] WB[27] WB[28] WB[29] WB[30] WB[31] WBI[16] WBI[17] WBI[18]
+   WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27]
+   WBI[28] WBI[29] WBI[30] WBI[31] WT[16] WT[17] WT[18] WT[19] WT[20] WT[21]
+   WT[22] WT[23] WT[24] WT[25] WT[26] WT[27] WT[28] WT[29] WT[30] WT[31]
+   WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24]
+   WTI[25] WTI[26] WTI[27] WTI[28] WTI[29] WTI[30] WTI[31]
+   SNPS_SP_HD_16Kx8_mux_rt
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_mux_row_b_mx ARYSD[0] ARYSD[1] ARYSD_BC1[0]
+       ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1] BB[0] BB[1] BB[2] BB[3] BB[4]
+       BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15]
+       BB[16] BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25]
+       BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35]
+       BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45]
+       BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55]
+       BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BB[64] BB[65]
+       BB[66] BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75]
+       BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83] BB[84] BB[85]
+       BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95]
+       BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103] BB[104]
+       BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BB[112] BB[113]
+       BB[114] BB[115] BB[116] BB[117] BB[118] BB[119] BB[120] BB[121] BB[122]
+       BB[123] BB[124] BB[125] BB[126] BB[127] BOTEDGE[0] BOTEDGE[1] BOTEDGE[2]
+       BOTEDGE[3] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9]
+       BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19]
+       BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28] BT[29]
+       BT[30] BT[31] BT[32] BT[33] BT[34] BT[35] BT[36] BT[37] BT[38] BT[39]
+       BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47] BT[48] BT[49]
+       BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57] BT[58] BT[59]
+       BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68] BT[69]
+       BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79]
+       BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89]
+       BT[90] BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99]
+       BT[100] BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108]
+       BT[109] BT[110] BT[111] BT[112] BT[113] BT[114] BT[115] BT[116] BT[117]
+       BT[118] BT[119] BT[120] BT[121] BT[122] BT[123] BT[124] BT[125] BT[126]
+       BT[127] BYP_VLOAD CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT
+       FLOAT_RET LBKADR0 LBKADR1 LCGTH[0] LCGTH[1] LCGTH_PCHG LDFTX LITESLP
+       LMATCH LMATCHB LOG0 LOG1 LWEIB LWERD LWEWR LXADR[0] LXADR[1] LXADR[2]
+       LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0]
+       PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+       PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] PM[0] PM[1] PM[2] PM[3] PRCKE_B
+       PWDO[0] PWDO[1] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8]
+       QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QB[16] QB[17] QB[18]
+       QB[19] QB[20] QB[21] QB[22] QB[23] QB[24] QB[25] QB[26] QB[27] QB[28]
+       QB[29] QB[30] QB[31] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+       QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17]
+       QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27]
+       QT[28] QT[29] QT[30] QT[31] RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3]
+       RASSISTBH[0] RASSISTBH[1] RASSISTBL[0] RASSISTBL[1] RB[0] RB[1] RB[2]
+       RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13]
+       RB[14] RB[15] RB[16] RB[17] RB[18] RB[19] RB[20] RB[21] RB[22] RB[23]
+       RB[24] RB[25] RB[26] RB[27] RB[28] RB[29] RB[30] RB[31] RBLRD RBLWA
+       RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RT[0] RT[1] RT[2] RT[3] RT[4]
+       RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15]
+       RT[16] RT[17] RT[18] RT[19] RT[20] RT[21] RT[22] RT[23] RT[24] RT[25]
+       RT[26] RT[27] RT[28] RT[29] RT[30] RT[31] RWLB_SAC SEL[0] SEL[1] SEL[2]
+       SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+       SEL[13] SEL[14] SEL[15] SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21]
+       SEL[22] SEL[23] SEL[24] SEL[25] SEL[26] SEL[27] SEL[28] SEL[29] SEL[30]
+       SEL[31] T1T TEST_RNMB VBA VBN VBP VDDA VDDAIL1 VDDAIR1 VDDMINB VDDP
+       VDDPI VDDWL[0] VDDWL[1] VEDGE[0] VEDGE[1] VSS VSSC_WL_L VSSC_WL_R
+       WABUF[0] WABUF[1] WABUF[2] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6]
+       WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WB[16]
+       WB[17] WB[18] WB[19] WB[20] WB[21] WB[22] WB[23] WB[24] WB[25] WB[26]
+       WB[27] WB[28] WB[29] WB[30] WB[31] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3]
+       WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10]
+       WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WB_IN[16] WB_IN[17]
+       WB_IN[18] WB_IN[19] WB_IN[20] WB_IN[21] WB_IN[22] WB_IN[23] WB_IN[24]
+       WB_IN[25] WB_IN[26] WB_IN[27] WB_IN[28] WB_IN[29] WB_IN[30] WB_IN[31]
+       WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0]
+       WPBUF[1] WPBUF[2] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8]
+       WT[9] WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WT[16] WT[17] WT[18]
+       WT[19] WT[20] WT[21] WT[22] WT[23] WT[24] WT[25] WT[26] WT[27] WT[28]
+       WT[29] WT[30] WT[31] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4]
+       WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11]
+       WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15] WT_IN[16] WT_IN[17] WT_IN[18]
+       WT_IN[19] WT_IN[20] WT_IN[21] WT_IN[22] WT_IN[23] WT_IN[24] WT_IN[25]
+       WT_IN[26] WT_IN[27] WT_IN[28] WT_IN[29] WT_IN[30] WT_IN[31]
X_mux_row_b ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+   ARYSD_BC2[1] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9]
+   BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20]
+   BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31]
+   BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42]
+   BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53]
+   BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BB[64]
+   BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75]
+   BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83] BB[84] BB[85] BB[86]
+   BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95] BB[96] BB[97]
+   BB[98] BB[99] BB[100] BB[101] BB[102] BB[103] BB[104] BB[105] BB[106]
+   BB[107] BB[108] BB[109] BB[110] BB[111] BB[112] BB[113] BB[114] BB[115]
+   BB[116] BB[117] BB[118] BB[119] BB[120] BB[121] BB[122] BB[123] BB[124]
+   BB[125] BB[126] BB[127] BOTEDGE[0] BOTEDGE[1] BOTEDGE[2] BOTEDGE[3] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34]
+   BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45]
+   BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56]
+   BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67]
+   BT[68] BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78]
+   BT[79] BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89]
+   BT[90] BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99]
+   BT[100] BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108]
+   BT[109] BT[110] BT[111] BT[112] BT[113] BT[114] BT[115] BT[116] BT[117]
+   BT[118] BT[119] BT[120] BT[121] BT[122] BT[123] BT[124] BT[125] BT[126]
+   BT[127] BYP_VLOAD CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT
+   FLOAT_RET LBKADR0 LBKADR1 LCGTH[0] LCGTH[1] LCGTH_PCHG LDFTX LITESLP LMATCH
+   LMATCHB LOG0 LOG1 LWEIB LWERD LWEWR LXADR[0] LXADR[1] LXADR[2] LXADR[3]
+   LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2]
+   PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5]
+   PCB[6] PCB[7] PWDO[0] PWDO[1] PM[0] PM[1] PM[2] PM[3] PRCKE_B QB[0] QB[1]
+   QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13]
+   QB[14] QB[15] QB[16] QB[17] QB[18] QB[19] QB[20] QB[21] QB[22] QB[23] QB[24]
+   QB[25] QB[26] QB[27] QB[28] QB[29] QB[30] QB[31] QT[0] QT[1] QT[2] QT[3]
+   QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] RASSIST[0] RASSIST[1] RASSIST[2]
+   RASSIST[3] RASSISTBH[0] RASSISTBH[1] RASSISTBL[0] RASSISTBL[1] RB[0] RB[1]
+   RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13]
+   RB[14] RB[15] RB[16] RB[17] RB[18] RB[19] RB[20] RB[21] RB[22] RB[23] RB[24]
+   RB[25] RB[26] RB[27] RB[28] RB[29] RB[30] RB[31] RBLRD RBLWA RBLWR RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7]
+   RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15] RT[16] RT[17] RT[18]
+   RT[19] RT[20] RT[21] RT[22] RT[23] RT[24] RT[25] RT[26] RT[27] RT[28] RT[29]
+   RT[30] RT[31] RWLB_SAC SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+   SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] SEL[16]
+   SEL[17] SEL[18] SEL[19] SEL[20] SEL[21] SEL[22] SEL[23] SEL[24] SEL[25]
+   SEL[26] SEL[27] SEL[28] SEL[29] SEL[30] SEL[31] T1T TEST_RNMB VBA VBA VBA
+   VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA
+   VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDAIL1 VDDAIR1 VDDMINB VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDWL[0] VDDWL[1] VEDGE[0] VEDGE[1] VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSSC_WL_L VSSC_WL_R WABUF[0] WABUF[1]
+   WABUF[2] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10]
+   WB[11] WB[12] WB[13] WB[14] WB[15] WB[16] WB[17] WB[18] WB[19] WB[20] WB[21]
+   WB[22] WB[23] WB[24] WB[25] WB[26] WB[27] WB[28] WB[29] WB[30] WB[31]
+   WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7]
+   WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14]
+   WB_IN[15] WB_IN[16] WB_IN[17] WB_IN[18] WB_IN[19] WB_IN[20] WB_IN[21]
+   WB_IN[22] WB_IN[23] WB_IN[24] WB_IN[25] WB_IN[26] WB_IN[27] WB_IN[28]
+   WB_IN[29] WB_IN[30] WB_IN[31] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] WMT[0]
+   WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT[0] WT[1] WT[2] WT[3]
+   WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14]
+   WT[15] WT[16] WT[17] WT[18] WT[19] WT[20] WT[21] WT[22] WT[23] WT[24] WT[25]
+   WT[26] WT[27] WT[28] WT[29] WT[30] WT[31] WT_IN[0] WT_IN[1] WT_IN[2]
+   WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10]
+   WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15] WT_IN[16] WT_IN[17]
+   WT_IN[18] WT_IN[19] WT_IN[20] WT_IN[21] WT_IN[22] WT_IN[23] WT_IN[24]
+   WT_IN[25] WT_IN[26] WT_IN[27] WT_IN[28] WT_IN[29] WT_IN[30] WT_IN[31]
+   SNPS_SP_HD_16Kx8_mux_row_b
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_sampwa QB[0] QB[1] QB[2] QB[3] QT[0] QT[1] QT[2] QT[3]
+       RB[0] RB[1] RB[2] RB[3] RT[0] RT[1] RT[2] RT[3] SEL[0] SEL[1] SEL[2]
+       SEL[3] VBN[0] VBN[1] VBN[2] VBN[3] VBP[0] VBP[1] VBP[2] VBP[3] VDDP[0]
+       VDDP[1] VDDP[2] VDDP[3] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VSS[0]
+       VSS[1] VSS[2] VSS[3] VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3] WA[0] WA[1]
+       WAPRCLKBUF WAPRCLKBUFB_RET WB[0] WB[1] WB[2] WB[3] WB_IN[0] WB_IN[1]
+       WB_IN[2] WB_IN[3] WT[0] WT[1] WT[2] WT[3] WT_IN[0] WT_IN[1] WT_IN[2]
+       WT_IN[3]

*** Jumper Report ***
* Jumper: VDDP[0] VDDPI[0]
* Jumper: VDDP[1] VDDPI[1]
* Jumper: VDDP[2] VDDPI[2]
* Jumper: VDDP[3] VDDPI[3]

X_mm16a05_u_hdsp_plus_hs_sacm4x1_wa_256_S0 VDDP[0] VDDPI[0] VSS[0] VSS_WA[0]
+   VBP[0] VBN[0] QB[0] QT[0] RB[0] RT[0] SEL[0] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RET WB[0] WB_IN[0] WT[0] WT_IN[0]
+   mm16a05_u_hdsp_plus_hs_sacm4x1_wa_256
X_mm16a05_u_hdsp_plus_hs_sacm4x1_wa_256_S1 VDDP[1] VDDPI[1] VSS[1] VSS_WA[1]
+   VBP[1] VBN[1] QB[1] QT[1] RB[1] RT[1] SEL[1] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RET WB[1] WB_IN[1] WT[1] WT_IN[1]
+   mm16a05_u_hdsp_plus_hs_sacm4x1_wa_256
X_mm16a05_u_hdsp_plus_hs_sacm4x1_wa_256_F1 VDDP[2] VDDPI[2] VSS[2] VSS_WA[2]
+   VBP[2] VBN[2] QB[2] QT[2] RB[2] RT[2] SEL[2] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RET WB[2] WB_IN[2] WT[2] WT_IN[2]
+   mm16a05_u_hdsp_plus_hs_sacm4x1_wa_256
X_mm16a05_u_hdsp_plus_hs_sacm4x1_wa_256_F0 VDDP[3] VDDPI[3] VSS[3] VSS_WA[3]
+   VBP[3] VBN[3] QB[3] QT[3] RB[3] RT[3] SEL[3] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RET WB[3] WB_IN[3] WT[3] WT_IN[3]
+   mm16a05_u_hdsp_plus_hs_sacm4x1_wa_256
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_sacwa_lt_seg1 QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6]
+       QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1]
+       QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12]
+       QT[13] QT[14] QT[15] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7]
+       RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RT[0] RT[1] RT[2]
+       RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13]
+       RT[14] RT[15] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7]
+       SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] VBN[0]
+       VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10]
+       VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBP[0] VBP[1] VBP[2] VBP[3]
+       VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+       VBP[13] VBP[14] VBP[15] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5]
+       VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+       VDDP[14] VDDP[15] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5]
+       VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+       VDDPI[13] VDDPI[14] VDDPI[15] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+       VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14]
+       VSS[15] VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5]
+       VSS_WA[6] VSS_WA[7] VSS_WA[8] VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12]
+       VSS_WA[13] VSS_WA[14] VSS_WA[15] WA[0] WA[1] WAPRCLKBUF WAPRCLKBUFB_RET
+       WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10]
+       WB[11] WB[12] WB[13] WB[14] WB[15] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3]
+       WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10]
+       WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WT[0] WT[1] WT[2]
+       WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13]
+       WT[14] WT[15] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5]
+       WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12]
+       WT_IN[13] WT_IN[14] WT_IN[15]
X_sampwa_S0 QB[0] QB[1] QB[2] QB[3] QT[0] QT[1] QT[2] QT[3] RB[0] RB[1] RB[2]
+   RB[3] RT[0] RT[1] RT[2] RT[3] SEL[0] SEL[1] SEL[2] SEL[3] VBN[0] VBN[1]
+   VBN[2] VBN[3] VBP[0] VBP[1] VBP[2] VBP[3] VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VSS[0] VSS[1] VSS[2] VSS[3] VSS_WA[0]
+   VSS_WA[1] VSS_WA[2] VSS_WA[3] WA[0] WA[1] WAPRCLKBUF WAPRCLKBUFB_RET WB[0]
+   WB[1] WB[2] WB[3] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WT[0] WT[1] WT[2]
+   WT[3] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] SNPS_SP_HD_16Kx8_sampwa
X_sampwa_S1 QB[4] QB[5] QB[6] QB[7] QT[4] QT[5] QT[6] QT[7] RB[4] RB[5] RB[6]
+   RB[7] RT[4] RT[5] RT[6] RT[7] SEL[4] SEL[5] SEL[6] SEL[7] VBN[4] VBN[5]
+   VBN[6] VBN[7] VBP[4] VBP[5] VBP[6] VBP[7] VDDP[4] VDDP[5] VDDP[6] VDDP[7]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VSS[4] VSS[5] VSS[6] VSS[7] VSS_WA[4]
+   VSS_WA[5] VSS_WA[6] VSS_WA[7] WA[0] WA[1] WAPRCLKBUF WAPRCLKBUFB_RET WB[4]
+   WB[5] WB[6] WB[7] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WT[4] WT[5] WT[6]
+   WT[7] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] SNPS_SP_HD_16Kx8_sampwa
X_sampwa_F1 QB[8] QB[9] QB[10] QB[11] QT[8] QT[9] QT[10] QT[11] RB[8] RB[9]
+   RB[10] RB[11] RT[8] RT[9] RT[10] RT[11] SEL[8] SEL[9] SEL[10] SEL[11] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBP[8] VBP[9] VBP[10] VBP[11] VDDP[8] VDDP[9]
+   VDDP[10] VDDP[11] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VSS[8] VSS[9]
+   VSS[10] VSS[11] VSS_WA[8] VSS_WA[9] VSS_WA[10] VSS_WA[11] WA[0] WA[1]
+   WAPRCLKBUF WAPRCLKBUFB_RET WB[8] WB[9] WB[10] WB[11] WB_IN[8] WB_IN[9]
+   WB_IN[10] WB_IN[11] WT[8] WT[9] WT[10] WT[11] WT_IN[8] WT_IN[9] WT_IN[10]
+   WT_IN[11] SNPS_SP_HD_16Kx8_sampwa
X_sampwa_F0 QB[12] QB[13] QB[14] QB[15] QT[12] QT[13] QT[14] QT[15] RB[12]
+   RB[13] RB[14] RB[15] RT[12] RT[13] RT[14] RT[15] SEL[12] SEL[13] SEL[14]
+   SEL[15] VBN[12] VBN[13] VBN[14] VBN[15] VBP[12] VBP[13] VBP[14] VBP[15]
+   VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VSS[12] VSS[13] VSS[14] VSS[15] VSS_WA[12] VSS_WA[13] VSS_WA[14] VSS_WA[15]
+   WA[0] WA[1] WAPRCLKBUF WAPRCLKBUFB_RET WB[12] WB[13] WB[14] WB[15] WB_IN[12]
+   WB_IN[13] WB_IN[14] WB_IN[15] WT[12] WT[13] WT[14] WT[15] WT_IN[12]
+   WT_IN[13] WT_IN[14] WT_IN[15] SNPS_SP_HD_16Kx8_sampwa
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_sacwa_lt LOG0 LOG1 PWDO QB[0] QB[1] QB[2] QB[3] QB[4]
+       QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15]
+       QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10]
+       QT[11] QT[12] QT[13] QT[14] QT[15] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5]
+       RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RT[0]
+       RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11]
+       RT[12] RT[13] RT[14] RT[15] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5]
+       SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14]
+       SEL[15] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+       VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0]
+       VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10]
+       VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDP[0] VDDP[1] VDDP[2]
+       VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+       VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1]
+       VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9]
+       VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16]
+       VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+       VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS_WA[0]
+       VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7]
+       VSS_WA[8] VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12] VSS_WA[13]
+       VSS_WA[14] VSS_WA[15] WAL[0] WAL[1] WAPRCLKBUF WAPRCLKBUFB_RETL WB[0]
+       WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11]
+       WB[12] WB[13] WB[14] WB[15] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4]
+       WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11]
+       WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WT[0] WT[1] WT[2] WT[3] WT[4]
+       WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14] WT[15]
+       WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7]
+       WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14]
+       WT_IN[15]
X_mm16a05_u_hdsp_plus_capsac_wa_left VDDP[0] VDDPI[0] VSS[0] VBP[0] VBN[0] LOG0
+   LOG1 PWDO VEDGE WAPRCLKBUF WAPRCLKBUFB_RET mm16a05_u_hdsp_plus_capsac_wa
X_sacwa_lt_seg1 QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9]
+   QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4]
+   QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15]
+   RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10] RB[11]
+   RB[12] RB[13] RB[14] RB[15] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7]
+   RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+   SEL[13] SEL[14] SEL[15] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7]
+   VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5]
+   VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13]
+   VDDPI[14] VDDPI[15] VDDPI[16] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6]
+   VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6]
+   VSS_WA[7] VSS_WA[8] VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12] VSS_WA[13]
+   VSS_WA[14] VSS_WA[15] WAL[0] WAL[1] WAPRCLKBUF WAPRCLKBUFB_RETL WB[0] WB[1]
+   WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13]
+   WB[14] WB[15] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6]
+   WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14]
+   WB_IN[15] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10]
+   WT[11] WT[12] WT[13] WT[14] WT[15] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3]
+   WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11]
+   WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15] SNPS_SP_HD_16Kx8_sacwa_lt_seg1
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_sacwa_cnt ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1]
+       ARYSD_BC2[0] ARYSD_BC2[1] CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT
+       FLOATT FLOAT_RET LBKADR0 LBKADR1 LBKADR2 LCGTH[0] LCGTH[1] LCGTH_PCHG
+       LDFTX LITESLP LMATCHB LOG0 LOG1 LWEIB LWERD LWEWR LXADR[0] LXADR[1]
+       LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+       PM[0] PM[1] PM[2] PM[3] PRCKE_B RASSIST[0] RASSIST[1] RASSIST[2]
+       RASSIST[3] RBLWA RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] T1T TEST_RNMB VBN[0]
+       VBN[1] VBN[2] VBP[0] VBP[1] VBP[2] VDDA[0] VDDA[1] VDDA[2] VDDMINB
+       VDDP[0] VDDP[1] VDDP[2] VDDPI[0] VDDPI[1] VDDPI[2] VSS[0] VSS[1] VSS[2]
+       WABUF[0] WABUF[1] WABUF[2] WAL[0] WAL[1] WAPRCLKBUF[0] WAPRCLKBUF[1]
+       WAPRCLKBUFB_RET WAPRCLKBUFB_RETL WAR[0] WAR[1] WMT[0] WMT[1] WMT[2]
+       WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]

*** Jumper Report ***
* Jumper: PRCKDLY TAP1
* Jumper: VDDP[1] VDDPI[1]
* Jumper: VDDP[2] VDDPI[2]

X_mm16a05_u_hdsp_plus_sacbuf_wa_left VDDA[0] VDDP[0] VDDPI[0] VSS[0] VBP[0]
+   VBN[0] WAL[0] WAL[1] WAPRCLKBUF[0] ARYSD[0] ARYSD_BC1[0] ARYSD_BC2[0]
+   LCGTH[0] RASSIST[0] RASSIST[1] WAPRCLKBUFB_RETL WABUF[0] WABUF[1] WAPRCLK
+   mm16a05_u_hdsp_plus_sacbuf_wa
X_mm16a05_u_hdsp_plus_sactrlwa_256 VDDA[1] VDDMINB VDDP[1] VDDPI[1] VSS[1]
+   VBP[1] VBN[1] TAP0 PRCKDLY TAP2 TAP3 WAPRCLK DEF_MODE FAST1_MODE FAST2_MODE
+   FLOAT FLOAT_RET LBKADR0 LBKADR1 LBKADR2 LCGTH_PCHG LMATCHB LOG0 LOG1 LWERD
+   LWEWR PM[0] PM[1] PM[2] PM[3] PRCKE_B RBLWA RM3CNT TEST_RNMB WABUF[0]
+   WABUF[1] WABUF[2] WAPRCLKBUFB_RET WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0]
+   WPBUF[1] WPBUF[2] CENDP FLOATT LDFTX LITESLP LWEIB LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PRCKDLY RMT[0] RMT[1] RMT[2] RMT[3] T1T mm16a05_u_hdsp_plus_sactrl_wa
X_mm16a05_u_hdsp_plus_sacbuf_wa VDDA[2] VDDP[2] VDDPI[2] VSS[2] VBP[2] VBN[2]
+   WAR[0] WAR[1] WAPRCLKBUF[1] ARYSD[1] ARYSD_BC1[1] ARYSD_BC2[1] LCGTH[1]
+   RASSIST[2] RASSIST[3] WAPRCLKBUFB_RET WABUF[0] WABUF[1] WAPRCLK
+   mm16a05_u_hdsp_plus_sacbuf_wa
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_sacwa_rt LOG0 LOG1 PWDO QB[0] QB[1] QB[2] QB[3] QB[4]
+       QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15]
+       QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10]
+       QT[11] QT[12] QT[13] QT[14] QT[15] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5]
+       RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RT[0]
+       RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11]
+       RT[12] RT[13] RT[14] RT[15] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5]
+       SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14]
+       SEL[15] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+       VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0]
+       VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10]
+       VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDP[0] VDDP[1] VDDP[2]
+       VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+       VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1]
+       VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9]
+       VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16]
+       VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+       VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS_WA[0]
+       VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7]
+       VSS_WA[8] VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12] VSS_WA[13]
+       VSS_WA[14] VSS_WA[15] WAPRCLKBUF WAPRCLKBUFB_RET WAR[0] WAR[1] WB[0]
+       WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11]
+       WB[12] WB[13] WB[14] WB[15] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4]
+       WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11]
+       WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WT[0] WT[1] WT[2] WT[3] WT[4]
+       WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14] WT[15]
+       WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7]
+       WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14]
+       WT_IN[15]
X_sacwa_lt_seg1 QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9]
+   QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4]
+   QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15]
+   RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10] RB[11]
+   RB[12] RB[13] RB[14] RB[15] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7]
+   RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+   SEL[13] SEL[14] SEL[15] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+   VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10]
+   VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+   VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+   VDDPI[13] VDDPI[14] VDDPI[15] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+   VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15]
+   VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6]
+   VSS_WA[7] VSS_WA[8] VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12] VSS_WA[13]
+   VSS_WA[14] VSS_WA[15] WAR[0] WAR[1] WAPRCLKBUF WAPRCLKBUFB_RET WB[0] WB[1]
+   WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13]
+   WB[14] WB[15] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6]
+   WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14]
+   WB_IN[15] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10]
+   WT[11] WT[12] WT[13] WT[14] WT[15] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3]
+   WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11]
+   WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15] SNPS_SP_HD_16Kx8_sacwa_lt_seg1
X_mm16a05_u_hdsp_plus_capsac_wa_256 VDDP[16] VDDPI[16] VSS[16] VBP[16] VBN[16]
+   LOG0 LOG1 PWDO VEDGE WAPRCLKBUF WAPRCLKBUFB_RET
+   mm16a05_u_hdsp_plus_capsac_wa
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_sacwa_row ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1]
+       ARYSD_BC2[0] ARYSD_BC2[1] CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT
+       FLOATT FLOAT_RET LBKADR0 LBKADR1 LBKADR2 LCGTH[0] LCGTH[1] LCGTH_PCHG
+       LDFTX LITESLP LMATCHB LOG0[0] LOG0[1] LOG0[2] LOG1[0] LOG1[1] LOG1[2]
+       LWEIB LWERD LWEWR LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+       LXADR[6] LXADR[7] LYADR[0] LYADR[1] PM[0] PM[1] PM[2] PM[3] PRCKE_B
+       PWDO[0] PWDO[1] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8]
+       QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QB[16] QB[17] QB[18]
+       QB[19] QB[20] QB[21] QB[22] QB[23] QB[24] QB[25] QB[26] QB[27] QB[28]
+       QB[29] QB[30] QB[31] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+       QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17]
+       QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27]
+       QT[28] QT[29] QT[30] QT[31] RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3]
+       RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10]
+       RB[11] RB[12] RB[13] RB[14] RB[15] RB[16] RB[17] RB[18] RB[19] RB[20]
+       RB[21] RB[22] RB[23] RB[24] RB[25] RB[26] RB[27] RB[28] RB[29] RB[30]
+       RB[31] RBLWA RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RT[0] RT[1] RT[2] RT[3]
+       RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14]
+       RT[15] RT[16] RT[17] RT[18] RT[19] RT[20] RT[21] RT[22] RT[23] RT[24]
+       RT[25] RT[26] RT[27] RT[28] RT[29] RT[30] RT[31] SEL[0] SEL[1] SEL[2]
+       SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+       SEL[13] SEL[14] SEL[15] SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21]
+       SEL[22] SEL[23] SEL[24] SEL[25] SEL[26] SEL[27] SEL[28] SEL[29] SEL[30]
+       SEL[31] T1T TEST_RNMB VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+       VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15]
+       VBN[16] VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24]
+       VBN[25] VBN[26] VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33]
+       VBN[34] VBN[35] VBN[36] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+       VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15]
+       VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24]
+       VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32] VBP[33]
+       VBP[34] VBP[35] VBP[36] VDDA[0] VDDA[1] VDDA[2] VDDMINB VDDP[0] VDDP[1]
+       VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+       VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+       VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+       VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+       VDDP[35] VDDP[36] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5]
+       VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+       VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19]
+       VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26]
+       VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33]
+       VDDPI[34] VDDPI[35] VDDPI[36] VEDGE[0] VEDGE[1] VSS[0] VSS[1] VSS[2]
+       VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+       VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21]
+       VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28] VSS[29] VSS[30]
+       VSS[31] VSS[32] VSS[33] VSS[34] VSS[35] VSS[36] VSS_WA[0] VSS_WA[1]
+       VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7] VSS_WA[8]
+       VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12] VSS_WA[13] VSS_WA[14]
+       VSS_WA[15] VSS_WA[16] VSS_WA[17] VSS_WA[18] VSS_WA[19] VSS_WA[20]
+       VSS_WA[21] VSS_WA[22] VSS_WA[23] VSS_WA[24] VSS_WA[25] VSS_WA[26]
+       VSS_WA[27] VSS_WA[28] VSS_WA[29] VSS_WA[30] VSS_WA[31] WABUF[0] WABUF[1]
+       WABUF[2] WAPRCLKBUFB_RET WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7]
+       WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WB[16] WB[17]
+       WB[18] WB[19] WB[20] WB[21] WB[22] WB[23] WB[24] WB[25] WB[26] WB[27]
+       WB[28] WB[29] WB[30] WB[31] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4]
+       WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11]
+       WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WB_IN[16] WB_IN[17] WB_IN[18]
+       WB_IN[19] WB_IN[20] WB_IN[21] WB_IN[22] WB_IN[23] WB_IN[24] WB_IN[25]
+       WB_IN[26] WB_IN[27] WB_IN[28] WB_IN[29] WB_IN[30] WB_IN[31] WMT[0]
+       WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT[0] WT[1] WT[2] WT[3]
+       WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14]
+       WT[15] WT[16] WT[17] WT[18] WT[19] WT[20] WT[21] WT[22] WT[23] WT[24]
+       WT[25] WT[26] WT[27] WT[28] WT[29] WT[30] WT[31] WT_IN[0] WT_IN[1]
+       WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9]
+       WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15] WT_IN[16]
+       WT_IN[17] WT_IN[18] WT_IN[19] WT_IN[20] WT_IN[21] WT_IN[22] WT_IN[23]
+       WT_IN[24] WT_IN[25] WT_IN[26] WT_IN[27] WT_IN[28] WT_IN[29] WT_IN[30]
+       WT_IN[31]
X_sacwa_lt LOG0[0] LOG1[0] PWDO[0] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6]
+   QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13]
+   QT[14] QT[15] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9]
+   RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RT[0] RT[1] RT[2] RT[3] RT[4]
+   RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15]
+   SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9]
+   SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] VBN[0] VBN[1] VBN[2] VBN[3]
+   VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13]
+   VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+   VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+   VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8]
+   VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16]
+   VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+   VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+   VDDPI[15] VDDPI[16] VEDGE[0] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+   VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15]
+   VSS[16] VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5]
+   VSS_WA[6] VSS_WA[7] VSS_WA[8] VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12]
+   VSS_WA[13] VSS_WA[14] VSS_WA[15] WAL[0] WAL[1] WAPRCLKBUF[0]
+   WAPRCLKBUFB_RETL WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9]
+   WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WB_IN[0] WB_IN[1] WB_IN[2]
+   WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10]
+   WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WT[0] WT[1] WT[2] WT[3]
+   WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14]
+   WT[15] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6]
+   WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14]
+   WT_IN[15] SNPS_SP_HD_16Kx8_sacwa_lt
X_sacwa_cnt ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+   ARYSD_BC2[1] CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET
+   LBKADR0 LBKADR1 LBKADR2 LCGTH[0] LCGTH[1] LCGTH_PCHG LDFTX LITESLP LMATCHB
+   LOG0[1] LOG1[1] LWEIB LWERD LWEWR LXADR[0] LXADR[1] LXADR[2] LXADR[3]
+   LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PM[0] PM[1] PM[2]
+   PM[3] PRCKE_B RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RBLWA RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] T1T TEST_RNMB VBN[17] VBN[18] VBN[19] VBP[17]
+   VBP[18] VBP[19] VDDA[0] VDDA[1] VDDA[2] VDDMINB VDDP[17] VDDP[18] VDDP[19]
+   VDDPI[17] VDDPI[18] VDDPI[19] VSS[17] VSS[18] VSS[19] WABUF[0] WABUF[1]
+   WABUF[2] WAL[0] WAL[1] WAPRCLKBUF[0] WAPRCLKBUF[1] WAPRCLKBUFB_RET
+   WAPRCLKBUFB_RETL WAR[0] WAR[1] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] SNPS_SP_HD_16Kx8_sacwa_cnt
X_sacwa_rt LOG0[2] LOG1[2] PWDO[1] QB[16] QB[17] QB[18] QB[19] QB[20] QB[21]
+   QB[22] QB[23] QB[24] QB[25] QB[26] QB[27] QB[28] QB[29] QB[30] QB[31] QT[16]
+   QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27]
+   QT[28] QT[29] QT[30] QT[31] RB[16] RB[17] RB[18] RB[19] RB[20] RB[21] RB[22]
+   RB[23] RB[24] RB[25] RB[26] RB[27] RB[28] RB[29] RB[30] RB[31] RT[16] RT[17]
+   RT[18] RT[19] RT[20] RT[21] RT[22] RT[23] RT[24] RT[25] RT[26] RT[27] RT[28]
+   RT[29] RT[30] RT[31] SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21] SEL[22]
+   SEL[23] SEL[24] SEL[25] SEL[26] SEL[27] SEL[28] SEL[29] SEL[30] SEL[31]
+   VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28]
+   VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35] VBN[36] VBP[20]
+   VBP[21] VBP[22] VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29]
+   VBP[30] VBP[31] VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VDDP[20] VDDP[21]
+   VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDP[29]
+   VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34] VDDP[35] VDDP[36] VDDPI[20]
+   VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27]
+   VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34]
+   VDDPI[35] VDDPI[36] VEDGE[1] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+   VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34]
+   VSS[35] VSS[36] VSS_WA[16] VSS_WA[17] VSS_WA[18] VSS_WA[19] VSS_WA[20]
+   VSS_WA[21] VSS_WA[22] VSS_WA[23] VSS_WA[24] VSS_WA[25] VSS_WA[26] VSS_WA[27]
+   VSS_WA[28] VSS_WA[29] VSS_WA[30] VSS_WA[31] WAPRCLKBUF[1] WAPRCLKBUFB_RET
+   WAR[0] WAR[1] WB[16] WB[17] WB[18] WB[19] WB[20] WB[21] WB[22] WB[23] WB[24]
+   WB[25] WB[26] WB[27] WB[28] WB[29] WB[30] WB[31] WB_IN[16] WB_IN[17]
+   WB_IN[18] WB_IN[19] WB_IN[20] WB_IN[21] WB_IN[22] WB_IN[23] WB_IN[24]
+   WB_IN[25] WB_IN[26] WB_IN[27] WB_IN[28] WB_IN[29] WB_IN[30] WB_IN[31] WT[16]
+   WT[17] WT[18] WT[19] WT[20] WT[21] WT[22] WT[23] WT[24] WT[25] WT[26] WT[27]
+   WT[28] WT[29] WT[30] WT[31] WT_IN[16] WT_IN[17] WT_IN[18] WT_IN[19]
+   WT_IN[20] WT_IN[21] WT_IN[22] WT_IN[23] WT_IN[24] WT_IN[25] WT_IN[26]
+   WT_IN[27] WT_IN[28] WT_IN[29] WT_IN[30] WT_IN[31] SNPS_SP_HD_16Kx8_sacwa_rt
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_samp BYPASS BYPASS_RET LCGTH LOG0 LOG1 QBOUT[0]
+       QBOUT[1] QBOUT[2] QBOUT[3] QB_IN[0] QB_IN[1] QB_IN[2] QB_IN[3]
+       QB_NORIN[0] QB_NORIN[1] QB_NORIN[2] QB_NORIN[3] QTOUT[0] QTOUT[1]
+       QTOUT[2] QTOUT[3] QT_IN[0] QT_IN[1] QT_IN[2] QT_IN[3] QT_NORIN[0]
+       QT_NORIN[1] QT_NORIN[2] QT_NORIN[3] RASSISTT[0] RASSISTT[1] RB[0] RB[1]
+       RB[2] RB[3] RT[0] RT[1] RT[2] RT[3] SAEB SAED SAPRB SEL[0] SEL[1] SEL[2]
+       SEL[3] VBN[0] VBN[1] VBN[2] VBN[3] VBP[0] VBP[1] VBP[2] VBP[3] VDDP[0]
+       VDDP[1] VDDP[2] VDDP[3] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VSS[0]
+       VSS[1] VSS[2] VSS[3] VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3] WB[0] WB[1]
+       WB[2] WB[3] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WT[0] WT[1] WT[2] WT[3]
+       WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3]

*** Jumper Report ***
* Jumper: QB_IN[0] QB_NORIN[0]
* Jumper: QB_IN[1] QB_NORIN[1]
* Jumper: QB_IN[2] QB_NORIN[2]
* Jumper: QB_IN[3] QB_NORIN[3]
* Jumper: QT_IN[0] QT_NORIN[0]
* Jumper: QT_IN[1] QT_NORIN[1]
* Jumper: QT_IN[2] QT_NORIN[2]
* Jumper: QT_IN[3] QT_NORIN[3]
* Jumper: VDDP[0] VDDPI[0]
* Jumper: VDDP[1] VDDPI[1]
* Jumper: VDDP[2] VDDPI[2]
* Jumper: VDDP[3] VDDPI[3]

X_mm16a05_u_hdsp_plus_sacm4x1_nor_S0 VDDP[0] VDDPI[0] VSS[0] VSS_WA[0] VBP[0]
+   VBN[0] QBOUT[0] QTOUT[0] BYPASS BYPASS_RET LCGTH LOG0 LOG1 RASSISTT[0]
+   RASSISTT[1] RB[0] RT[0] SAED WB[0] WB_IN[0] WT[0] WT_IN[0] QB_IN[0]
+   QB_NORIN[0] QT_IN[0] QT_NORIN[0] SAEB SAPRB SEL[0]
+   mm16a05_u_hdsp_plus_sacm4x1_nor
X_mm16a05_u_hdsp_plus_sacm4x1_nor_S1 VDDP[1] VDDPI[1] VSS[1] VSS_WA[1] VBP[1]
+   VBN[1] QBOUT[1] QTOUT[1] BYPASS BYPASS_RET LCGTH LOG0 LOG1 RASSISTT[0]
+   RASSISTT[1] RB[1] RT[1] SAED WB[1] WB_IN[1] WT[1] WT_IN[1] QB_IN[1]
+   QB_NORIN[1] QT_IN[1] QT_NORIN[1] SAEB SAPRB SEL[1]
+   mm16a05_u_hdsp_plus_sacm4x1_nor
X_mm16a05_u_hdsp_plus_sacm4x1_nor_F1 VDDP[2] VDDPI[2] VSS[2] VSS_WA[2] VBP[2]
+   VBN[2] QBOUT[2] QTOUT[2] BYPASS BYPASS_RET LCGTH LOG0 LOG1 RASSISTT[0]
+   RASSISTT[1] RB[2] RT[2] SAED WB[2] WB_IN[2] WT[2] WT_IN[2] QB_IN[2]
+   QB_NORIN[2] QT_IN[2] QT_NORIN[2] SAEB SAPRB SEL[2]
+   mm16a05_u_hdsp_plus_sacm4x1_nor
X_mm16a05_u_hdsp_plus_sacm4x1_nor_F0 VDDP[3] VDDPI[3] VSS[3] VSS_WA[3] VBP[3]
+   VBN[3] QBOUT[3] QTOUT[3] BYPASS BYPASS_RET LCGTH LOG0 LOG1 RASSISTT[0]
+   RASSISTT[1] RB[3] RT[3] SAED WB[3] WB_IN[3] WT[3] WT_IN[3] QB_IN[3]
+   QB_NORIN[3] QT_IN[3] QT_NORIN[3] SAEB SAPRB SEL[3]
+   mm16a05_u_hdsp_plus_sacm4x1_nor
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_sac_lt_seg1 BYPASS BYPASS_RET LCGTH LOG0 LOG1 QBOUT[0]
+       QBOUT[1] QBOUT[2] QBOUT[3] QBOUT[4] QBOUT[5] QBOUT[6] QBOUT[7] QBOUT[8]
+       QBOUT[9] QBOUT[10] QBOUT[11] QBOUT[12] QBOUT[13] QBOUT[14] QBOUT[15]
+       QB_IN[0] QB_IN[1] QB_IN[2] QB_IN[3] QB_IN[4] QB_IN[5] QB_IN[6] QB_IN[7]
+       QB_IN[8] QB_IN[9] QB_IN[10] QB_IN[11] QB_IN[12] QB_IN[13] QB_IN[14]
+       QB_IN[15] QB_NORIN[0] QB_NORIN[1] QB_NORIN[2] QB_NORIN[3] QB_NORIN[4]
+       QB_NORIN[5] QB_NORIN[6] QB_NORIN[7] QB_NORIN[8] QB_NORIN[9] QB_NORIN[10]
+       QB_NORIN[11] QB_NORIN[12] QB_NORIN[13] QB_NORIN[14] QB_NORIN[15]
+       QTOUT[0] QTOUT[1] QTOUT[2] QTOUT[3] QTOUT[4] QTOUT[5] QTOUT[6] QTOUT[7]
+       QTOUT[8] QTOUT[9] QTOUT[10] QTOUT[11] QTOUT[12] QTOUT[13] QTOUT[14]
+       QTOUT[15] QT_IN[0] QT_IN[1] QT_IN[2] QT_IN[3] QT_IN[4] QT_IN[5] QT_IN[6]
+       QT_IN[7] QT_IN[8] QT_IN[9] QT_IN[10] QT_IN[11] QT_IN[12] QT_IN[13]
+       QT_IN[14] QT_IN[15] QT_NORIN[0] QT_NORIN[1] QT_NORIN[2] QT_NORIN[3]
+       QT_NORIN[4] QT_NORIN[5] QT_NORIN[6] QT_NORIN[7] QT_NORIN[8] QT_NORIN[9]
+       QT_NORIN[10] QT_NORIN[11] QT_NORIN[12] QT_NORIN[13] QT_NORIN[14]
+       QT_NORIN[15] RASSISTT[0] RASSISTT[1] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5]
+       RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RT[0]
+       RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11]
+       RT[12] RT[13] RT[14] RT[15] SAEB SAED SAPRB SEL[0] SEL[1] SEL[2] SEL[3]
+       SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+       SEL[13] SEL[14] SEL[15] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+       VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15]
+       VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9]
+       VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VDDP[0] VDDP[1] VDDP[2]
+       VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+       VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDPI[0] VDDPI[1] VDDPI[2]
+       VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+       VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VSS[0] VSS[1] VSS[2]
+       VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+       VSS[13] VSS[14] VSS[15] VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3]
+       VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7] VSS_WA[8] VSS_WA[9] VSS_WA[10]
+       VSS_WA[11] VSS_WA[12] VSS_WA[13] VSS_WA[14] VSS_WA[15] WB[0] WB[1] WB[2]
+       WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13]
+       WB[14] WB[15] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5]
+       WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12]
+       WB_IN[13] WB_IN[14] WB_IN[15] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6]
+       WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WT_IN[0]
+       WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8]
+       WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15]
X_samp_S0 BYPASS BYPASS_RET LCGTH LOG0 LOG1 QBOUT[0] QBOUT[1] QBOUT[2] QBOUT[3]
+   QB_IN[0] QB_IN[1] QB_IN[2] QB_IN[3] QB_NORIN[0] QB_NORIN[1] QB_NORIN[2]
+   QB_NORIN[3] QTOUT[0] QTOUT[1] QTOUT[2] QTOUT[3] QT_IN[0] QT_IN[1] QT_IN[2]
+   QT_IN[3] QT_NORIN[0] QT_NORIN[1] QT_NORIN[2] QT_NORIN[3] RASSISTT[0]
+   RASSISTT[1] RB[0] RB[1] RB[2] RB[3] RT[0] RT[1] RT[2] RT[3] SAEB SAED SAPRB
+   SEL[0] SEL[1] SEL[2] SEL[3] VBN[0] VBN[1] VBN[2] VBN[3] VBP[0] VBP[1] VBP[2]
+   VBP[3] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VSS[0] VSS[1] VSS[2] VSS[3] VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3] WB[0]
+   WB[1] WB[2] WB[3] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WT[0] WT[1] WT[2]
+   WT[3] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] SNPS_SP_HD_16Kx8_samp
X_samp_S1 BYPASS BYPASS_RET LCGTH LOG0 LOG1 QBOUT[4] QBOUT[5] QBOUT[6] QBOUT[7]
+   QB_IN[4] QB_IN[5] QB_IN[6] QB_IN[7] QB_NORIN[4] QB_NORIN[5] QB_NORIN[6]
+   QB_NORIN[7] QTOUT[4] QTOUT[5] QTOUT[6] QTOUT[7] QT_IN[4] QT_IN[5] QT_IN[6]
+   QT_IN[7] QT_NORIN[4] QT_NORIN[5] QT_NORIN[6] QT_NORIN[7] RASSISTT[0]
+   RASSISTT[1] RB[4] RB[5] RB[6] RB[7] RT[4] RT[5] RT[6] RT[7] SAEB SAED SAPRB
+   SEL[4] SEL[5] SEL[6] SEL[7] VBN[4] VBN[5] VBN[6] VBN[7] VBP[4] VBP[5] VBP[6]
+   VBP[7] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+   VSS[4] VSS[5] VSS[6] VSS[7] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7] WB[4]
+   WB[5] WB[6] WB[7] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WT[4] WT[5] WT[6]
+   WT[7] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] SNPS_SP_HD_16Kx8_samp
X_samp_F1 BYPASS BYPASS_RET LCGTH LOG0 LOG1 QBOUT[8] QBOUT[9] QBOUT[10]
+   QBOUT[11] QB_IN[8] QB_IN[9] QB_IN[10] QB_IN[11] QB_NORIN[8] QB_NORIN[9]
+   QB_NORIN[10] QB_NORIN[11] QTOUT[8] QTOUT[9] QTOUT[10] QTOUT[11] QT_IN[8]
+   QT_IN[9] QT_IN[10] QT_IN[11] QT_NORIN[8] QT_NORIN[9] QT_NORIN[10]
+   QT_NORIN[11] RASSISTT[0] RASSISTT[1] RB[8] RB[9] RB[10] RB[11] RT[8] RT[9]
+   RT[10] RT[11] SAEB SAED SAPRB SEL[8] SEL[9] SEL[10] SEL[11] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBP[8] VBP[9] VBP[10] VBP[11] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VSS[8] VSS[9] VSS[10] VSS[11]
+   VSS_WA[8] VSS_WA[9] VSS_WA[10] VSS_WA[11] WB[8] WB[9] WB[10] WB[11] WB_IN[8]
+   WB_IN[9] WB_IN[10] WB_IN[11] WT[8] WT[9] WT[10] WT[11] WT_IN[8] WT_IN[9]
+   WT_IN[10] WT_IN[11] SNPS_SP_HD_16Kx8_samp
X_samp_F0 BYPASS BYPASS_RET LCGTH LOG0 LOG1 QBOUT[12] QBOUT[13] QBOUT[14]
+   QBOUT[15] QB_IN[12] QB_IN[13] QB_IN[14] QB_IN[15] QB_NORIN[12] QB_NORIN[13]
+   QB_NORIN[14] QB_NORIN[15] QTOUT[12] QTOUT[13] QTOUT[14] QTOUT[15] QT_IN[12]
+   QT_IN[13] QT_IN[14] QT_IN[15] QT_NORIN[12] QT_NORIN[13] QT_NORIN[14]
+   QT_NORIN[15] RASSISTT[0] RASSISTT[1] RB[12] RB[13] RB[14] RB[15] RT[12]
+   RT[13] RT[14] RT[15] SAEB SAED SAPRB SEL[12] SEL[13] SEL[14] SEL[15] VBN[12]
+   VBN[13] VBN[14] VBN[15] VBP[12] VBP[13] VBP[14] VBP[15] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VSS[12] VSS[13]
+   VSS[14] VSS[15] VSS_WA[12] VSS_WA[13] VSS_WA[14] VSS_WA[15] WB[12] WB[13]
+   WB[14] WB[15] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WT[12] WT[13] WT[14]
+   WT[15] WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15] SNPS_SP_HD_16Kx8_samp
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_sac_lt BYPASS BYPASS_RET LCGTH LOG0 LOG1 PWDO QBOUT[0]
+       QBOUT[1] QBOUT[2] QBOUT[3] QBOUT[4] QBOUT[5] QBOUT[6] QBOUT[7] QBOUT[8]
+       QBOUT[9] QBOUT[10] QBOUT[11] QBOUT[12] QBOUT[13] QBOUT[14] QBOUT[15]
+       QB_IN[0] QB_IN[1] QB_IN[2] QB_IN[3] QB_IN[4] QB_IN[5] QB_IN[6] QB_IN[7]
+       QB_IN[8] QB_IN[9] QB_IN[10] QB_IN[11] QB_IN[12] QB_IN[13] QB_IN[14]
+       QB_IN[15] QB_NORIN[0] QB_NORIN[1] QB_NORIN[2] QB_NORIN[3] QB_NORIN[4]
+       QB_NORIN[5] QB_NORIN[6] QB_NORIN[7] QB_NORIN[8] QB_NORIN[9] QB_NORIN[10]
+       QB_NORIN[11] QB_NORIN[12] QB_NORIN[13] QB_NORIN[14] QB_NORIN[15]
+       QTOUT[0] QTOUT[1] QTOUT[2] QTOUT[3] QTOUT[4] QTOUT[5] QTOUT[6] QTOUT[7]
+       QTOUT[8] QTOUT[9] QTOUT[10] QTOUT[11] QTOUT[12] QTOUT[13] QTOUT[14]
+       QTOUT[15] QT_IN[0] QT_IN[1] QT_IN[2] QT_IN[3] QT_IN[4] QT_IN[5] QT_IN[6]
+       QT_IN[7] QT_IN[8] QT_IN[9] QT_IN[10] QT_IN[11] QT_IN[12] QT_IN[13]
+       QT_IN[14] QT_IN[15] QT_NORIN[0] QT_NORIN[1] QT_NORIN[2] QT_NORIN[3]
+       QT_NORIN[4] QT_NORIN[5] QT_NORIN[6] QT_NORIN[7] QT_NORIN[8] QT_NORIN[9]
+       QT_NORIN[10] QT_NORIN[11] QT_NORIN[12] QT_NORIN[13] QT_NORIN[14]
+       QT_NORIN[15] RASSISTT[0] RASSISTT[1] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5]
+       RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RT[0]
+       RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11]
+       RT[12] RT[13] RT[14] RT[15] SAEB SAED SAPRB SEL[0] SEL[1] SEL[2] SEL[3]
+       SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+       SEL[13] SEL[14] SEL[15] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+       VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15]
+       VBN[16] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8]
+       VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDP[0]
+       VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9]
+       VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+       VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+       VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+       VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+       VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6]
+       VSS_WA[7] VSS_WA[8] VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12]
+       VSS_WA[13] VSS_WA[14] VSS_WA[15] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5]
+       WB[6] WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15]
+       WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7]
+       WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14]
+       WB_IN[15] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9]
+       WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WT_IN[0] WT_IN[1] WT_IN[2]
+       WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10]
+       WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15]
X_mm16a05_u_hdsp_plus_capsac VDDP[0] VDDPI[0] VSS[0] VBP[0] VBN[0] SAED LOG0
+   LOG1 PWDO VEDGE SAEB mm16a05_u_hdsp_plus_capsac
X_sac_lt_seg1 BYPASS BYPASS_RET LCGTH LOG0 LOG1 QBOUT[0] QBOUT[1] QBOUT[2]
+   QBOUT[3] QBOUT[4] QBOUT[5] QBOUT[6] QBOUT[7] QBOUT[8] QBOUT[9] QBOUT[10]
+   QBOUT[11] QBOUT[12] QBOUT[13] QBOUT[14] QBOUT[15] QB_IN[0] QB_IN[1] QB_IN[2]
+   QB_IN[3] QB_IN[4] QB_IN[5] QB_IN[6] QB_IN[7] QB_IN[8] QB_IN[9] QB_IN[10]
+   QB_IN[11] QB_IN[12] QB_IN[13] QB_IN[14] QB_IN[15] QB_NORIN[0] QB_NORIN[1]
+   QB_NORIN[2] QB_NORIN[3] QB_NORIN[4] QB_NORIN[5] QB_NORIN[6] QB_NORIN[7]
+   QB_NORIN[8] QB_NORIN[9] QB_NORIN[10] QB_NORIN[11] QB_NORIN[12] QB_NORIN[13]
+   QB_NORIN[14] QB_NORIN[15] QTOUT[0] QTOUT[1] QTOUT[2] QTOUT[3] QTOUT[4]
+   QTOUT[5] QTOUT[6] QTOUT[7] QTOUT[8] QTOUT[9] QTOUT[10] QTOUT[11] QTOUT[12]
+   QTOUT[13] QTOUT[14] QTOUT[15] QT_IN[0] QT_IN[1] QT_IN[2] QT_IN[3] QT_IN[4]
+   QT_IN[5] QT_IN[6] QT_IN[7] QT_IN[8] QT_IN[9] QT_IN[10] QT_IN[11] QT_IN[12]
+   QT_IN[13] QT_IN[14] QT_IN[15] QT_NORIN[0] QT_NORIN[1] QT_NORIN[2]
+   QT_NORIN[3] QT_NORIN[4] QT_NORIN[5] QT_NORIN[6] QT_NORIN[7] QT_NORIN[8]
+   QT_NORIN[9] QT_NORIN[10] QT_NORIN[11] QT_NORIN[12] QT_NORIN[13] QT_NORIN[14]
+   QT_NORIN[15] RASSISTT[0] RASSISTT[1] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5]
+   RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RT[0]
+   RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12]
+   RT[13] RT[14] RT[15] SAEB SAED SAPRB SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14]
+   SEL[15] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6]
+   VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14]
+   VDDP[15] VDDP[16] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6]
+   VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+   VDDPI[15] VDDPI[16] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+   VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS_WA[0]
+   VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7]
+   VSS_WA[8] VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12] VSS_WA[13] VSS_WA[14]
+   VSS_WA[15] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9]
+   WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WB_IN[0] WB_IN[1] WB_IN[2]
+   WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10]
+   WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WT[0] WT[1] WT[2] WT[3]
+   WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14]
+   WT[15] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6]
+   WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14]
+   WT_IN[15] SNPS_SP_HD_16Kx8_sac_lt_seg1
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_sac_cen BYPASS BYP_VLOAD CENDP DEF_MODE ENLPGB FAST1B
+       FAST1_MODE FAST2_MODE FLOAT FLOATT FLOATT_PGM FLOAT_RET
+       FLOAT_RET_TIMER_PROG LBKADR[0] LBKADR[1] LBKADR[2] LCGTB LCGTHB LCGTHHV
+       LCGTHLV LCGTH_PCHG LDFTX LITESLP LLBKADRB[0] LLBKADRB[1] LLBKADRB[2]
+       LLBKADRT[0] LLBKADRT[1] LLBKADRT[2] LMATCH LMATCHB LMATCHB_I_BBK
+       LMATCHB_I_TBK LOG0 LOG1 LWEIB LWERD LWEWR LXADR[0] LXADR[1] LXADR[2]
+       LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+       PLBKADR[0] PLBKADR[1] PLBKADR[2] PLBKADRB PM[0] PM[1] PM[2] PM[3]
+       PRCKE_B PRCKE_T PRCLKB RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2]
+       RMT[3] RWLBHV RWLBLV RWLB_SAC SAEDL SAEDR SAET SAPRT T1T TEST_RNMB VBN
+       VBP VDDA VDDMINB VDDP VDDPI VSS WABUF[0] WABUF[1] WABUF[2]
+       WAPRCLKBUFB_RET WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]

*** Jumper Report ***
* Jumper: FLOAT_RET FLOAT_RET_TIMER_PROG
* Jumper: LBKADR[0] PLBKADR[0]
* Jumper: LCGTHHV LCGTHLV
* Jumper: LLBKADRB[0] PLBKADRB
* Jumper: LLBKADRB[1] PLBKADR[1]
* Jumper: LLBKADRB[2] PLBKADR[2]
* Jumper: LOG0 ENLPGB LBKADR[2] LDFTX
* Jumper: LOG1 FLOATT_PGM LMATCHB LMATCHB_I_BBK LMATCHB_I_TBK
* Jumper: RWLBHV RWLBLV
* Jumper: VDDA VDDP VDDPI

X_mm16a05_u_hdsp_plus_sactrl VDDA VDDMINB VDDP VDDPI VSS VBP VBN FAST1B LCGTB
+   LCGTHB LCGTHLV LCGTH_PCHG LLBKADRB[0] LLBKADRB[1] LLBKADRB[2] LLBKADRT[0]
+   LLBKADRT[1] LLBKADRT[2] LMATCH LWERD LWEWR PM[0] PM[1] PM[2] PM[3] PRCKE_B
+   PRCKE_T PRCLKB RWLBLV SAET SAPRT BYPASS BYP_VLOAD DEF_MODE FAST1_MODE
+   FAST2_MODE FLOAT FLOATT_PGM FLOAT_RET LOG0 LOG1 RBLRD RBLWA RBLWR RMT[0]
+   RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2]
+   WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] CENDP ENLPGB FLOATT
+   FLOAT_RET_TIMER_PROG LBKADR[0] LBKADR[1] LBKADR[2] LCGTHHV LDFTX LITESLP
+   LMATCHB LMATCHB_I_BBK LMATCHB_I_TBK LWEIB LXADR[0] LXADR[1] LXADR[2]
+   LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PLBKADR[0]
+   PLBKADR[1] PLBKADR[2] PLBKADRB RM3CNT RWLBHV SAEDL SAEDR WAPRCLKBUFB_RET
+   mm16a05_u_hdsp_plus_sactrl
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_sac_buf ARYSD ARYSD_BC1 ARYSD_BC2 BYPASS BYPASS_RET
+       LCGTH LCGTHB LCGTHB_IN LCGTHHV LOG0 LOG1 RASSIST[0] RASSIST[1]
+       RASSISTT[0] RASSISTT[1] SAEB SAED SAET SAPRB SAPRT VBN VBP VDDA VDDP
+       VDDPI VSS

*** Jumper Report ***
* Jumper: LCGTHB LCGTHB_IN
* Jumper: VDDA VDDP VDDPI

X_mm16a05_u_hdsp_plus_sacbuf VDDA VDDP VDDPI VSS VBP VBN LCGTH SAEB SAPRB ARYSD
+   ARYSD_BC1 ARYSD_BC2 BYPASS BYPASS_RET LOG0 LOG1 RASSIST[0] RASSIST[1]
+   RASSISTT[0] RASSISTT[1] SAED LCGTHB LCGTHB_IN LCGTHHV SAET SAPRT
+   mm16a05_u_hdsp_plus_sacbuf
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_sac_cnt ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1]
+       ARYSD_BC2[0] ARYSD_BC2[1] BYPASS[0] BYPASS[1] BYPASS_RET[0]
+       BYPASS_RET[1] BYP_VLOAD CENDP DEF_MODE ENLPGB FAST1B FAST1_MODE
+       FAST2_MODE FLOAT FLOATT FLOATT_PGM FLOAT_RET FLOAT_RET_TIMER_PROG
+       LBKADR0 LBKADR1 LCGTH[0] LCGTH[1] LCGTH_PCHG LDFTX LITESLP LLBKADRB[0]
+       LLBKADRB[1] LLBKADRB[2] LLBKADRT[0] LLBKADRT[1] LLBKADRT[2] LMATCH
+       LMATCHB LMATCHB_I_BBK LMATCHB_I_TBK LOG0 LOG1 LWEIB LWERD LWEWR LXADR[0]
+       LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+       LYADR[1] PLBKADR[0] PLBKADR[1] PLBKADR[2] PLBKADRB PM[0] PM[1] PM[2]
+       PM[3] PRCKE_B PRCKE_T PRCLKB RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3]
+       RASSISTTH[0] RASSISTTH[1] RASSISTTL[0] RASSISTTL[1] RBLRD RBLWA RBLWR
+       RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC SAEBL SAEBR SAEDL SAEDR
+       SAPRB[0] SAPRB[1] T1T TEST_RNMB VBN[0] VBN[1] VBN[2] VBP[0] VBP[1]
+       VBP[2] VDDA[0] VDDA[1] VDDA[2] VDDMINB VDDP[0] VDDP[1] VDDP[2] VDDPI[0]
+       VDDPI[1] VDDPI[2] VSS[0] VSS[1] VSS[2] WABUF[0] WABUF[1] WABUF[2]
+       WAPRCLKBUFB_RET WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]

*** Jumper Report ***
* Jumper: LCGTHB LCGTHB_IN[0]
* Jumper: VDDA[0] VDDP[0] VDDPI[0]

X_mm16a05_u_hdsp_plus_sacbuf_left VDDA[0] VDDP[0] VDDPI[0] VSS[0] VBP[0] VBN[0]
+   LCGTH[0] SAEBL SAPRB[0] ARYSD[0] ARYSD_BC1[0] ARYSD_BC2[0] BYPASS[0]
+   BYPASS_RET[0] LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTTL[0] RASSISTTL[1]
+   SAEDL LCGTHB LCGTHB LCGTHHV SAET SAPRT mm16a05_u_hdsp_plus_sacbuf
X_sac_cen BYPASS[1] BYP_VLOAD CENDP DEF_MODE ENLPGB FAST1B FAST1_MODE FAST2_MODE
+   FLOAT FLOATT FLOATT_PGM FLOAT_RET FLOAT_RET_TIMER_PROG LBKADR0 LBKADR1 LOG0
+   LCGTB LCGTHB LCGTHHV LCGTHHV LCGTH_PCHG LDFTX LITESLP LLBKADRB[0]
+   LLBKADRB[1] LLBKADRB[2] LLBKADRT[0] LLBKADRT[1] LLBKADRT[2] LMATCH LMATCHB
+   LMATCHB_I_BBK LMATCHB_I_TBK LOG0 LOG1 LWEIB LWERD LWEWR LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PLBKADR[0] PLBKADR[1] PLBKADR[2] PLBKADRB PM[0] PM[1] PM[2] PM[3] PRCKE_B
+   PRCKE_T PRCLKB RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLBHV
+   RWLBHV RWLB_SAC SAEDL SAEDR SAET SAPRT T1T TEST_RNMB VBN[1] VBP[1] VDDA[1]
+   VDDMINB VDDP[1] VDDPI[1] VSS[1] WABUF[0] WABUF[1] WABUF[2] WAPRCLKBUFB_RET
+   WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]
+   SNPS_SP_HD_16Kx8_sac_cen
X_sac_buf ARYSD[1] ARYSD_BC1[1] ARYSD_BC2[1] BYPASS[1] BYPASS_RET[1] LCGTH[1]
+   LCGTHB LCGTHB LCGTHHV LOG0 LOG1 RASSIST[2] RASSIST[3] RASSISTTH[0]
+   RASSISTTH[1] SAEBR SAEDR SAET SAPRB[1] SAPRT VBN[2] VBP[2] VDDA[2] VDDP[2]
+   VDDPI[2] VSS[2] SNPS_SP_HD_16Kx8_sac_buf
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_sac_rt BYPASS BYPASS_RET LCGTH LOG0 LOG1 PWDO QBOUT[0]
+       QBOUT[1] QBOUT[2] QBOUT[3] QBOUT[4] QBOUT[5] QBOUT[6] QBOUT[7] QBOUT[8]
+       QBOUT[9] QBOUT[10] QBOUT[11] QBOUT[12] QBOUT[13] QBOUT[14] QBOUT[15]
+       QB_IN[0] QB_IN[1] QB_IN[2] QB_IN[3] QB_IN[4] QB_IN[5] QB_IN[6] QB_IN[7]
+       QB_IN[8] QB_IN[9] QB_IN[10] QB_IN[11] QB_IN[12] QB_IN[13] QB_IN[14]
+       QB_IN[15] QB_NORIN[0] QB_NORIN[1] QB_NORIN[2] QB_NORIN[3] QB_NORIN[4]
+       QB_NORIN[5] QB_NORIN[6] QB_NORIN[7] QB_NORIN[8] QB_NORIN[9] QB_NORIN[10]
+       QB_NORIN[11] QB_NORIN[12] QB_NORIN[13] QB_NORIN[14] QB_NORIN[15]
+       QTOUT[0] QTOUT[1] QTOUT[2] QTOUT[3] QTOUT[4] QTOUT[5] QTOUT[6] QTOUT[7]
+       QTOUT[8] QTOUT[9] QTOUT[10] QTOUT[11] QTOUT[12] QTOUT[13] QTOUT[14]
+       QTOUT[15] QT_IN[0] QT_IN[1] QT_IN[2] QT_IN[3] QT_IN[4] QT_IN[5] QT_IN[6]
+       QT_IN[7] QT_IN[8] QT_IN[9] QT_IN[10] QT_IN[11] QT_IN[12] QT_IN[13]
+       QT_IN[14] QT_IN[15] QT_NORIN[0] QT_NORIN[1] QT_NORIN[2] QT_NORIN[3]
+       QT_NORIN[4] QT_NORIN[5] QT_NORIN[6] QT_NORIN[7] QT_NORIN[8] QT_NORIN[9]
+       QT_NORIN[10] QT_NORIN[11] QT_NORIN[12] QT_NORIN[13] QT_NORIN[14]
+       QT_NORIN[15] RASSISTT[0] RASSISTT[1] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5]
+       RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RT[0]
+       RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11]
+       RT[12] RT[13] RT[14] RT[15] SAEB SAED SAPRB SEL[0] SEL[1] SEL[2] SEL[3]
+       SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+       SEL[13] SEL[14] SEL[15] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+       VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15]
+       VBN[16] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8]
+       VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDP[0]
+       VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9]
+       VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+       VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+       VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+       VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+       VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6]
+       VSS_WA[7] VSS_WA[8] VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12]
+       VSS_WA[13] VSS_WA[14] VSS_WA[15] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5]
+       WB[6] WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15]
+       WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7]
+       WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14]
+       WB_IN[15] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9]
+       WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WT_IN[0] WT_IN[1] WT_IN[2]
+       WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10]
+       WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15]
X_sac_lt_seg1 BYPASS BYPASS_RET LCGTH LOG0 LOG1 QBOUT[0] QBOUT[1] QBOUT[2]
+   QBOUT[3] QBOUT[4] QBOUT[5] QBOUT[6] QBOUT[7] QBOUT[8] QBOUT[9] QBOUT[10]
+   QBOUT[11] QBOUT[12] QBOUT[13] QBOUT[14] QBOUT[15] QB_IN[0] QB_IN[1] QB_IN[2]
+   QB_IN[3] QB_IN[4] QB_IN[5] QB_IN[6] QB_IN[7] QB_IN[8] QB_IN[9] QB_IN[10]
+   QB_IN[11] QB_IN[12] QB_IN[13] QB_IN[14] QB_IN[15] QB_NORIN[0] QB_NORIN[1]
+   QB_NORIN[2] QB_NORIN[3] QB_NORIN[4] QB_NORIN[5] QB_NORIN[6] QB_NORIN[7]
+   QB_NORIN[8] QB_NORIN[9] QB_NORIN[10] QB_NORIN[11] QB_NORIN[12] QB_NORIN[13]
+   QB_NORIN[14] QB_NORIN[15] QTOUT[0] QTOUT[1] QTOUT[2] QTOUT[3] QTOUT[4]
+   QTOUT[5] QTOUT[6] QTOUT[7] QTOUT[8] QTOUT[9] QTOUT[10] QTOUT[11] QTOUT[12]
+   QTOUT[13] QTOUT[14] QTOUT[15] QT_IN[0] QT_IN[1] QT_IN[2] QT_IN[3] QT_IN[4]
+   QT_IN[5] QT_IN[6] QT_IN[7] QT_IN[8] QT_IN[9] QT_IN[10] QT_IN[11] QT_IN[12]
+   QT_IN[13] QT_IN[14] QT_IN[15] QT_NORIN[0] QT_NORIN[1] QT_NORIN[2]
+   QT_NORIN[3] QT_NORIN[4] QT_NORIN[5] QT_NORIN[6] QT_NORIN[7] QT_NORIN[8]
+   QT_NORIN[9] QT_NORIN[10] QT_NORIN[11] QT_NORIN[12] QT_NORIN[13] QT_NORIN[14]
+   QT_NORIN[15] RASSISTT[0] RASSISTT[1] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5]
+   RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RT[0]
+   RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12]
+   RT[13] RT[14] RT[15] SAEB SAED SAPRB SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14]
+   SEL[15] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBP[0] VBP[1] VBP[2]
+   VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+   VBP[13] VBP[14] VBP[15] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5]
+   VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14]
+   VDDP[15] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6]
+   VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+   VDDPI[15] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+   VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS_WA[0] VSS_WA[1]
+   VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7] VSS_WA[8]
+   VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12] VSS_WA[13] VSS_WA[14] VSS_WA[15]
+   WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11]
+   WB[12] WB[13] WB[14] WB[15] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4]
+   WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12]
+   WB_IN[13] WB_IN[14] WB_IN[15] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6]
+   WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WT_IN[0]
+   WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8]
+   WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15]
+   SNPS_SP_HD_16Kx8_sac_lt_seg1
X_mm16a05_u_hdsp_plus_capsac VDDP[16] VDDPI[16] VSS[16] VBP[16] VBN[16] SAED
+   LOG0 LOG1 PWDO VEDGE SAEB mm16a05_u_hdsp_plus_capsac
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_sac_row_2 ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1]
+       ARYSD_BC2[0] ARYSD_BC2[1] BYP_VLOAD CENDP DEF_MODE ENLPGB FAST1B
+       FAST1_MODE FAST2_MODE FLOAT FLOATT FLOATT_PGM FLOAT_RET
+       FLOAT_RET_TIMER_PROG LBKADR0 LBKADR1 LCGTH[0] LCGTH[1] LCGTH_PCHG LDFTX
+       LITESLP LLBKADRB[0] LLBKADRB[1] LLBKADRB[2] LLBKADRT[0] LLBKADRT[1]
+       LLBKADRT[2] LMATCH LMATCHB LMATCHB_I_BBK LMATCHB_I_TBK LOG0 LOG1 LWEIB
+       LWERD LWEWR LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+       LXADR[6] LXADR[7] LYADR[0] LYADR[1] PLBKADR[0] PLBKADR[1] PLBKADR[2]
+       PLBKADRB PM[0] PM[1] PM[2] PM[3] PRCKE_B PRCKE_T PRCLKB PWDO[0] PWDO[1]
+       QBOUT[0] QBOUT[1] QBOUT[2] QBOUT[3] QBOUT[4] QBOUT[5] QBOUT[6] QBOUT[7]
+       QBOUT[8] QBOUT[9] QBOUT[10] QBOUT[11] QBOUT[12] QBOUT[13] QBOUT[14]
+       QBOUT[15] QBOUT[16] QBOUT[17] QBOUT[18] QBOUT[19] QBOUT[20] QBOUT[21]
+       QBOUT[22] QBOUT[23] QBOUT[24] QBOUT[25] QBOUT[26] QBOUT[27] QBOUT[28]
+       QBOUT[29] QBOUT[30] QBOUT[31] QB_IN[0] QB_IN[1] QB_IN[2] QB_IN[3]
+       QB_IN[4] QB_IN[5] QB_IN[6] QB_IN[7] QB_IN[8] QB_IN[9] QB_IN[10]
+       QB_IN[11] QB_IN[12] QB_IN[13] QB_IN[14] QB_IN[15] QB_IN[16] QB_IN[17]
+       QB_IN[18] QB_IN[19] QB_IN[20] QB_IN[21] QB_IN[22] QB_IN[23] QB_IN[24]
+       QB_IN[25] QB_IN[26] QB_IN[27] QB_IN[28] QB_IN[29] QB_IN[30] QB_IN[31]
+       QB_NORIN[0] QB_NORIN[1] QB_NORIN[2] QB_NORIN[3] QB_NORIN[4] QB_NORIN[5]
+       QB_NORIN[6] QB_NORIN[7] QB_NORIN[8] QB_NORIN[9] QB_NORIN[10]
+       QB_NORIN[11] QB_NORIN[12] QB_NORIN[13] QB_NORIN[14] QB_NORIN[15]
+       QB_NORIN[16] QB_NORIN[17] QB_NORIN[18] QB_NORIN[19] QB_NORIN[20]
+       QB_NORIN[21] QB_NORIN[22] QB_NORIN[23] QB_NORIN[24] QB_NORIN[25]
+       QB_NORIN[26] QB_NORIN[27] QB_NORIN[28] QB_NORIN[29] QB_NORIN[30]
+       QB_NORIN[31] QTOUT[0] QTOUT[1] QTOUT[2] QTOUT[3] QTOUT[4] QTOUT[5]
+       QTOUT[6] QTOUT[7] QTOUT[8] QTOUT[9] QTOUT[10] QTOUT[11] QTOUT[12]
+       QTOUT[13] QTOUT[14] QTOUT[15] QTOUT[16] QTOUT[17] QTOUT[18] QTOUT[19]
+       QTOUT[20] QTOUT[21] QTOUT[22] QTOUT[23] QTOUT[24] QTOUT[25] QTOUT[26]
+       QTOUT[27] QTOUT[28] QTOUT[29] QTOUT[30] QTOUT[31] QT_IN[0] QT_IN[1]
+       QT_IN[2] QT_IN[3] QT_IN[4] QT_IN[5] QT_IN[6] QT_IN[7] QT_IN[8] QT_IN[9]
+       QT_IN[10] QT_IN[11] QT_IN[12] QT_IN[13] QT_IN[14] QT_IN[15] QT_IN[16]
+       QT_IN[17] QT_IN[18] QT_IN[19] QT_IN[20] QT_IN[21] QT_IN[22] QT_IN[23]
+       QT_IN[24] QT_IN[25] QT_IN[26] QT_IN[27] QT_IN[28] QT_IN[29] QT_IN[30]
+       QT_IN[31] QT_NORIN[0] QT_NORIN[1] QT_NORIN[2] QT_NORIN[3] QT_NORIN[4]
+       QT_NORIN[5] QT_NORIN[6] QT_NORIN[7] QT_NORIN[8] QT_NORIN[9] QT_NORIN[10]
+       QT_NORIN[11] QT_NORIN[12] QT_NORIN[13] QT_NORIN[14] QT_NORIN[15]
+       QT_NORIN[16] QT_NORIN[17] QT_NORIN[18] QT_NORIN[19] QT_NORIN[20]
+       QT_NORIN[21] QT_NORIN[22] QT_NORIN[23] QT_NORIN[24] QT_NORIN[25]
+       QT_NORIN[26] QT_NORIN[27] QT_NORIN[28] QT_NORIN[29] QT_NORIN[30]
+       QT_NORIN[31] RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RB[0] RB[1]
+       RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12]
+       RB[13] RB[14] RB[15] RB[16] RB[17] RB[18] RB[19] RB[20] RB[21] RB[22]
+       RB[23] RB[24] RB[25] RB[26] RB[27] RB[28] RB[29] RB[30] RB[31] RBLRD
+       RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RT[0] RT[1] RT[2] RT[3]
+       RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14]
+       RT[15] RT[16] RT[17] RT[18] RT[19] RT[20] RT[21] RT[22] RT[23] RT[24]
+       RT[25] RT[26] RT[27] RT[28] RT[29] RT[30] RT[31] RWLB_SAC SEL[0] SEL[1]
+       SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+       SEL[12] SEL[13] SEL[14] SEL[15] SEL[16] SEL[17] SEL[18] SEL[19] SEL[20]
+       SEL[21] SEL[22] SEL[23] SEL[24] SEL[25] SEL[26] SEL[27] SEL[28] SEL[29]
+       SEL[30] SEL[31] T1T TEST_RNMB VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5]
+       VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14]
+       VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23]
+       VBN[24] VBN[25] VBN[26] VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32]
+       VBN[33] VBN[34] VBN[35] VBN[36] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4]
+       VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+       VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+       VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+       VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VDDA[0] VDDA[1] VDDA[2] VDDMINB
+       VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8]
+       VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16]
+       VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24]
+       VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32]
+       VDDP[33] VDDP[34] VDDP[35] VDDP[36] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+       VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+       VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17]
+       VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24]
+       VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31]
+       VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36] VEDGE[0] VEDGE[1]
+       VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9]
+       VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18]
+       VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27]
+       VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34] VSS[35] VSS[36]
+       VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6]
+       VSS_WA[7] VSS_WA[8] VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12]
+       VSS_WA[13] VSS_WA[14] VSS_WA[15] VSS_WA[16] VSS_WA[17] VSS_WA[18]
+       VSS_WA[19] VSS_WA[20] VSS_WA[21] VSS_WA[22] VSS_WA[23] VSS_WA[24]
+       VSS_WA[25] VSS_WA[26] VSS_WA[27] VSS_WA[28] VSS_WA[29] VSS_WA[30]
+       VSS_WA[31] WABUF[0] WABUF[1] WABUF[2] WAPRCLKBUFB_RET WB[0] WB[1] WB[2]
+       WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13]
+       WB[14] WB[15] WB[16] WB[17] WB[18] WB[19] WB[20] WB[21] WB[22] WB[23]
+       WB[24] WB[25] WB[26] WB[27] WB[28] WB[29] WB[30] WB[31] WB_IN[0]
+       WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8]
+       WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15]
+       WB_IN[16] WB_IN[17] WB_IN[18] WB_IN[19] WB_IN[20] WB_IN[21] WB_IN[22]
+       WB_IN[23] WB_IN[24] WB_IN[25] WB_IN[26] WB_IN[27] WB_IN[28] WB_IN[29]
+       WB_IN[30] WB_IN[31] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+       WPBUF[2] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9]
+       WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WT[16] WT[17] WT[18] WT[19]
+       WT[20] WT[21] WT[22] WT[23] WT[24] WT[25] WT[26] WT[27] WT[28] WT[29]
+       WT[30] WT[31] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5]
+       WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12]
+       WT_IN[13] WT_IN[14] WT_IN[15] WT_IN[16] WT_IN[17] WT_IN[18] WT_IN[19]
+       WT_IN[20] WT_IN[21] WT_IN[22] WT_IN[23] WT_IN[24] WT_IN[25] WT_IN[26]
+       WT_IN[27] WT_IN[28] WT_IN[29] WT_IN[30] WT_IN[31]
X_sac_lt BYPASS[0] BYPASS_RET[0] LCGTH[0] LOG0 LOG1 PWDO[0] QBOUT[0] QBOUT[1]
+   QBOUT[2] QBOUT[3] QBOUT[4] QBOUT[5] QBOUT[6] QBOUT[7] QBOUT[8] QBOUT[9]
+   QBOUT[10] QBOUT[11] QBOUT[12] QBOUT[13] QBOUT[14] QBOUT[15] QB_IN[0]
+   QB_IN[1] QB_IN[2] QB_IN[3] QB_IN[4] QB_IN[5] QB_IN[6] QB_IN[7] QB_IN[8]
+   QB_IN[9] QB_IN[10] QB_IN[11] QB_IN[12] QB_IN[13] QB_IN[14] QB_IN[15]
+   QB_NORIN[0] QB_NORIN[1] QB_NORIN[2] QB_NORIN[3] QB_NORIN[4] QB_NORIN[5]
+   QB_NORIN[6] QB_NORIN[7] QB_NORIN[8] QB_NORIN[9] QB_NORIN[10] QB_NORIN[11]
+   QB_NORIN[12] QB_NORIN[13] QB_NORIN[14] QB_NORIN[15] QTOUT[0] QTOUT[1]
+   QTOUT[2] QTOUT[3] QTOUT[4] QTOUT[5] QTOUT[6] QTOUT[7] QTOUT[8] QTOUT[9]
+   QTOUT[10] QTOUT[11] QTOUT[12] QTOUT[13] QTOUT[14] QTOUT[15] QT_IN[0]
+   QT_IN[1] QT_IN[2] QT_IN[3] QT_IN[4] QT_IN[5] QT_IN[6] QT_IN[7] QT_IN[8]
+   QT_IN[9] QT_IN[10] QT_IN[11] QT_IN[12] QT_IN[13] QT_IN[14] QT_IN[15]
+   QT_NORIN[0] QT_NORIN[1] QT_NORIN[2] QT_NORIN[3] QT_NORIN[4] QT_NORIN[5]
+   QT_NORIN[6] QT_NORIN[7] QT_NORIN[8] QT_NORIN[9] QT_NORIN[10] QT_NORIN[11]
+   QT_NORIN[12] QT_NORIN[13] QT_NORIN[14] QT_NORIN[15] RASSISTTL[0]
+   RASSISTTL[1] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9]
+   RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RT[0] RT[1] RT[2] RT[3] RT[4]
+   RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15]
+   SAEBL SAEDL SAPRB[0] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7]
+   SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] VBN[0] VBN[1]
+   VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11]
+   VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4]
+   VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14]
+   VBP[15] VBP[16] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6]
+   VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14]
+   VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5]
+   VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13]
+   VDDPI[14] VDDPI[15] VDDPI[16] VEDGE[0] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4]
+   VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14]
+   VSS[15] VSS[16] VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5]
+   VSS_WA[6] VSS_WA[7] VSS_WA[8] VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12]
+   VSS_WA[13] VSS_WA[14] VSS_WA[15] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6]
+   WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WB_IN[0]
+   WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8]
+   WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WT[0]
+   WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12]
+   WT[13] WT[14] WT[15] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5]
+   WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13]
+   WT_IN[14] WT_IN[15] SNPS_SP_HD_16Kx8_sac_lt
X_sac_cnt ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1]
+   BYPASS[0] BYPASS[1] BYPASS_RET[0] BYPASS_RET[1] BYP_VLOAD CENDP DEF_MODE
+   ENLPGB FAST1B FAST1_MODE FAST2_MODE FLOAT FLOATT FLOATT_PGM FLOAT_RET
+   FLOAT_RET_TIMER_PROG LBKADR0 LBKADR1 LCGTH[0] LCGTH[1] LCGTH_PCHG LDFTX
+   LITESLP LLBKADRB[0] LLBKADRB[1] LLBKADRB[2] LLBKADRT[0] LLBKADRT[1]
+   LLBKADRT[2] LMATCH LMATCHB LMATCHB_I_BBK LMATCHB_I_TBK LOG0 LOG1 LWEIB LWERD
+   LWEWR LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6]
+   LXADR[7] LYADR[0] LYADR[1] PLBKADR[0] PLBKADR[1] PLBKADR[2] PLBKADRB PM[0]
+   PM[1] PM[2] PM[3] PRCKE_B PRCKE_T PRCLKB RASSIST[0] RASSIST[1] RASSIST[2]
+   RASSIST[3] RASSISTTH[0] RASSISTTH[1] RASSISTTL[0] RASSISTTL[1] RBLRD RBLWA
+   RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC SAEBL SAEBR SAEDL SAEDR
+   SAPRB[0] SAPRB[1] T1T TEST_RNMB VBN[17] VBN[18] VBN[19] VBP[17] VBP[18]
+   VBP[19] VDDA[0] VDDA[1] VDDA[2] VDDMINB VDDP[17] VDDP[18] VDDP[19] VDDPI[17]
+   VDDPI[18] VDDPI[19] VSS[17] VSS[18] VSS[19] WABUF[0] WABUF[1] WABUF[2]
+   WAPRCLKBUFB_RET WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]
+   SNPS_SP_HD_16Kx8_sac_cnt
X_sac_rt BYPASS[1] BYPASS_RET[1] LCGTH[1] LOG0 LOG1 PWDO[1] QBOUT[16] QBOUT[17]
+   QBOUT[18] QBOUT[19] QBOUT[20] QBOUT[21] QBOUT[22] QBOUT[23] QBOUT[24]
+   QBOUT[25] QBOUT[26] QBOUT[27] QBOUT[28] QBOUT[29] QBOUT[30] QBOUT[31]
+   QB_IN[16] QB_IN[17] QB_IN[18] QB_IN[19] QB_IN[20] QB_IN[21] QB_IN[22]
+   QB_IN[23] QB_IN[24] QB_IN[25] QB_IN[26] QB_IN[27] QB_IN[28] QB_IN[29]
+   QB_IN[30] QB_IN[31] QB_NORIN[16] QB_NORIN[17] QB_NORIN[18] QB_NORIN[19]
+   QB_NORIN[20] QB_NORIN[21] QB_NORIN[22] QB_NORIN[23] QB_NORIN[24]
+   QB_NORIN[25] QB_NORIN[26] QB_NORIN[27] QB_NORIN[28] QB_NORIN[29]
+   QB_NORIN[30] QB_NORIN[31] QTOUT[16] QTOUT[17] QTOUT[18] QTOUT[19] QTOUT[20]
+   QTOUT[21] QTOUT[22] QTOUT[23] QTOUT[24] QTOUT[25] QTOUT[26] QTOUT[27]
+   QTOUT[28] QTOUT[29] QTOUT[30] QTOUT[31] QT_IN[16] QT_IN[17] QT_IN[18]
+   QT_IN[19] QT_IN[20] QT_IN[21] QT_IN[22] QT_IN[23] QT_IN[24] QT_IN[25]
+   QT_IN[26] QT_IN[27] QT_IN[28] QT_IN[29] QT_IN[30] QT_IN[31] QT_NORIN[16]
+   QT_NORIN[17] QT_NORIN[18] QT_NORIN[19] QT_NORIN[20] QT_NORIN[21]
+   QT_NORIN[22] QT_NORIN[23] QT_NORIN[24] QT_NORIN[25] QT_NORIN[26]
+   QT_NORIN[27] QT_NORIN[28] QT_NORIN[29] QT_NORIN[30] QT_NORIN[31]
+   RASSISTTH[0] RASSISTTH[1] RB[16] RB[17] RB[18] RB[19] RB[20] RB[21] RB[22]
+   RB[23] RB[24] RB[25] RB[26] RB[27] RB[28] RB[29] RB[30] RB[31] RT[16] RT[17]
+   RT[18] RT[19] RT[20] RT[21] RT[22] RT[23] RT[24] RT[25] RT[26] RT[27] RT[28]
+   RT[29] RT[30] RT[31] SAEBR SAEDR SAPRB[1] SEL[16] SEL[17] SEL[18] SEL[19]
+   SEL[20] SEL[21] SEL[22] SEL[23] SEL[24] SEL[25] SEL[26] SEL[27] SEL[28]
+   SEL[29] SEL[30] SEL[31] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25]
+   VBN[26] VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34]
+   VBN[35] VBN[36] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25] VBP[26]
+   VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32] VBP[33] VBP[34] VBP[35]
+   VBP[36] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+   VDDP[35] VDDP[36] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24]
+   VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31]
+   VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36] VEDGE[1] VSS[20] VSS[21]
+   VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28] VSS[29] VSS[30]
+   VSS[31] VSS[32] VSS[33] VSS[34] VSS[35] VSS[36] VSS_WA[16] VSS_WA[17]
+   VSS_WA[18] VSS_WA[19] VSS_WA[20] VSS_WA[21] VSS_WA[22] VSS_WA[23] VSS_WA[24]
+   VSS_WA[25] VSS_WA[26] VSS_WA[27] VSS_WA[28] VSS_WA[29] VSS_WA[30] VSS_WA[31]
+   WB[16] WB[17] WB[18] WB[19] WB[20] WB[21] WB[22] WB[23] WB[24] WB[25] WB[26]
+   WB[27] WB[28] WB[29] WB[30] WB[31] WB_IN[16] WB_IN[17] WB_IN[18] WB_IN[19]
+   WB_IN[20] WB_IN[21] WB_IN[22] WB_IN[23] WB_IN[24] WB_IN[25] WB_IN[26]
+   WB_IN[27] WB_IN[28] WB_IN[29] WB_IN[30] WB_IN[31] WT[16] WT[17] WT[18]
+   WT[19] WT[20] WT[21] WT[22] WT[23] WT[24] WT[25] WT[26] WT[27] WT[28] WT[29]
+   WT[30] WT[31] WT_IN[16] WT_IN[17] WT_IN[18] WT_IN[19] WT_IN[20] WT_IN[21]
+   WT_IN[22] WT_IN[23] WT_IN[24] WT_IN[25] WT_IN[26] WT_IN[27] WT_IN[28]
+   WT_IN[29] WT_IN[30] WT_IN[31] SNPS_SP_HD_16Kx8_sac_rt
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_mux_cnt_1 ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1]
+       ARYSD_BC2[0] ARYSD_BC2[1] BOTEDGE[0] BOTEDGE[1] BYP_VLOAD CENDP CKPRCHH
+       CKPRCHL DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR0
+       LBKADR1 LCGTH[0] LCGTH[1] LCGTH_PCHG LDFTX LITESLP LMATCH LMATCHB LOG0
+       LOG1 LWEIB LWERD LWEWR LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+       LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3]
+       PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5]
+       PCB[6] PCB[7] PM[0] PM[1] PM[2] PM[3] PO[0] PO[1] PRCHRDBH[0]
+       PRCHRDBH[1] PRCHRDBH[2] PRCHRDBH[3] PRCHRDBL[0] PRCHRDBL[1] PRCHRDBL[2]
+       PRCHRDBL[3] PRCHWRBH[0] PRCHWRBH[1] PRCHWRBH[2] PRCHWRBH[3] PRCHWRBL[0]
+       PRCHWRBL[1] PRCHWRBL[2] PRCHWRBL[3] PRCKE_T RASSIST[0] RASSIST[1]
+       RASSIST[2] RASSIST[3] RASSISTBH[0] RASSISTBH[1] RASSISTBL[0]
+       RASSISTBL[1] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3]
+       RWLB_SAC T1T TEST_RNMB VBA[0] VBA[1] VBN[0] VBN[1] VBN[2] VBP[0] VBP[1]
+       VBP[2] VDDA[0] VDDA[1] VDDA[2] VDDMINB VDDP[0] VDDP[1] VDDP[2] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDWL[0] VDDWL[1] VSS[0] VSS[1] VSS[2] VSSC_WL_L
+       VSSC_WL_R WABUF[0] WABUF[1] WABUF[2] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+       WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]

*** Jumper Report ***
* Jumper: CLK_WLBH CLK_WLBL
* Jumper: LOG1 LMATCHB
* Jumper: PRCHWR[0] PRCHWRH[0]
* Jumper: PRCHWR[1] PRCHWRH[1]
* Jumper: PRCHWR[2] PRCHWRH[2]
* Jumper: PRCHWR[3] PRCHWRH[3]
* Jumper: VDDA[0] VDDP[0] VDDPI[0]
* Jumper: VDDA[1] VDDP[1] VDDPI[1]
* Jumper: VDDA[2] VDDP[2] VDDPI[2]
* Jumper: XPRBH[0] XPRBL[0]
* Jumper: XPRBH[1] XPRBL[1]
* Jumper: XPRBH[2] XPRBL[2]
* Jumper: XPRBH[3] XPRBL[3]

X_mm16a05_u_hdsp_plus_lcenbuf_left VDDA[0] VDDP[0] VDDPI[0] VDDWL[0] VSS[0]
+   VBP[0] VBN[0] CKPRCHL LCGTHB[0] PRCHRDBL[0] PRCHRDBL[1] PRCHRDBL[2]
+   PRCHRDBL[3] PRCHWRBL[0] PRCHWRBL[1] PRCHWRBL[2] PRCHWRBL[3] RASSISTBL[0]
+   RASSISTBL[1] ARYSD[0] ARYSD_BC1[0] ARYSD_BC2[0] BOTEDGE[0] PO[0] VBA[0]
+   CKPRCHB LCGTH[0] LOG0 LOG1 PRCHRD[0] PRCHRD[1] PRCHRD[2] PRCHRD[3] PRCHWR[0]
+   PRCHWR[1] PRCHWR[2] PRCHWR[3] RASSIST[0] RASSIST[1]
+   mm16a05_u_hdsp_plus_lcenbuf
X_mm16a05_u_hdsp_plus_lcen VDDA[1] VDDMINB VDDP[1] VDDPI[1] VSS[1] VSSC_WL_L
+   VSSC_WL_R VBP[1] VBN[1] CKPRCHB LMATCH PBB[0] PBB[1] PBB[2] PBB[3] PBB[4]
+   PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7]
+   PRCHRD[0] PRCHRD[1] PRCHRD[2] PRCHRD[3] PRCHWR[0] PRCHWR[1] PRCHWR[2]
+   PRCHWR[3] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] BYP_VLOAD CENDP CLK_WLBH
+   CLK_WLBH DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LDFTX LITESLP
+   LOG0 LOG1 LWEIB LWERD LWEWR PRCHWR[0] PRCHWR[1] PRCHWR[2] PRCHWR[3] RBLRD
+   RBLWA RBLWR RWLB_SAC WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3]
+   WPBUF[0] WPBUF[1] WPBUF[2] XPRBH[0] XPRBH[1] XPRBH[2] XPRBH[3] XPRBH[0]
+   XPRBH[1] XPRBH[2] XPRBH[3] LBKADR0 LBKADR1 LBKADR LCGTHB[1] LCGTH_PCHG
+   LMATCHB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6]
+   LXADR[7] LYADR[0] LYADR[1] PM[0] PM[1] PM[2] PM[3] PRCKE_T RM3CNT RMT[0]
+   RMT[1] RMT[2] RMT[3] T1T TEST_RNMB mm16a05_u_hdsp_plus_lcen
X_mm16a05_u_hdsp_plus_lcenbuf VDDA[2] VDDP[2] VDDPI[2] VDDWL[1] VSS[2] VBP[2]
+   VBN[2] CKPRCHH LCGTHB[1] PRCHRDBH[0] PRCHRDBH[1] PRCHRDBH[2] PRCHRDBH[3]
+   PRCHWRBH[0] PRCHWRBH[1] PRCHWRBH[2] PRCHWRBH[3] RASSISTBH[0] RASSISTBH[1]
+   ARYSD[1] ARYSD_BC1[1] ARYSD_BC2[1] BOTEDGE[1] PO[1] VBA[1] CKPRCHB LCGTH[1]
+   LOG0 LOG1 PRCHRD[0] PRCHRD[1] PRCHRD[2] PRCHRD[3] PRCHWR[0] PRCHWR[1]
+   PRCHWR[2] PRCHWR[3] RASSIST[2] RASSIST[3] mm16a05_u_hdsp_plus_lcenbuf
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_mux_row_2 ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1]
+       ARYSD_BC2[0] ARYSD_BC2[1] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+       BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+       BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+       BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BB[64] BB[65] BB[66]
+       BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75] BB[76]
+       BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83] BB[84] BB[85] BB[86]
+       BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95] BB[96]
+       BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103] BB[104] BB[105]
+       BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BB[112] BB[113] BB[114]
+       BB[115] BB[116] BB[117] BB[118] BB[119] BB[120] BB[121] BB[122] BB[123]
+       BB[124] BB[125] BB[126] BB[127] BOTEDGE[0] BOTEDGE[1] BOTEDGE[2]
+       BOTEDGE[3] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9]
+       BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19]
+       BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28] BT[29]
+       BT[30] BT[31] BT[32] BT[33] BT[34] BT[35] BT[36] BT[37] BT[38] BT[39]
+       BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47] BT[48] BT[49]
+       BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57] BT[58] BT[59]
+       BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68] BT[69]
+       BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79]
+       BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89]
+       BT[90] BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99]
+       BT[100] BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108]
+       BT[109] BT[110] BT[111] BT[112] BT[113] BT[114] BT[115] BT[116] BT[117]
+       BT[118] BT[119] BT[120] BT[121] BT[122] BT[123] BT[124] BT[125] BT[126]
+       BT[127] BYP_VLOAD CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT
+       FLOAT_RET LBKADR0 LBKADR1 LCGTH[0] LCGTH[1] LCGTH_PCHG LDFTX LITESLP
+       LMATCH LMATCHB LOG0 LOG1 LWEIB LWERD LWEWR LXADR[0] LXADR[1] LXADR[2]
+       LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0]
+       PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+       PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] PGIOI[0] PGIOI[1] PM[0] PM[1] PM[2]
+       PM[3] PRCKE_T QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8]
+       QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QB[16] QB[17] QB[18]
+       QB[19] QB[20] QB[21] QB[22] QB[23] QB[24] QB[25] QB[26] QB[27] QB[28]
+       QB[29] QB[30] QB[31] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+       QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17]
+       QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27]
+       QT[28] QT[29] QT[30] QT[31] RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3]
+       RASSISTBH[0] RASSISTBH[1] RASSISTBL[0] RASSISTBL[1] RB[0] RB[1] RB[2]
+       RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13]
+       RB[14] RB[15] RB[16] RB[17] RB[18] RB[19] RB[20] RB[21] RB[22] RB[23]
+       RB[24] RB[25] RB[26] RB[27] RB[28] RB[29] RB[30] RB[31] RBLRD RBLWA
+       RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RT[0] RT[1] RT[2] RT[3] RT[4]
+       RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15]
+       RT[16] RT[17] RT[18] RT[19] RT[20] RT[21] RT[22] RT[23] RT[24] RT[25]
+       RT[26] RT[27] RT[28] RT[29] RT[30] RT[31] RWLB_SAC SEL[0] SEL[1] SEL[2]
+       SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+       SEL[13] SEL[14] SEL[15] SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21]
+       SEL[22] SEL[23] SEL[24] SEL[25] SEL[26] SEL[27] SEL[28] SEL[29] SEL[30]
+       SEL[31] T1T TEST_RNMB VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+       VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+       VBA[16] VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23] VBA[24]
+       VBA[25] VBA[26] VBA[27] VBA[28] VBA[29] VBA[30] VBA[31] VBA[32] VBA[33]
+       VBA[34] VBA[35] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7]
+       VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+       VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25]
+       VBN[26] VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34]
+       VBN[35] VBN[36] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7]
+       VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+       VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+       VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32] VBP[33] VBP[34]
+       VBP[35] VBP[36] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6]
+       VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+       VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22]
+       VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30]
+       VDDA[31] VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDAIL1 VDDAIR1
+       VDDMINB VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7]
+       VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15]
+       VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23]
+       VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31]
+       VDDP[32] VDDP[33] VDDP[34] VDDP[35] VDDP[36] VDDPI[0] VDDPI[1] VDDPI[2]
+       VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+       VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17]
+       VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24]
+       VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31]
+       VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36] VDDWL[0] VDDWL[1]
+       VEDGE[0] VEDGE[1] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6]
+       VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15]
+       VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24]
+       VSS[25] VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33]
+       VSS[34] VSS[35] VSS[36] VSSC_WL_L VSSC_WL_R WABUF[0] WABUF[1] WABUF[2]
+       WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10]
+       WB[11] WB[12] WB[13] WB[14] WB[15] WB[16] WB[17] WB[18] WB[19] WB[20]
+       WB[21] WB[22] WB[23] WB[24] WB[25] WB[26] WB[27] WB[28] WB[29] WB[30]
+       WB[31] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8]
+       WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17]
+       WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26]
+       WBI[27] WBI[28] WBI[29] WBI[30] WBI[31] WCLKB[0] WCLKB[1] WCLKB[2]
+       WCLKB[3] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT[0]
+       WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11]
+       WT[12] WT[13] WT[14] WT[15] WT[16] WT[17] WT[18] WT[19] WT[20] WT[21]
+       WT[22] WT[23] WT[24] WT[25] WT[26] WT[27] WT[28] WT[29] WT[30] WT[31]
+       WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9]
+       WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18]
+       WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27]
+       WTI[28] WTI[29] WTI[30] WTI[31]
X_mux_lt BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BOTEDGE[0]
+   BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11]
+   BT[12] BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22]
+   BT[23] BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33]
+   BT[34] BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44]
+   BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55]
+   BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] CKPRCHL LOG0 LOG1
+   PGIOI[0] PO[0] POWINT[0] POWINT[1] PRCHRDBL[0] PRCHRDBL[1] PRCHRDBL[2]
+   PRCHRDBL[3] PRCHWRBL[0] PRCHWRBL[1] PRCHWRBL[2] PRCHWRBL[3] QB[0] QB[1]
+   QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13]
+   QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9]
+   QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] RB[0] RB[1] RB[2] RB[3] RB[4]
+   RB[5] RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15]
+   RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11]
+   RT[12] RT[13] RT[14] RT[15] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+   SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] VBA[0]
+   VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10]
+   VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16] VBN[0] VBN[1] VBN[2] VBN[3]
+   VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13]
+   VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+   VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+   VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8]
+   VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16]
+   VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7]
+   VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15]
+   VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6]
+   VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+   VDDPI[15] VDDPI[16] VEDGE[0] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+   VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15]
+   VSS[16] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10]
+   WB[11] WB[12] WB[13] WB[14] WB[15] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11]
+   WT[12] WT[13] WT[14] WT[15] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_mux_lt
X_mux_cnt ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1]
+   BOTEDGE[1] BOTEDGE[2] BYP_VLOAD CENDP CKPRCHH CKPRCHL DEF_MODE FAST1_MODE
+   FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR0 LBKADR1 LCGTH[0] LCGTH[1]
+   LCGTH_PCHG LDFTX LITESLP LMATCH LMATCHB LOG0 LOG1 LWEIB LWERD LWEWR LXADR[0]
+   LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+   LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0]
+   PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] PM[0] PM[1] PM[2] PM[3]
+   PO[0] PO[1] PRCHRDBH[0] PRCHRDBH[1] PRCHRDBH[2] PRCHRDBH[3] PRCHRDBL[0]
+   PRCHRDBL[1] PRCHRDBL[2] PRCHRDBL[3] PRCHWRBH[0] PRCHWRBH[1] PRCHWRBH[2]
+   PRCHWRBH[3] PRCHWRBL[0] PRCHWRBL[1] PRCHWRBL[2] PRCHWRBL[3] PRCKE_T
+   RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RASSISTBH[0] RASSISTBH[1]
+   RASSISTBL[0] RASSISTBL[1] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2]
+   RMT[3] RWLB_SAC T1T TEST_RNMB VBA[17] VBA[18] VBN[17] VBN[18] VBN[19]
+   VBP[17] VBP[18] VBP[19] VDDA[17] VDDA[18] VDDA[19] VDDMINB VDDP[17] VDDP[18]
+   VDDP[19] VDDPI[17] VDDPI[18] VDDPI[19] VDDWL[0] VDDWL[1] VSS[17] VSS[18]
+   VSS[19] VSSC_WL_L VSSC_WL_R WABUF[0] WABUF[1] WABUF[2] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]
+   SNPS_SP_HD_16Kx8_mux_cnt_1
X_mux_rt BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73]
+   BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83] BB[84]
+   BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95]
+   BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103] BB[104] BB[105]
+   BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BB[112] BB[113] BB[114]
+   BB[115] BB[116] BB[117] BB[118] BB[119] BB[120] BB[121] BB[122] BB[123]
+   BB[124] BB[125] BB[126] BB[127] BOTEDGE[3] BT[64] BT[65] BT[66] BT[67]
+   BT[68] BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78]
+   BT[79] BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89]
+   BT[90] BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99]
+   BT[100] BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108]
+   BT[109] BT[110] BT[111] BT[112] BT[113] BT[114] BT[115] BT[116] BT[117]
+   BT[118] BT[119] BT[120] BT[121] BT[122] BT[123] BT[124] BT[125] BT[126]
+   BT[127] CKPRCHH LOG0 LOG1 PGIOI[1] PO[1] POWINT[2] POWINT[3] PRCHRDBH[0]
+   PRCHRDBH[1] PRCHRDBH[2] PRCHRDBH[3] PRCHWRBH[0] PRCHWRBH[1] PRCHWRBH[2]
+   PRCHWRBH[3] QB[16] QB[17] QB[18] QB[19] QB[20] QB[21] QB[22] QB[23] QB[24]
+   QB[25] QB[26] QB[27] QB[28] QB[29] QB[30] QB[31] QT[16] QT[17] QT[18] QT[19]
+   QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28] QT[29] QT[30]
+   QT[31] RB[16] RB[17] RB[18] RB[19] RB[20] RB[21] RB[22] RB[23] RB[24] RB[25]
+   RB[26] RB[27] RB[28] RB[29] RB[30] RB[31] RT[16] RT[17] RT[18] RT[19] RT[20]
+   RT[21] RT[22] RT[23] RT[24] RT[25] RT[26] RT[27] RT[28] RT[29] RT[30] RT[31]
+   SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21] SEL[22] SEL[23] SEL[24]
+   SEL[25] SEL[26] SEL[27] SEL[28] SEL[29] SEL[30] SEL[31] VBA[19] VBA[20]
+   VBA[21] VBA[22] VBA[23] VBA[24] VBA[25] VBA[26] VBA[27] VBA[28] VBA[29]
+   VBA[30] VBA[31] VBA[32] VBA[33] VBA[34] VBA[35] VBN[20] VBN[21] VBN[22]
+   VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28] VBN[29] VBN[30] VBN[31]
+   VBN[32] VBN[33] VBN[34] VBN[35] VBN[36] VBP[20] VBP[21] VBP[22] VBP[23]
+   VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32]
+   VBP[33] VBP[34] VBP[35] VBP[36] VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24]
+   VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31] VDDA[32]
+   VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDAIR1 VDDP[20] VDDP[21] VDDP[22]
+   VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDP[29] VDDP[30]
+   VDDP[31] VDDP[32] VDDP[33] VDDP[34] VDDP[35] VDDP[36] VDDPI[20] VDDPI[21]
+   VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28]
+   VDDPI[29] VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35]
+   VDDPI[36] VEDGE[1] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26]
+   VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34] VSS[35]
+   VSS[36] WB[16] WB[17] WB[18] WB[19] WB[20] WB[21] WB[22] WB[23] WB[24]
+   WB[25] WB[26] WB[27] WB[28] WB[29] WB[30] WB[31] WBI[16] WBI[17] WBI[18]
+   WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27]
+   WBI[28] WBI[29] WBI[30] WBI[31] WT[16] WT[17] WT[18] WT[19] WT[20] WT[21]
+   WT[22] WT[23] WT[24] WT[25] WT[26] WT[27] WT[28] WT[29] WT[30] WT[31]
+   WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24]
+   WTI[25] WTI[26] WTI[27] WTI[28] WTI[29] WTI[30] WTI[31]
+   SNPS_SP_HD_16Kx8_mux_rt
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_lt_seg1_1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+       BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+       BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+       BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] LLSB LOG0 LOG1 QB[0]
+       QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+       QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+       QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SDB_BC1T
+       SDB_BC2T SDOR SDOR_RET SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+       SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15]
+       VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9]
+       VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBN[0] VBN[1] VBN[2]
+       VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12]
+       VBN[13] VBN[14] VBN[15] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+       VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15]
+       VDDA VDDAI[0] VDDAI[1] VDDAI[2] VDDAI[3] VDDAI[4] VDDAI[5] VDDAI[6]
+       VDDAI[7] VDDAI[8] VDDAI[9] VDDAI[10] VDDAI[11] VDDAI[12] VDDAI[13]
+       VDDAI[14] VDDAI[15] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5]
+       VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+       VDDP[14] VDDP[15] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5]
+       VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+       VDDPI[13] VDDPI[14] VDDPI[15] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+       VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14]
+       VSS[15] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8]
+       WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WTI[0] WTI[1]
+       WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11]
+       WTI[12] WTI[13] WTI[14] WTI[15]

*** Jumper Report ***
* Jumper: VBA[0] VSS[0]
* Jumper: VBA[1] VSS[1]
* Jumper: VBA[2] VSS[2]
* Jumper: VBA[3] VSS[3]
* Jumper: VBA[4] VSS[4]
* Jumper: VBA[5] VSS[5]
* Jumper: VBA[6] VSS[6]
* Jumper: VBA[7] VSS[7]
* Jumper: VBA[8] VSS[8]
* Jumper: VBA[9] VSS[9]
* Jumper: VBA[10] VSS[10]
* Jumper: VBA[11] VSS[11]
* Jumper: VBA[12] VSS[12]
* Jumper: VBA[13] VSS[13]
* Jumper: VBA[14] VSS[14]
* Jumper: VBA[15] VSS[15]
* Jumper: VDDA VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15]

X_mm16a05_u_hdsp_plus_rar4x1_S0 VDDA VDDAI[0] VDDP[0] VDDPI[0] VSS[0] VBP[0]
+   VBN[0] BB[0] BB[1] BB[2] BB[3] LOG0 LOG1 QB[0] QT[0] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[0] VBA[0] WBI[0] WTI[0] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_S1 VDDA VDDAI[1] VDDP[1] VDDPI[1] VSS[1] VBP[1]
+   VBN[1] BB[4] BB[5] BB[6] BB[7] LOG0 LOG1 QB[1] QT[1] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[1] VBA[1] WBI[1] WTI[1] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_S2 VDDA VDDAI[2] VDDP[2] VDDPI[2] VSS[2] VBP[2]
+   VBN[2] BB[8] BB[9] BB[10] BB[11] LOG0 LOG1 QB[2] QT[2] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[2] VBA[2] WBI[2] WTI[2] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_S3 VDDA VDDAI[3] VDDP[3] VDDPI[3] VSS[3] VBP[3]
+   VBN[3] BB[12] BB[13] BB[14] BB[15] LOG0 LOG1 QB[3] QT[3] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[3] VBA[3] WBI[3] WTI[3] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_S4 VDDA VDDAI[4] VDDP[4] VDDPI[4] VSS[4] VBP[4]
+   VBN[4] BB[16] BB[17] BB[18] BB[19] LOG0 LOG1 QB[4] QT[4] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[4] VBA[4] WBI[4] WTI[4] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_S5 VDDA VDDAI[5] VDDP[5] VDDPI[5] VSS[5] VBP[5]
+   VBN[5] BB[20] BB[21] BB[22] BB[23] LOG0 LOG1 QB[5] QT[5] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[5] VBA[5] WBI[5] WTI[5] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_S6 VDDA VDDAI[6] VDDP[6] VDDPI[6] VSS[6] VBP[6]
+   VBN[6] BB[24] BB[25] BB[26] BB[27] LOG0 LOG1 QB[6] QT[6] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[6] VBA[6] WBI[6] WTI[6] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_S7 VDDA VDDAI[7] VDDP[7] VDDPI[7] VSS[7] VBP[7]
+   VBN[7] BB[28] BB[29] BB[30] BB[31] LOG0 LOG1 QB[7] QT[7] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[7] VBA[7] WBI[7] WTI[7] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_F7 VDDA VDDAI[8] VDDP[8] VDDPI[8] VSS[8] VBP[8]
+   VBN[8] BB[32] BB[33] BB[34] BB[35] LOG0 LOG1 QB[8] QT[8] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[8] VBA[8] WBI[8] WTI[8] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_F6 VDDA VDDAI[9] VDDP[9] VDDPI[9] VSS[9] VBP[9]
+   VBN[9] BB[36] BB[37] BB[38] BB[39] LOG0 LOG1 QB[9] QT[9] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[9] VBA[9] WBI[9] WTI[9] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_F5 VDDA VDDAI[10] VDDP[10] VDDPI[10] VSS[10]
+   VBP[10] VBN[10] BB[40] BB[41] BB[42] BB[43] LOG0 LOG1 QB[10] QT[10] LOG0
+   LOG0 LOG0 LOG0 SDOR SDOR_RET SEL[10] VBA[10] WBI[10] WTI[10] LLSB SDB_BC1T
+   SDB_BC2T mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_F4 VDDA VDDAI[11] VDDP[11] VDDPI[11] VSS[11]
+   VBP[11] VBN[11] BB[44] BB[45] BB[46] BB[47] LOG0 LOG1 QB[11] QT[11] LOG0
+   LOG0 LOG0 LOG0 SDOR SDOR_RET SEL[11] VBA[11] WBI[11] WTI[11] LLSB SDB_BC1T
+   SDB_BC2T mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_F3 VDDA VDDAI[12] VDDP[12] VDDPI[12] VSS[12]
+   VBP[12] VBN[12] BB[48] BB[49] BB[50] BB[51] LOG0 LOG1 QB[12] QT[12] LOG0
+   LOG0 LOG0 LOG0 SDOR SDOR_RET SEL[12] VBA[12] WBI[12] WTI[12] LLSB SDB_BC1T
+   SDB_BC2T mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_F2 VDDA VDDAI[13] VDDP[13] VDDPI[13] VSS[13]
+   VBP[13] VBN[13] BB[52] BB[53] BB[54] BB[55] LOG0 LOG1 QB[13] QT[13] LOG0
+   LOG0 LOG0 LOG0 SDOR SDOR_RET SEL[13] VBA[13] WBI[13] WTI[13] LLSB SDB_BC1T
+   SDB_BC2T mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_F1 VDDA VDDAI[14] VDDP[14] VDDPI[14] VSS[14]
+   VBP[14] VBN[14] BB[56] BB[57] BB[58] BB[59] LOG0 LOG1 QB[14] QT[14] LOG0
+   LOG0 LOG0 LOG0 SDOR SDOR_RET SEL[14] VBA[14] WBI[14] WTI[14] LLSB SDB_BC1T
+   SDB_BC2T mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_F0 VDDA VDDAI[15] VDDP[15] VDDPI[15] VSS[15]
+   VBP[15] VBN[15] BB[60] BB[61] BB[62] BB[63] LOG0 LOG1 QB[15] QT[15] LOG0
+   LOG0 LOG0 LOG0 SDOR SDOR_RET SEL[15] VBA[15] WBI[15] WTI[15] LLSB SDB_BC1T
+   SDB_BC2T mm16a05_u_hdsp_plus_rar4x1
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_lt_1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+       BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+       BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+       BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] LLSB LOG0 LOG1 PGIOI
+       QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+       QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5]
+       QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15]
+       SDB_BC1T SDB_BC2T SDOR SDOR_RET SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+       SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13]
+       SEL[14] SEL[15] TOPEDGE VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+       VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+       VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+       VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0]
+       VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10]
+       VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA VDDAIL1 VDDP[0]
+       VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9]
+       VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+       VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+       VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+       VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+       WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9]
+       WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WTI[0] WTI[1] WTI[2]
+       WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12]
+       WTI[13] WTI[14] WTI[15]

*** Jumper Report ***
* Jumper: LOG1 PGIOI

X_mm16a05_u_hdsp_plus_pg_pwedge VDDA VDDP[0] VDDPI[0] VSS[0] VBP[0] VBN[0] LOG0
+   LOG1 PGIOI PO SDOR_RET TOPEDGE VBA[0] VEDGE SDOR
+   mm16a05_u_hdsp_plus_pg_pwedge
X_ref_lt_seg1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] LLSB LOG0
+   LOG1 QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SDB_BC1T
+   SDB_BC2T SDOR SDOR_RET SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+   SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] VBA[1]
+   VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11]
+   VBA[12] VBA[13] VBA[14] VBA[15] VBA[16] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5]
+   VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15]
+   VBN[16] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9]
+   VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA VDDAIL1 VDDAIL1
+   VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1
+   VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5]
+   VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13]
+   VDDPI[14] VDDPI[15] VDDPI[16] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6]
+   VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9]
+   WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WTI[0] WTI[1] WTI[2] WTI[3]
+   WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13]
+   WTI[14] WTI[15] SNPS_SP_HD_16Kx8_ref_lt_seg1_1
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_cnt_1 ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+       ARYSD_BC2[1] ARYSD_IN[0] ARYSD_IN[1] ARYSD_TOP[0] ARYSD_TOP[1] CENDP
+       DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET FLOAT_RET_PROG
+       LBKADR0 LBKADR1 LCGTH[0] LCGTH[1] LDFTX LITESLP LLBKADRB[0] LLBKADRB[1]
+       LLSB[0] LLSB[1] LMATCHB LMATCHB_I LOG0[0] LOG0[1] LOG0[2] LOG0[3]
+       LOG1[0] LOG1[3] LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+       LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PLBKADR[0] PLBKADR[1]
+       RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RASSISTBH[0] RASSISTBH[1]
+       RASSISTBL[0] RASSISTBL[1] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2]
+       RMT[3] RWLB_SAC RWLD_RD RWLD_WR RWL_DLY_0 RWL_DLY_2 RWL_DLY_4
+       RWL_DLY_RD_PGM RWL_DLY_WR_PGM RWL_RD[1] RWL_RWLD_AND RWL_RWLD_AND_WR
+       RWL_WR[1] SDB_BC1T[0] SDB_BC1T[1] SDB_BC2T[0] SDB_BC2T[1] SDOR[0]
+       SDOR[1] SDOR_RET[0] SDOR_RET[1] T1T TEST_RNMB TOPEDGE[0] TOPEDGE[1]
+       VBA[0] VBA[1] VBN[0] VBN[1] VBN[2] VBP[0] VBP[1] VBP[2] VDDA[0] VDDA[1]
+       VDDA[2] VDDMINB VDDP[0] VDDP[1] VDDP[2] VDDPI[0] VDDPI[1] VDDPI[2]
+       VDDWL[0] VDDWL[1] VSS[0] VSS[1] VSS[2] VSSC_WL_L VSSC_WL_R WABUF[0]
+       WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]

*** Jumper Report ***
* Jumper: FLOAT_RET_PROG LOG1[3]
* Jumper: LLBKADRB[0] PLBKADR[0]
* Jumper: LLBKADRB[1] PLBKADR[1]
* Jumper: LMATCHB LMATCHB_I
* Jumper: LOG0[3] LBKADR
* Jumper: RWLB_RD RWLHVBRD
* Jumper: RWLB_WR RWLHVBWR
* Jumper: RWL_DLY_0 RWL_DLY_RD_PGM RWL_DLY_WR_PGM
* Jumper: VDDA[0] VDDP[0]
* Jumper: VDDA[1] VDDP[1] VDDPI[1]
* Jumper: VDDA[2] VDDP[2]

X_mm16a05_u_hdsp_plus_rwbuf_left VDDA[0] VDDP[0] VDDPI[0] VDDWL[0] VSS[0] VBP[0]
+   VBN[0] SDB_BC1T[0] SDB_BC2T[0] ARYSD_TOP[0] LLSB[0] RWL_RD[0] RWL_WR[0]
+   SDOR[0] LOG0[0] LOG1[0] PO[0] RASSIST[0] RASSIST[1] RASSISTBL[0]
+   RASSISTBL[1] LOG0[1] LOG0[2] TOPEDGE[0] VBA[0] ARYSD_BC1[0] ARYSD_BC2[0]
+   ARYSD_IN[0] LCGTH[0] LOG1[1] LOG1[2] SDOR_RET[0]
+   mm16a05_u_hdsp_plus_rwbuf_left
X_mm16a05_u_hdsp_plus_rw_gf22 VDDMINB VDDA[1] VDDP[1] VDDPI[1] VSS[1] VSSC_WL_L
+   VSSC_WL_R VBP[1] VBN[1] RWLB_RD RWLB_WR RWL_DLY_0 RWL_DLY_2 RWL_DLY_4
+   RWL_RWLD_AND RWL_RWLD_AND_WR CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT_RET
+   FLOAT_RET_PROG LBKADR0 LBKADR1 LOG0[3] LCGTHB LDFTX LITESLP LLBKADRB[0]
+   LLBKADRB[1] LMATCHB LMATCHB_I LOG0[3] LOG1[3] LXADR[0] LXADR[1] LXADR[2]
+   LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PLBKADR[0]
+   PLBKADR[1] RBLRD RBLWA RBLWR RM3CNT RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WPBUF[0] WPBUF[1] WPBUF[2] FLOAT FLOATT LWEIB RMT[0] RMT[1] RMT[2]
+   RMT[3] RWLD_RD RWLD_WR RWLB_RD RWLB_WR RWL_DLY_RD_PGM RWL_DLY_WR_PGM WMT[0]
+   WMT[1] WMT[2] WMT[3] mm16a05_u_hdsp_plus_rw_gf22
X_mm16a05_u_hdsp_plus_rwbuf VDDA[2] VDDP[2] VDDPI[2] VDDWL[1] VSS[2] VBP[2]
+   VBN[2] SDB_BC1T[1] SDB_BC2T[1] ARYSD_TOP[1] LLSB[1] RWL_RD[1] RWL_WR[1]
+   SDOR[1] LCGTHB LOG0[3] LOG1[3] PO[1] RASSIST[2] RASSIST[3] RASSISTBH[0]
+   RASSISTBH[1] RWLD_RD RWLD_WR TOPEDGE[1] VBA[1] ARYSD_BC1[1] ARYSD_BC2[1]
+   ARYSD_IN[1] LCGTH[1] RWLB_RD RWLB_WR SDOR_RET[1] mm16a05_u_hdsp_plus_rwbuf
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_rt_rwl_1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] LLSB LOG0 LOG1 QB[0] QB[1] QB[2] QT[0]
+       QT[1] QT[2] RWLD_RD RWLD_WR RWL_RD RWL_WR SDB_BC1T SDB_BC2T SDOR
+       SDOR_RET SEL[0] SEL[1] SEL[2] VBA[0] VBA[1] VBA[2] VBN[0] VBN[1] VBN[2]
+       VBP[0] VBP[1] VBP[2] VDDA VDDAI[0] VDDAI[1] VDDAI[2] VDDP[0] VDDP[1]
+       VDDP[2] VDDPI[0] VDDPI[1] VDDPI[2] VSS[0] VSS[1] VSS[2] WBI[0] WBI[1]
+       WBI[2] WTI[0] WTI[1] WTI[2]

*** Jumper Report ***
* Jumper: VBA[0] VSS[0]
* Jumper: VBA[1] VSS[1]
* Jumper: VBA[2] VSS[2]
* Jumper: VDDA VDDP[0] VDDP[1] VDDP[2]

X_mm16a05_u_hdsp_plus_rar4x1_S0 VDDA VDDAI[0] VDDP[0] VDDPI[0] VSS[0] VBP[0]
+   VBN[0] BB[0] BB[1] BB[2] BB[3] LOG0 LOG1 QB[0] QT[0] RWLD_RD RWLD_WR RWL_RD
+   RWL_WR SDOR SDOR_RET SEL[0] VBA[0] WBI[0] WTI[0] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_F1 VDDA VDDAI[1] VDDP[1] VDDPI[1] VSS[1] VBP[1]
+   VBN[1] BB[4] BB[5] BB[6] BB[7] LOG0 LOG1 QB[1] QT[1] RWLD_RD RWLD_WR RWL_RD
+   RWL_WR SDOR SDOR_RET SEL[1] VBA[1] WBI[1] WTI[1] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_F0 VDDA VDDAI[2] VDDP[2] VDDPI[2] VSS[2] VBP[2]
+   VBN[2] BB[8] BB[9] BB[10] BB[11] LOG0 LOG1 QB[2] QT[2] RWLD_RD RWLD_WR
+   RWL_RD RWL_WR SDOR SDOR_RET SEL[2] VBA[2] WBI[2] WTI[2] LLSB SDB_BC1T
+   SDB_BC2T mm16a05_u_hdsp_plus_rar4x1
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_cnt_rt_rwl_1 ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+       ARYSD_BC2[1] ARYSD_IN[0] ARYSD_IN[1] ARYSD_TOP[0] ARYSD_TOP[1] BB[0]
+       BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11]
+       CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET
+       FLOAT_RET_PROG LBKADR0 LBKADR1 LCGTH[0] LCGTH[1] LDFTX LITESLP
+       LLBKADRB[0] LLBKADRB[1] LLSB[0] LLSB[1] LMATCHB LMATCHB_I LOG0[0]
+       LOG0[1] LOG0[2] LOG0[3] LOG1[0] LOG1[1] LWEIB LXADR[0] LXADR[1] LXADR[2]
+       LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+       PLBKADR[0] PLBKADR[1] QB[0] QB[1] QB[2] QT[0] QT[1] QT[2] RASSIST[0]
+       RASSIST[1] RASSIST[2] RASSIST[3] RASSISTBH[0] RASSISTBH[1] RASSISTBL[0]
+       RASSISTBL[1] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3]
+       RWLB_SAC RWLD_RD RWLD_WR RWL_DLY_0 RWL_DLY_2 RWL_DLY_4 RWL_DLY_RD_PGM
+       RWL_DLY_WR_PGM RWL_RD RWL_RWLD_AND RWL_RWLD_AND_WR RWL_WR SDB_BC1T[0]
+       SDB_BC1T[1] SDB_BC2T[0] SDB_BC2T[1] SDOR[0] SDOR[1] SDOR_RET[0]
+       SDOR_RET[1] SEL[0] SEL[1] SEL[2] T1T TEST_RNMB TOPEDGE[0] TOPEDGE[1]
+       VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4]
+       VBN[5] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VDDA[0] VDDA[1] VDDA[2]
+       VDDAI[0] VDDAI[1] VDDAI[2] VDDMINB VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+       VDDP[4] VDDP[5] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5]
+       VDDWL[0] VDDWL[1] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSSC_WL_L
+       VSSC_WL_R WABUF[0] WABUF[1] WABUF[2] WBI[0] WBI[1] WBI[2] WMT[0] WMT[1]
+       WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WTI[0] WTI[1] WTI[2]
X_ref_cnt ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1] ARYSD_IN[0]
+   ARYSD_IN[1] ARYSD_TOP[0] ARYSD_TOP[1] CENDP DEF_MODE FAST1_MODE FAST2_MODE
+   FLOAT FLOATT FLOAT_RET FLOAT_RET_PROG LBKADR0 LBKADR1 LCGTH[0] LCGTH[1]
+   LDFTX LITESLP LLBKADRB[0] LLBKADRB[1] LLSB[0] LLSB[1] LMATCHB LMATCHB_I
+   LOG0[0] LOG0[1] LOG0[2] LOG0[3] LOG1[0] LOG1[1] LWEIB LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PLBKADR[0] PLBKADR[1] RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3]
+   RASSISTBH[0] RASSISTBH[1] RASSISTBL[0] RASSISTBL[1] RBLRD RBLWA RBLWR RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC RWLD_RD RWLD_WR RWL_DLY_0 RWL_DLY_2
+   RWL_DLY_4 RWL_DLY_RD_PGM RWL_DLY_WR_PGM RWL_RD RWL_RWLD_AND RWL_RWLD_AND_WR
+   RWL_WR SDB_BC1T[0] SDB_BC1T[1] SDB_BC2T[0] SDB_BC2T[1] SDOR[0] SDOR[1]
+   SDOR_RET[0] SDOR_RET[1] T1T TEST_RNMB TOPEDGE[0] TOPEDGE[1] VBA[0] VBA[1]
+   VBN[0] VBN[1] VBN[2] VBP[0] VBP[1] VBP[2] VDDA[0] VDDA[1] VDDA[2] VDDMINB
+   VDDP[0] VDDP[1] VDDP[2] VDDPI[0] VDDPI[1] VDDPI[2] VDDWL[0] VDDWL[1] VSS[0]
+   VSS[1] VSS[2] VSSC_WL_L VSSC_WL_R WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1]
+   WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] SNPS_SP_HD_16Kx8_ref_cnt_1
X_ref_rt_rwl BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] LLSB[1] LOG0[3] LOG1[1] QB[0] QB[1] QB[2] QT[0] QT[1] QT[2] RWLD_RD
+   RWLD_WR RWL_RD RWL_WR SDB_BC1T[1] SDB_BC2T[1] SDOR[1] SDOR_RET[1] SEL[0]
+   SEL[1] SEL[2] VBA[2] VBA[3] VBA[4] VBN[3] VBN[4] VBN[5] VBP[3] VBP[4] VBP[5]
+   VDDA[2] VDDAI[0] VDDAI[1] VDDAI[2] VDDP[3] VDDP[4] VDDP[5] VDDPI[3] VDDPI[4]
+   VDDPI[5] VSS[3] VSS[4] VSS[5] WBI[0] WBI[1] WBI[2] WTI[0] WTI[1] WTI[2]
+   SNPS_SP_HD_16Kx8_ref_rt_rwl_1
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_rt_log0_1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+       BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+       BB[47] LLSB LOG0 LOG1 QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7]
+       QB[8] QB[9] QB[10] QB[11] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+       QT[7] QT[8] QT[9] QT[10] QT[11] SDB_BC1T SDB_BC2T SDOR SDOR_RET SEL[0]
+       SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10]
+       SEL[11] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8]
+       VBA[9] VBA[10] VBA[11] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+       VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4]
+       VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VDDA VDDAI[0]
+       VDDAI[1] VDDAI[2] VDDAI[3] VDDAI[4] VDDAI[5] VDDAI[6] VDDAI[7] VDDAI[8]
+       VDDAI[9] VDDAI[10] VDDAI[11] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+       VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+       VDDPI[9] VDDPI[10] VDDPI[11] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+       VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] WBI[0] WBI[1] WBI[2] WBI[3]
+       WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WTI[0] WTI[1]
+       WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11]

*** Jumper Report ***
* Jumper: VBA[0] VSS[0]
* Jumper: VBA[1] VSS[1]
* Jumper: VBA[2] VSS[2]
* Jumper: VBA[3] VSS[3]
* Jumper: VBA[4] VSS[4]
* Jumper: VBA[5] VSS[5]
* Jumper: VBA[6] VSS[6]
* Jumper: VBA[7] VSS[7]
* Jumper: VBA[8] VSS[8]
* Jumper: VBA[9] VSS[9]
* Jumper: VBA[10] VSS[10]
* Jumper: VBA[11] VSS[11]
* Jumper: VDDA VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11]

X_mm16a05_u_hdsp_plus_rar4x1_S0 VDDA VDDAI[0] VDDP[0] VDDPI[0] VSS[0] VBP[0]
+   VBN[0] BB[0] BB[1] BB[2] BB[3] LOG0 LOG1 QB[0] QT[0] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[0] VBA[0] WBI[0] WTI[0] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_S1 VDDA VDDAI[1] VDDP[1] VDDPI[1] VSS[1] VBP[1]
+   VBN[1] BB[4] BB[5] BB[6] BB[7] LOG0 LOG1 QB[1] QT[1] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[1] VBA[1] WBI[1] WTI[1] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_S2 VDDA VDDAI[2] VDDP[2] VDDPI[2] VSS[2] VBP[2]
+   VBN[2] BB[8] BB[9] BB[10] BB[11] LOG0 LOG1 QB[2] QT[2] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[2] VBA[2] WBI[2] WTI[2] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_S3 VDDA VDDAI[3] VDDP[3] VDDPI[3] VSS[3] VBP[3]
+   VBN[3] BB[12] BB[13] BB[14] BB[15] LOG0 LOG1 QB[3] QT[3] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[3] VBA[3] WBI[3] WTI[3] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_S4 VDDA VDDAI[4] VDDP[4] VDDPI[4] VSS[4] VBP[4]
+   VBN[4] BB[16] BB[17] BB[18] BB[19] LOG0 LOG1 QB[4] QT[4] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[4] VBA[4] WBI[4] WTI[4] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_S5 VDDA VDDAI[5] VDDP[5] VDDPI[5] VSS[5] VBP[5]
+   VBN[5] BB[20] BB[21] BB[22] BB[23] LOG0 LOG1 QB[5] QT[5] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[5] VBA[5] WBI[5] WTI[5] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_F5 VDDA VDDAI[6] VDDP[6] VDDPI[6] VSS[6] VBP[6]
+   VBN[6] BB[24] BB[25] BB[26] BB[27] LOG0 LOG1 QB[6] QT[6] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[6] VBA[6] WBI[6] WTI[6] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_F4 VDDA VDDAI[7] VDDP[7] VDDPI[7] VSS[7] VBP[7]
+   VBN[7] BB[28] BB[29] BB[30] BB[31] LOG0 LOG1 QB[7] QT[7] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[7] VBA[7] WBI[7] WTI[7] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_F3 VDDA VDDAI[8] VDDP[8] VDDPI[8] VSS[8] VBP[8]
+   VBN[8] BB[32] BB[33] BB[34] BB[35] LOG0 LOG1 QB[8] QT[8] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[8] VBA[8] WBI[8] WTI[8] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_F2 VDDA VDDAI[9] VDDP[9] VDDPI[9] VSS[9] VBP[9]
+   VBN[9] BB[36] BB[37] BB[38] BB[39] LOG0 LOG1 QB[9] QT[9] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[9] VBA[9] WBI[9] WTI[9] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_F1 VDDA VDDAI[10] VDDP[10] VDDPI[10] VSS[10]
+   VBP[10] VBN[10] BB[40] BB[41] BB[42] BB[43] LOG0 LOG1 QB[10] QT[10] LOG0
+   LOG0 LOG0 LOG0 SDOR SDOR_RET SEL[10] VBA[10] WBI[10] WTI[10] LLSB SDB_BC1T
+   SDB_BC2T mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_F0 VDDA VDDAI[11] VDDP[11] VDDPI[11] VSS[11]
+   VBP[11] VBN[11] BB[44] BB[45] BB[46] BB[47] LOG0 LOG1 QB[11] QT[11] LOG0
+   LOG0 LOG0 LOG0 SDOR SDOR_RET SEL[11] VBA[11] WBI[11] WTI[11] LLSB SDB_BC1T
+   SDB_BC2T mm16a05_u_hdsp_plus_rar4x1
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_row_2 ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+       ARYSD_BC2[1] ARYSD_IN[0] ARYSD_IN[1] ARYSD_TOP[0] ARYSD_TOP[1] BB[0]
+       BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11]
+       BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+       BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31]
+       BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41]
+       BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51]
+       BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61]
+       BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+       BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81]
+       BB[82] BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91]
+       BB[92] BB[93] BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101]
+       BB[102] BB[103] BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110]
+       BB[111] BB[112] BB[113] BB[114] BB[115] BB[116] BB[117] BB[118] BB[119]
+       BB[120] BB[121] BB[122] BB[123] BB[124] BB[125] BB[126] BB[127] CENDP
+       DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET FLOAT_RET_PROG
+       LBKADR0 LBKADR1 LCGTH[0] LCGTH[1] LDFTX LITESLP LLBKADRB[0] LLBKADRB[1]
+       LMATCHB LMATCHB_I LOG0[0] LOG0[1] LOG1[0] LOG1[1] LWEIB LXADR[0]
+       LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+       LYADR[1] PGIOI[0] PGIOI[1] PLBKADR[0] PLBKADR[1] QB[0] QB[1] QB[2] QB[3]
+       QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14]
+       QB[15] QB[16] QB[17] QB[18] QB[19] QB[20] QB[21] QB[22] QB[23] QB[24]
+       QB[25] QB[26] QB[27] QB[28] QB[29] QB[30] QB[31] QT[0] QT[1] QT[2] QT[3]
+       QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+       QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24]
+       QT[25] QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] RASSIST[0] RASSIST[1]
+       RASSIST[2] RASSIST[3] RASSISTBH[0] RASSISTBH[1] RASSISTBL[0]
+       RASSISTBL[1] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3]
+       RWLB_SAC RWL_DLY_0 RWL_DLY_2 RWL_DLY_4 RWL_DLY_RD_PGM RWL_DLY_WR_PGM
+       RWL_RWLD_AND RWL_RWLD_AND_WR SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5]
+       SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14]
+       SEL[15] SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21] SEL[22] SEL[23]
+       SEL[24] SEL[25] SEL[26] SEL[27] SEL[28] SEL[29] SEL[30] SEL[31] T1T
+       TEST_RNMB TOPEDGE[0] TOPEDGE[1] TOPEDGE[2] TOPEDGE[3] VBA[0] VBA[1]
+       VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11]
+       VBA[12] VBA[13] VBA[14] VBA[15] VBA[16] VBA[17] VBA[18] VBA[19] VBA[20]
+       VBA[21] VBA[22] VBA[23] VBA[24] VBA[25] VBA[26] VBA[27] VBA[28] VBA[29]
+       VBA[30] VBA[31] VBA[32] VBA[33] VBA[34] VBA[35] VBN[0] VBN[1] VBN[2]
+       VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12]
+       VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20] VBN[21]
+       VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28] VBN[29] VBN[30]
+       VBN[31] VBN[32] VBN[33] VBN[34] VBN[35] VBN[36] VBP[0] VBP[1] VBP[2]
+       VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+       VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21]
+       VBP[22] VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30]
+       VBP[31] VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VDDA[0] VDDA[1] VDDA[2]
+       VDDAIL1 VDDAIR1 VDDMINB VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5]
+       VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+       VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21]
+       VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDP[29]
+       VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34] VDDP[35] VDDP[36] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+       VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+       VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+       VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+       VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+       VDDWL[0] VDDWL[1] VEDGE[0] VEDGE[1] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4]
+       VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13]
+       VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22]
+       VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31]
+       VSS[32] VSS[33] VSS[34] VSS[35] VSS[36] VSSC_WL_L VSSC_WL_R WABUF[0]
+       WABUF[1] WABUF[2] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+       WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+       WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24]
+       WBI[25] WBI[26] WBI[27] WBI[28] WBI[29] WBI[30] WBI[31] WMT[0] WMT[1]
+       WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WTI[0] WTI[1] WTI[2] WTI[3]
+       WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12]
+       WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21]
+       WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27] WTI[28] WTI[29] WTI[30]
+       WTI[31]

*** Jumper Report ***
* Jumper: LOG1[1] PGIOI[1]
* Jumper: VBA[22] VSS[23]
* Jumper: VDDA[2] VDDP[23]

X_ref_lt BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] LLSB[0]
+   LOG0[0] LOG1[0] PGIOI[0] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7]
+   QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] SDB_BC1T[0] SDB_BC2T[0] SDOR[0] SDOR_RET[0] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+   SEL[13] SEL[14] SEL[15] TOPEDGE[0] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDAIL1 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1]
+   VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9]
+   VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16]
+   VEDGE[0] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+   VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1]
+   WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11]
+   WBI[12] WBI[13] WBI[14] WBI[15] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ref_lt_1
X_ref_cnt_rt_rwl ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1] ARYSD_IN[0]
+   ARYSD_IN[1] ARYSD_TOP[0] ARYSD_TOP[1] BB[64] BB[65] BB[66] BB[67] BB[68]
+   BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75] CENDP DEF_MODE FAST1_MODE
+   FAST2_MODE FLOAT FLOATT FLOAT_RET FLOAT_RET_PROG LBKADR0 LBKADR1 LCGTH[0]
+   LCGTH[1] LDFTX LITESLP LLBKADRB[0] LLBKADRB[1] LLSB[0] LLSB[1] LMATCHB
+   LMATCHB_I LOG0[0] LOG0[0] LOG0[0] LOG0[1] LOG1[0] LOG1[1] LWEIB LXADR[0]
+   LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+   LYADR[1] PLBKADR[0] PLBKADR[1] QB[16] QB[17] QB[18] QT[16] QT[17] QT[18]
+   RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RASSISTBH[0] RASSISTBH[1]
+   RASSISTBL[0] RASSISTBL[1] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2]
+   RMT[3] RWLB_SAC RWLD_RD RWLD_WR RWL_DLY_0 RWL_DLY_2 RWL_DLY_4 RWL_DLY_RD_PGM
+   RWL_DLY_WR_PGM RWLD_RD RWL_RWLD_AND RWL_RWLD_AND_WR RWLD_WR SDB_BC1T[0]
+   SDB_BC1T[1] SDB_BC2T[0] SDB_BC2T[1] SDOR[0] SDOR[1] SDOR_RET[0] SDOR_RET[1]
+   SEL[16] SEL[17] SEL[18] T1T TEST_RNMB TOPEDGE[1] TOPEDGE[2] VBA[17] VBA[18]
+   VBA[19] VBA[20] VBA[21] VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22]
+   VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VDDA[0] VDDA[1] VDDA[2]
+   VDDAIR1 VDDAIR1 VDDAIR1 VDDMINB VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21]
+   VDDP[22] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDWL[0] VDDWL[1] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSSC_WL_L
+   VSSC_WL_R WABUF[0] WABUF[1] WABUF[2] WBI[16] WBI[17] WBI[18] WMT[0] WMT[1]
+   WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WTI[16] WTI[17] WTI[18]
+   SNPS_SP_HD_16Kx8_ref_cnt_rt_rwl_1
X_mm16a05_u_hdsp_plus_rrtar4x1 VDDA[2] VDDAIR1 VDDP[23] VDDPI[23] VSS[23]
+   VBP[23] VBN[23] BB[76] BB[77] BB[78] BB[79] LOG0[1] LOG1[1] QB[19] QT[19]
+   RWLD_RD RWLD_WR RWLD_RD RWLD_WR SDOR[1] SDOR_RET[1] SEL[19] VBA[22] WBI[19]
+   WTI[19] LLSB[1] SDB_BC1T[1] SDB_BC2T[1] mm16a05_u_hdsp_plus_rar4x1
X_ref_rt_log0 BB[80] BB[81] BB[82] BB[83] BB[84] BB[85] BB[86] BB[87] BB[88]
+   BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95] BB[96] BB[97] BB[98] BB[99]
+   BB[100] BB[101] BB[102] BB[103] BB[104] BB[105] BB[106] BB[107] BB[108]
+   BB[109] BB[110] BB[111] BB[112] BB[113] BB[114] BB[115] BB[116] BB[117]
+   BB[118] BB[119] BB[120] BB[121] BB[122] BB[123] BB[124] BB[125] BB[126]
+   BB[127] LLSB[1] LOG0[1] LOG1[1] QB[20] QB[21] QB[22] QB[23] QB[24] QB[25]
+   QB[26] QB[27] QB[28] QB[29] QB[30] QB[31] QT[20] QT[21] QT[22] QT[23] QT[24]
+   QT[25] QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] SDB_BC1T[1] SDB_BC2T[1]
+   SDOR[1] SDOR_RET[1] SEL[20] SEL[21] SEL[22] SEL[23] SEL[24] SEL[25] SEL[26]
+   SEL[27] SEL[28] SEL[29] SEL[30] SEL[31] VBA[23] VBA[24] VBA[25] VBA[26]
+   VBA[27] VBA[28] VBA[29] VBA[30] VBA[31] VBA[32] VBA[33] VBA[34] VBN[24]
+   VBN[25] VBN[26] VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33]
+   VBN[34] VBN[35] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30]
+   VBP[31] VBP[32] VBP[33] VBP[34] VBP[35] VDDA[2] VDDAIR1 VDDAIR1 VDDAIR1
+   VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1
+   VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31]
+   VDDP[32] VDDP[33] VDDP[34] VDDP[35] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27]
+   VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34]
+   VDDPI[35] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31]
+   VSS[32] VSS[33] VSS[34] VSS[35] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24]
+   WBI[25] WBI[26] WBI[27] WBI[28] WBI[29] WBI[30] WBI[31] WTI[20] WTI[21]
+   WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27] WTI[28] WTI[29] WTI[30]
+   WTI[31] SNPS_SP_HD_16Kx8_ref_rt_log0_1
X_mm16a05_u_hdsp_plus_pg_pwedge VDDA[2] VDDP[36] VDDPI[36] VSS[36] VBP[36]
+   VBN[36] LOG0[1] LOG1[1] PGIOI[1] PO SDOR_RET[1] TOPEDGE[3] VBA[35] VEDGE[1]
+   SDOR[1] mm16a05_u_hdsp_plus_pg_pwedge
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_lt_seg1_2 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+       BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+       BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+       BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] LLSB LOG0 LOG1 QB[0]
+       QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+       QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+       QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SDB_BC1T
+       SDB_BC2T SDOR SDOR_RET SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+       SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15]
+       VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9]
+       VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBN[0] VBN[1] VBN[2]
+       VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12]
+       VBN[13] VBN[14] VBN[15] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+       VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15]
+       VDDA VDDAI[0] VDDAI[1] VDDAI[2] VDDAI[3] VDDAI[4] VDDAI[5] VDDAI[6]
+       VDDAI[7] VDDAI[8] VDDAI[9] VDDAI[10] VDDAI[11] VDDAI[12] VDDAI[13]
+       VDDAI[14] VDDAI[15] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5]
+       VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+       VDDP[14] VDDP[15] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5]
+       VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+       VDDPI[13] VDDPI[14] VDDPI[15] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+       VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14]
+       VSS[15] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8]
+       WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WTI[0] WTI[1]
+       WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11]
+       WTI[12] WTI[13] WTI[14] WTI[15]

*** Jumper Report ***
* Jumper: VBA[0] VSS[0]
* Jumper: VBA[1] VSS[1]
* Jumper: VBA[2] VSS[2]
* Jumper: VBA[3] VSS[3]
* Jumper: VBA[4] VSS[4]
* Jumper: VBA[5] VSS[5]
* Jumper: VBA[6] VSS[6]
* Jumper: VBA[7] VSS[7]
* Jumper: VBA[8] VSS[8]
* Jumper: VBA[9] VSS[9]
* Jumper: VBA[10] VSS[10]
* Jumper: VBA[11] VSS[11]
* Jumper: VBA[12] VSS[12]
* Jumper: VBA[13] VSS[13]
* Jumper: VBA[14] VSS[14]
* Jumper: VBA[15] VSS[15]

X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_S0 VDDA VDDAI[0] VDDP[0] VDDPI[0] VSS[0]
+   VBP[0] VBN[0] BB[0] BB[1] BB[2] BB[3] LOG0 LOG1 QB[0] QT[0] SDOR SDOR_RET
+   SEL[0] VBA[0] WBI[0] WTI[0] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_S1 VDDA VDDAI[1] VDDP[1] VDDPI[1] VSS[1]
+   VBP[1] VBN[1] BB[4] BB[5] BB[6] BB[7] LOG0 LOG1 QB[1] QT[1] SDOR SDOR_RET
+   SEL[1] VBA[1] WBI[1] WTI[1] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_S2 VDDA VDDAI[2] VDDP[2] VDDPI[2] VSS[2]
+   VBP[2] VBN[2] BB[8] BB[9] BB[10] BB[11] LOG0 LOG1 QB[2] QT[2] SDOR SDOR_RET
+   SEL[2] VBA[2] WBI[2] WTI[2] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_S3 VDDA VDDAI[3] VDDP[3] VDDPI[3] VSS[3]
+   VBP[3] VBN[3] BB[12] BB[13] BB[14] BB[15] LOG0 LOG1 QB[3] QT[3] SDOR
+   SDOR_RET SEL[3] VBA[3] WBI[3] WTI[3] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_S4 VDDA VDDAI[4] VDDP[4] VDDPI[4] VSS[4]
+   VBP[4] VBN[4] BB[16] BB[17] BB[18] BB[19] LOG0 LOG1 QB[4] QT[4] SDOR
+   SDOR_RET SEL[4] VBA[4] WBI[4] WTI[4] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_S5 VDDA VDDAI[5] VDDP[5] VDDPI[5] VSS[5]
+   VBP[5] VBN[5] BB[20] BB[21] BB[22] BB[23] LOG0 LOG1 QB[5] QT[5] SDOR
+   SDOR_RET SEL[5] VBA[5] WBI[5] WTI[5] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_S6 VDDA VDDAI[6] VDDP[6] VDDPI[6] VSS[6]
+   VBP[6] VBN[6] BB[24] BB[25] BB[26] BB[27] LOG0 LOG1 QB[6] QT[6] SDOR
+   SDOR_RET SEL[6] VBA[6] WBI[6] WTI[6] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_S7 VDDA VDDAI[7] VDDP[7] VDDPI[7] VSS[7]
+   VBP[7] VBN[7] BB[28] BB[29] BB[30] BB[31] LOG0 LOG1 QB[7] QT[7] SDOR
+   SDOR_RET SEL[7] VBA[7] WBI[7] WTI[7] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_F7 VDDA VDDAI[8] VDDP[8] VDDPI[8] VSS[8]
+   VBP[8] VBN[8] BB[32] BB[33] BB[34] BB[35] LOG0 LOG1 QB[8] QT[8] SDOR
+   SDOR_RET SEL[8] VBA[8] WBI[8] WTI[8] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_F6 VDDA VDDAI[9] VDDP[9] VDDPI[9] VSS[9]
+   VBP[9] VBN[9] BB[36] BB[37] BB[38] BB[39] LOG0 LOG1 QB[9] QT[9] SDOR
+   SDOR_RET SEL[9] VBA[9] WBI[9] WTI[9] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_F5 VDDA VDDAI[10] VDDP[10] VDDPI[10] VSS[10]
+   VBP[10] VBN[10] BB[40] BB[41] BB[42] BB[43] LOG0 LOG1 QB[10] QT[10] SDOR
+   SDOR_RET SEL[10] VBA[10] WBI[10] WTI[10] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_F4 VDDA VDDAI[11] VDDP[11] VDDPI[11] VSS[11]
+   VBP[11] VBN[11] BB[44] BB[45] BB[46] BB[47] LOG0 LOG1 QB[11] QT[11] SDOR
+   SDOR_RET SEL[11] VBA[11] WBI[11] WTI[11] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_F3 VDDA VDDAI[12] VDDP[12] VDDPI[12] VSS[12]
+   VBP[12] VBN[12] BB[48] BB[49] BB[50] BB[51] LOG0 LOG1 QB[12] QT[12] SDOR
+   SDOR_RET SEL[12] VBA[12] WBI[12] WTI[12] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_F2 VDDA VDDAI[13] VDDP[13] VDDPI[13] VSS[13]
+   VBP[13] VBN[13] BB[52] BB[53] BB[54] BB[55] LOG0 LOG1 QB[13] QT[13] SDOR
+   SDOR_RET SEL[13] VBA[13] WBI[13] WTI[13] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_F1 VDDA VDDAI[14] VDDP[14] VDDPI[14] VSS[14]
+   VBP[14] VBN[14] BB[56] BB[57] BB[58] BB[59] LOG0 LOG1 QB[14] QT[14] SDOR
+   SDOR_RET SEL[14] VBA[14] WBI[14] WTI[14] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_F0 VDDA VDDAI[15] VDDP[15] VDDPI[15] VSS[15]
+   VBP[15] VBN[15] BB[60] BB[61] BB[62] BB[63] LOG0 LOG1 QB[15] QT[15] SDOR
+   SDOR_RET SEL[15] VBA[15] WBI[15] WTI[15] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_lt_2 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+       BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+       BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+       BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] LLSB LOG0 LOG1 PGIOI
+       QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+       QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5]
+       QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15]
+       SDB_BC1T SDB_BC2T SDOR SDOR_RET SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+       SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13]
+       SEL[14] SEL[15] TOPEDGE VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+       VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+       VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+       VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0]
+       VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10]
+       VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA VDDAIL1 VDDP[0]
+       VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9]
+       VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+       VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+       VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+       VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+       WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9]
+       WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WTI[0] WTI[1] WTI[2]
+       WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12]
+       WTI[13] WTI[14] WTI[15]

*** Jumper Report ***
* Jumper: LOG1 PGIOI

X_mm16a05_u_hdsp_plus_pg_pwedge_wk_bk2 VDDA VDDP[0] VDDPI[0] VSS[0] VBP[0]
+   VBN[0] LOG0 LOG1 PGIOI PO SDOR_RET TOPEDGE VBA[0] VEDGE SDOR
+   mm16a05_u_hdsp_plus_pg_pwedge
X_ref_lt_seg1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] LLSB LOG0
+   LOG1 QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SDB_BC1T
+   SDB_BC2T SDOR SDOR_RET SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+   SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] VBA[1]
+   VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11]
+   VBA[12] VBA[13] VBA[14] VBA[15] VBA[16] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5]
+   VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15]
+   VBN[16] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9]
+   VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA VDDAIL1 VDDAIL1
+   VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1
+   VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5]
+   VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13]
+   VDDPI[14] VDDPI[15] VDDPI[16] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6]
+   VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9]
+   WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WTI[0] WTI[1] WTI[2] WTI[3]
+   WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13]
+   WTI[14] WTI[15] SNPS_SP_HD_16Kx8_ref_lt_seg1_2
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_buf_l_1 ARYSDB_BC1 ARYSDB_BC2 ARYSD_BC1 ARYSD_BC2
+       ARYSD_IN ARYSD_OUT ARYSD_TOP LCGTH LLSB LOG0 LOG1 PO RASSIST[0]
+       RASSIST[1] RASSISTB[0] RASSISTB[1] RWLB_RD RWLB_WR RWLD_RD RWLD_WR
+       RWL_RD RWL_WR SDOR_RETI TOPEDGE VBA VBN VBP VDDA VDDP VDDPI VDDWL VSS
X_mm16a05_u_hdsp_plus_rwbuf_wk_bk2_left VDDA VDDP VDDPI VDDWL VSS VBP VBN
+   ARYSDB_BC1 ARYSDB_BC2 ARYSD_TOP LLSB RWL_RD RWL_WR ARYSD_OUT LOG0 LOG1 PO
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] RWLD_RD RWLD_WR TOPEDGE VBA
+   ARYSD_BC1 ARYSD_BC2 ARYSD_IN LCGTH RWLB_RD RWLB_WR SDOR_RETI
+   mm16a05_u_hdsp_plus_rwbuf_wk_bk2_left
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_cnt_2 ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+       ARYSD_BC2[1] ARYSD_IN[0] ARYSD_IN[1] ARYSD_TOP[0] ARYSD_TOP[1] CENDP
+       DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR0 LBKADR1
+       LCGTH[0] LCGTH[1] LDFTX LITESLP LLBKADRB[0] LLBKADRB[1] LLSB[0] LLSB[1]
+       LMATCHB LMATCHB_I LOG0[0] LOG0[1] LOG0[2] LOG0[3] LOG1[0] LOG1[1]
+       LOG1[2] LOG1[3] LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+       LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PLBKADR[0] PLBKADR[1]
+       RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RASSISTB[0] RASSISTB[1]
+       RASSISTB[2] RASSISTB[3] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2]
+       RMT[3] RWLB_RD RWLB_SAC RWLB_WR RWLD_RD RWLD_WR RWL_RD[1] RWL_WR[1]
+       SDB_BC1T[0] SDB_BC1T[1] SDB_BC2T[0] SDB_BC2T[1] SDOR[0] SDOR[1]
+       SDOR_RET[0] SDOR_RET[1] T1T TEST_RNMB TOPEDGE[0] TOPEDGE[1] VBA[0]
+       VBA[1] VBN[0] VBN[1] VBN[2] VBP[0] VBP[1] VBP[2] VDDA[0] VDDA[1] VDDA[2]
+       VDDMINB VDDP[0] VDDP[1] VDDP[2] VDDPI[0] VDDPI[1] VDDPI[2] VDDWL[0]
+       VDDWL[1] VSS[0] VSS[1] VSS[2] WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1]
+       WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]

*** Jumper Report ***
* Jumper: VDDA[1] VDDP[1] VDDPI[1]

X_ref_buf_l SDB_BC1T[0] SDB_BC2T[0] ARYSD_BC1[0] ARYSD_BC2[0] ARYSD_IN[0]
+   SDOR[0] ARYSD_TOP[0] LCGTH[0] LLSB[0] LOG0[0] LOG1[0] PO[0] RASSIST[0]
+   RASSIST[1] RASSISTB[0] RASSISTB[1] LOG1[1] LOG1[2] LOG0[1] LOG0[2] RWL_RD[0]
+   RWL_WR[0] SDOR_RET[0] TOPEDGE[0] VBA[0] VBN[0] VBP[0] VDDA[0] VDDP[0]
+   VDDPI[0] VDDWL[0] VSS[0] SNPS_SP_HD_16Kx8_ref_buf_l_1
X_mm16a05_u_hdsp_plus_rw_wk_bk2 VDDA[1] VDDMINB VDDP[1] VDDPI[1] VSS[1] VBP[1]
+   VBN[1] RWLB_RD RWLB_WR CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT_RET
+   LBKADR0 LBKADR1 LBKADR LDFTX LITESLP LLBKADRB[0] LLBKADRB[1] LMATCHB
+   LMATCHB_I LOG0[3] LOG1[3] LWEIB_HV LXADR[0] LXADR[1] LXADR[2] LXADR[3]
+   LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PLBKADR[0] PLBKADR[1]
+   RBLRD RBLWA RBLWR RM3CNT RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2]
+   WPBUF[0] WPBUF[1] WPBUF[2] FLOAT FLOATT LWEIB RMT[0] RMT[1] RMT[2] RMT[3]
+   RWLD_RD RWLD_WR WMT[0] WMT[1] WMT[2] WMT[3] mm16a05_u_hdsp_plus_rw_wk_bk2
X_mm16a05_u_hdsp_plus_rwbuf_wk_bk2 VDDA[2] VDDP[2] VDDPI[2] VDDWL[1] VSS[2]
+   VBP[2] VBN[2] SDB_BC1T[1] SDB_BC2T[1] ARYSD_TOP[1] LCGTHB LLSB[1] RWL_RD[1]
+   RWL_WR[1] ARYSD_IN[1] SDOR[1] LOG0[3] LOG1[3] PO[1] RASSIST[2] RASSIST[3]
+   RASSISTB[2] RASSISTB[3] RWLD_RD RWLD_WR TOPEDGE[1] VBA[1] ARYSD_BC1[1]
+   ARYSD_BC2[1] LCGTH[1] RWLB_RD RWLB_WR SDOR_RET[1]
+   mm16a05_u_hdsp_plus_rwbuf_wk_bk2
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_rt_rwl_2 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] LLSB LOG0 LOG1 QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QT[0]
+       QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] SDB_BC1T SDB_BC2T SDOR SDOR_RET
+       SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] VBA[0] VBA[1] VBA[2]
+       VBA[3] VBA[4] VBA[5] VBA[6] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5]
+       VBN[6] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VDDA VDDAI[0]
+       VDDAI[1] VDDAI[2] VDDAI[3] VDDAI[4] VDDAI[5] VDDAI[6] VDDP[0] VDDP[1]
+       VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDPI[0] VDDPI[1] VDDPI[2]
+       VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4]
+       VSS[5] VSS[6] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WTI[0]
+       WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]

*** Jumper Report ***
* Jumper: VBA[0] VSS[0]
* Jumper: VBA[1] VSS[1]
* Jumper: VBA[2] VSS[2]
* Jumper: VBA[3] VSS[3]
* Jumper: VBA[4] VSS[4]
* Jumper: VBA[5] VSS[5]
* Jumper: VBA[6] VSS[6]

X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_S0 VDDA VDDAI[0] VDDP[0] VDDPI[0] VSS[0]
+   VBP[0] VBN[0] BB[0] BB[1] BB[2] BB[3] LOG0 LOG1 QB[0] QT[0] SDOR SDOR_RET
+   SEL[0] VBA[0] WBI[0] WTI[0] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_S1 VDDA VDDAI[1] VDDP[1] VDDPI[1] VSS[1]
+   VBP[1] VBN[1] BB[4] BB[5] BB[6] BB[7] LOG0 LOG1 QB[1] QT[1] SDOR SDOR_RET
+   SEL[1] VBA[1] WBI[1] WTI[1] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_S2 VDDA VDDAI[2] VDDP[2] VDDPI[2] VSS[2]
+   VBP[2] VBN[2] BB[8] BB[9] BB[10] BB[11] LOG0 LOG1 QB[2] QT[2] SDOR SDOR_RET
+   SEL[2] VBA[2] WBI[2] WTI[2] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_F3 VDDA VDDAI[3] VDDP[3] VDDPI[3] VSS[3]
+   VBP[3] VBN[3] BB[12] BB[13] BB[14] BB[15] LOG0 LOG1 QB[3] QT[3] SDOR
+   SDOR_RET SEL[3] VBA[3] WBI[3] WTI[3] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_F2 VDDA VDDAI[4] VDDP[4] VDDPI[4] VSS[4]
+   VBP[4] VBN[4] BB[16] BB[17] BB[18] BB[19] LOG0 LOG1 QB[4] QT[4] SDOR
+   SDOR_RET SEL[4] VBA[4] WBI[4] WTI[4] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_F1 VDDA VDDAI[5] VDDP[5] VDDPI[5] VSS[5]
+   VBP[5] VBN[5] BB[20] BB[21] BB[22] BB[23] LOG0 LOG1 QB[5] QT[5] SDOR
+   SDOR_RET SEL[5] VBA[5] WBI[5] WTI[5] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_F0 VDDA VDDAI[6] VDDP[6] VDDPI[6] VSS[6]
+   VBP[6] VBN[6] BB[24] BB[25] BB[26] BB[27] LOG0 LOG1 QB[6] QT[6] SDOR
+   SDOR_RET SEL[6] VBA[6] WBI[6] WTI[6] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_cnt_rt_rwl_2 ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+       ARYSD_BC2[1] ARYSD_IN[0] ARYSD_IN[1] ARYSD_TOP[0] ARYSD_TOP[1] BB[0]
+       BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11]
+       BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+       BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] CENDP DEF_MODE FAST1_MODE
+       FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR0 LBKADR1 LCGTH[0] LCGTH[1]
+       LDFTX LITESLP LLBKADRB[0] LLBKADRB[1] LLSB[0] LLSB[1] LMATCHB LMATCHB_I
+       LOG0[0] LOG0[1] LOG0[2] LOG0[3] LOG1[0] LOG1[1] LOG1[2] LOG1[3] LWEIB
+       LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+       LYADR[0] LYADR[1] PLBKADR[0] PLBKADR[1] QB[0] QB[1] QB[2] QB[3] QB[4]
+       QB[5] QB[6] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] RASSIST[0]
+       RASSIST[1] RASSIST[2] RASSIST[3] RASSISTB[0] RASSISTB[1] RASSISTB[2]
+       RASSISTB[3] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3]
+       RWLB_SAC SDB_BC1T[0] SDB_BC1T[1] SDB_BC2T[0] SDB_BC2T[1] SDOR[0] SDOR[1]
+       SDOR_RET[0] SDOR_RET[1] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+       T1T TEST_RNMB TOPEDGE[0] TOPEDGE[1] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4]
+       VBA[5] VBA[6] VBA[7] VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5]
+       VBN[6] VBN[7] VBN[8] VBN[9] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5]
+       VBP[6] VBP[7] VBP[8] VBP[9] VDDA[0] VDDA[1] VDDA[2] VDDAI[0] VDDAI[1]
+       VDDAI[2] VDDAI[3] VDDAI[4] VDDAI[5] VDDAI[6] VDDMINB VDDP[0] VDDP[1]
+       VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+       VDDPI[9] VDDWL[0] VDDWL[1] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+       VSS[6] VSS[7] VSS[8] VSS[9] WABUF[0] WABUF[1] WABUF[2] WBI[0] WBI[1]
+       WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0]
+       WPBUF[1] WPBUF[2] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
X_ref_cnt ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1] ARYSD_IN[0]
+   ARYSD_IN[1] ARYSD_TOP[0] ARYSD_TOP[1] CENDP DEF_MODE FAST1_MODE FAST2_MODE
+   FLOAT FLOATT FLOAT_RET LBKADR0 LBKADR1 LCGTH[0] LCGTH[1] LDFTX LITESLP
+   LLBKADRB[0] LLBKADRB[1] LLSB[0] LLSB[1] LMATCHB LMATCHB_I LOG0[0] LOG0[1]
+   LOG0[2] LOG0[3] LOG1[0] LOG1[1] LOG1[2] LOG1[3] LWEIB LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PLBKADR[0] PLBKADR[1] RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3]
+   RASSISTB[0] RASSISTB[1] RASSISTB[2] RASSISTB[3] RBLRD RBLWA RBLWR RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_RD RWLB_SAC RWLB_WR RWLD_RD RWLD_WR RWL_RD
+   RWL_WR SDB_BC1T[0] SDB_BC1T[1] SDB_BC2T[0] SDB_BC2T[1] SDOR[0] SDOR[1]
+   SDOR_RET[0] SDOR_RET[1] T1T TEST_RNMB TOPEDGE[0] TOPEDGE[1] VBA[0] VBA[1]
+   VBN[0] VBN[1] VBN[2] VBP[0] VBP[1] VBP[2] VDDA[0] VDDA[1] VDDA[2] VDDMINB
+   VDDP[0] VDDP[1] VDDP[2] VDDPI[0] VDDPI[1] VDDPI[2] VDDWL[0] VDDWL[1] VSS[0]
+   VSS[1] VSS[2] WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3]
+   WPBUF[0] WPBUF[1] WPBUF[2] SNPS_SP_HD_16Kx8_ref_cnt_2
X_ref_rt_rwl BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] LLSB[1] LOG0[3] LOG1[3] QB[0]
+   QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5]
+   QT[6] SDB_BC1T[1] SDB_BC2T[1] SDOR[1] SDOR_RET[1] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8]
+   VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBP[3] VBP[4] VBP[5] VBP[6]
+   VBP[7] VBP[8] VBP[9] VDDA[2] VDDAI[0] VDDAI[1] VDDAI[2] VDDAI[3] VDDAI[4]
+   VDDAI[5] VDDAI[6] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9]
+   VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VSS[3] VSS[4]
+   VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   SNPS_SP_HD_16Kx8_ref_rt_rwl_2
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_rt_log0_2 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] LLSB LOG0 LOG1 QB[0] QB[1] QB[2]
+       QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+       QT[7] SDB_BC1T SDB_BC2T SDOR SDOR_RET SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+       SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+       VBA[7] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBP[0]
+       VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VDDA VDDAI[0] VDDAI[1]
+       VDDAI[2] VDDAI[3] VDDAI[4] VDDAI[5] VDDAI[6] VDDAI[7] VDDP[0] VDDP[1]
+       VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDPI[0] VDDPI[1]
+       VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VSS[0] VSS[1]
+       VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] WBI[0] WBI[1] WBI[2] WBI[3]
+       WBI[4] WBI[5] WBI[6] WBI[7] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+       WTI[6] WTI[7]

*** Jumper Report ***
* Jumper: VBA[0] VSS[0]
* Jumper: VBA[1] VSS[1]
* Jumper: VBA[2] VSS[2]
* Jumper: VBA[3] VSS[3]
* Jumper: VBA[4] VSS[4]
* Jumper: VBA[5] VSS[5]
* Jumper: VBA[6] VSS[6]
* Jumper: VBA[7] VSS[7]

X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_S0 VDDA VDDAI[0] VDDP[0] VDDPI[0] VSS[0]
+   VBP[0] VBN[0] BB[0] BB[1] BB[2] BB[3] LOG0 LOG1 QB[0] QT[0] SDOR SDOR_RET
+   SEL[0] VBA[0] WBI[0] WTI[0] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_S1 VDDA VDDAI[1] VDDP[1] VDDPI[1] VSS[1]
+   VBP[1] VBN[1] BB[4] BB[5] BB[6] BB[7] LOG0 LOG1 QB[1] QT[1] SDOR SDOR_RET
+   SEL[1] VBA[1] WBI[1] WTI[1] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_S2 VDDA VDDAI[2] VDDP[2] VDDPI[2] VSS[2]
+   VBP[2] VBN[2] BB[8] BB[9] BB[10] BB[11] LOG0 LOG1 QB[2] QT[2] SDOR SDOR_RET
+   SEL[2] VBA[2] WBI[2] WTI[2] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_S3 VDDA VDDAI[3] VDDP[3] VDDPI[3] VSS[3]
+   VBP[3] VBN[3] BB[12] BB[13] BB[14] BB[15] LOG0 LOG1 QB[3] QT[3] SDOR
+   SDOR_RET SEL[3] VBA[3] WBI[3] WTI[3] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_F3 VDDA VDDAI[4] VDDP[4] VDDPI[4] VSS[4]
+   VBP[4] VBN[4] BB[16] BB[17] BB[18] BB[19] LOG0 LOG1 QB[4] QT[4] SDOR
+   SDOR_RET SEL[4] VBA[4] WBI[4] WTI[4] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_F2 VDDA VDDAI[5] VDDP[5] VDDPI[5] VSS[5]
+   VBP[5] VBN[5] BB[20] BB[21] BB[22] BB[23] LOG0 LOG1 QB[5] QT[5] SDOR
+   SDOR_RET SEL[5] VBA[5] WBI[5] WTI[5] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_F1 VDDA VDDAI[6] VDDP[6] VDDPI[6] VSS[6]
+   VBP[6] VBN[6] BB[24] BB[25] BB[26] BB[27] LOG0 LOG1 QB[6] QT[6] SDOR
+   SDOR_RET SEL[6] VBA[6] WBI[6] WTI[6] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2_F0 VDDA VDDAI[7] VDDP[7] VDDPI[7] VSS[7]
+   VBP[7] VBN[7] BB[28] BB[29] BB[30] BB[31] LOG0 LOG1 QB[7] QT[7] SDOR
+   SDOR_RET SEL[7] VBA[7] WBI[7] WTI[7] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1_wk_bk2
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_row_mx_4 ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+       ARYSD_BC2[1] ARYSD_IN[0] ARYSD_IN[1] ARYSD_TOP[0] ARYSD_TOP[1] BB[0]
+       BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11]
+       BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+       BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31]
+       BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41]
+       BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51]
+       BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61]
+       BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+       BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81]
+       BB[82] BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91]
+       BB[92] BB[93] BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101]
+       BB[102] BB[103] BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110]
+       BB[111] BB[112] BB[113] BB[114] BB[115] BB[116] BB[117] BB[118] BB[119]
+       BB[120] BB[121] BB[122] BB[123] BB[124] BB[125] BB[126] BB[127] CENDP
+       DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR0 LBKADR1
+       LCGTH[0] LCGTH[1] LDFTX LITESLP LLBKADRB[0] LLBKADRB[1] LMATCHB
+       LMATCHB_I LOG0[0] LOG0[1] LOG1[0] LOG1[1] LWEIB LXADR[0] LXADR[1]
+       LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+       PGIOI[0] PGIOI[1] PLBKADR[0] PLBKADR[1] QB[0] QB[1] QB[2] QB[3] QB[4]
+       QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15]
+       QB[16] QB[17] QB[18] QB[19] QB[20] QB[21] QB[22] QB[23] QB[24] QB[25]
+       QB[26] QB[27] QB[28] QB[29] QB[30] QB[31] QT[0] QT[1] QT[2] QT[3] QT[4]
+       QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15]
+       QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+       QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] RASSIST[0] RASSIST[1]
+       RASSIST[2] RASSIST[3] RASSISTB[0] RASSISTB[1] RASSISTB[2] RASSISTB[3]
+       RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC SEL[0]
+       SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10]
+       SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] SEL[16] SEL[17] SEL[18] SEL[19]
+       SEL[20] SEL[21] SEL[22] SEL[23] SEL[24] SEL[25] SEL[26] SEL[27] SEL[28]
+       SEL[29] SEL[30] SEL[31] T1T TEST_RNMB TOPEDGE[0] TOPEDGE[1] TOPEDGE[2]
+       TOPEDGE[3] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+       VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+       VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23] VBA[24] VBA[25]
+       VBA[26] VBA[27] VBA[28] VBA[29] VBA[30] VBA[31] VBA[32] VBA[33] VBA[34]
+       VBA[35] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+       VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+       VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+       VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+       VBN[36] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8]
+       VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VBP[17]
+       VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25] VBP[26]
+       VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32] VBP[33] VBP[34] VBP[35]
+       VBP[36] VDDA[0] VDDA[1] VDDA[2] VDDAIL1 VDDAIR1 VDDMINB VDDP[0] VDDP[1]
+       VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+       VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+       VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+       VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+       VDDP[35] VDDP[36] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5]
+       VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+       VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19]
+       VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26]
+       VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33]
+       VDDPI[34] VDDPI[35] VDDPI[36] VDDWL[0] VDDWL[1] VEDGE[0] VEDGE[1] VSS[0]
+       VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+       VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19]
+       VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28]
+       VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34] VSS[35] VSS[36] WABUF[0]
+       WABUF[1] WABUF[2] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+       WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+       WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24]
+       WBI[25] WBI[26] WBI[27] WBI[28] WBI[29] WBI[30] WBI[31] WMT[0] WMT[1]
+       WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WTI[0] WTI[1] WTI[2] WTI[3]
+       WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12]
+       WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21]
+       WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27] WTI[28] WTI[29] WTI[30]
+       WTI[31]

*** Jumper Report ***
* Jumper: LOG1[1] PGIOI[1]
* Jumper: VBA[26] VSS[27]

X_ref_lt BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] LLSB[0]
+   LOG0[0] LOG1[0] PGIOI[0] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7]
+   QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] SDB_BC1T[0] SDB_BC2T[0] SDOR[0] SDOR_RET[0] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+   SEL[13] SEL[14] SEL[15] TOPEDGE[0] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDAIL1 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1]
+   VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9]
+   VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16]
+   VEDGE[0] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+   VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1]
+   WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11]
+   WBI[12] WBI[13] WBI[14] WBI[15] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ref_lt_2
X_ref_cnt_rt_rwl ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1] ARYSD_IN[0]
+   ARYSD_IN[1] ARYSD_TOP[0] ARYSD_TOP[1] BB[64] BB[65] BB[66] BB[67] BB[68]
+   BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79]
+   BB[80] BB[81] BB[82] BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90]
+   BB[91] CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR0
+   LBKADR1 LCGTH[0] LCGTH[1] LDFTX LITESLP LLBKADRB[0] LLBKADRB[1] LLSB[0]
+   LLSB[1] LMATCHB LMATCHB_I LOG0[0] LOG0[0] LOG0[0] LOG0[1] LOG1[0] LOG1[0]
+   LOG1[0] LOG1[1] LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+   LXADR[6] LXADR[7] LYADR[0] LYADR[1] PLBKADR[0] PLBKADR[1] QB[16] QB[17]
+   QB[18] QB[19] QB[20] QB[21] QB[22] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21]
+   QT[22] RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RASSISTB[0] RASSISTB[1]
+   RASSISTB[2] RASSISTB[3] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3]
+   RWLB_SAC SDB_BC1T[0] SDB_BC1T[1] SDB_BC2T[0] SDB_BC2T[1] SDOR[0] SDOR[1]
+   SDOR_RET[0] SDOR_RET[1] SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21]
+   SEL[22] T1T TEST_RNMB TOPEDGE[1] TOPEDGE[2] VBA[17] VBA[18] VBA[19] VBA[20]
+   VBA[21] VBA[22] VBA[23] VBA[24] VBA[25] VBN[17] VBN[18] VBN[19] VBN[20]
+   VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBP[17] VBP[18] VBP[19]
+   VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25] VBP[26] VDDA[0] VDDA[1]
+   VDDA[2] VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDMINB
+   VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24]
+   VDDP[25] VDDP[26] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21]
+   VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDWL[0] VDDWL[1] VSS[17]
+   VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26]
+   WABUF[0] WABUF[1] WABUF[2] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21]
+   WBI[22] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WTI[16]
+   WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22]
+   SNPS_SP_HD_16Kx8_ref_cnt_rt_rwl_2
X_mm16a05_u_hdsp_plus_rar4x1_wk_bk2 VDDA[2] VDDAIR1 VDDP[27] VDDPI[27] VSS[27]
+   VBP[27] VBN[27] BB[92] BB[93] BB[94] BB[95] LOG0[1] LOG1[1] QB[23] QT[23]
+   SDOR[1] SDOR_RET[1] SEL[23] VBA[26] WBI[23] WTI[23] LLSB[1] SDB_BC1T[1]
+   SDB_BC2T[1] mm16a05_u_hdsp_plus_rar4x1_wk_bk2
X_ref_rt_log0 BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103]
+   BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BB[112]
+   BB[113] BB[114] BB[115] BB[116] BB[117] BB[118] BB[119] BB[120] BB[121]
+   BB[122] BB[123] BB[124] BB[125] BB[126] BB[127] LLSB[1] LOG0[1] LOG1[1]
+   QB[24] QB[25] QB[26] QB[27] QB[28] QB[29] QB[30] QB[31] QT[24] QT[25] QT[26]
+   QT[27] QT[28] QT[29] QT[30] QT[31] SDB_BC1T[1] SDB_BC2T[1] SDOR[1]
+   SDOR_RET[1] SEL[24] SEL[25] SEL[26] SEL[27] SEL[28] SEL[29] SEL[30] SEL[31]
+   VBA[27] VBA[28] VBA[29] VBA[30] VBA[31] VBA[32] VBA[33] VBA[34] VBN[28]
+   VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35] VBP[28] VBP[29]
+   VBP[30] VBP[31] VBP[32] VBP[33] VBP[34] VBP[35] VDDA[2] VDDAIR1 VDDAIR1
+   VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDP[28] VDDP[29] VDDP[30]
+   VDDP[31] VDDP[32] VDDP[33] VDDP[34] VDDP[35] VDDPI[28] VDDPI[29] VDDPI[30]
+   VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VSS[28] VSS[29] VSS[30]
+   VSS[31] VSS[32] VSS[33] VSS[34] VSS[35] WBI[24] WBI[25] WBI[26] WBI[27]
+   WBI[28] WBI[29] WBI[30] WBI[31] WTI[24] WTI[25] WTI[26] WTI[27] WTI[28]
+   WTI[29] WTI[30] WTI[31] SNPS_SP_HD_16Kx8_ref_rt_log0_2
X_mm16a05_u_hdsp_plus_pg_pwedge_wk_bk2 VDDA[2] VDDP[36] VDDPI[36] VSS[36]
+   VBP[36] VBN[36] LOG0[1] LOG1[1] PGIOI[1] PO SDOR_RET[1] TOPEDGE[3] VBA[35]
+   VEDGE[1] SDOR[1] mm16a05_u_hdsp_plus_pg_pwedge
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_samp_1 BYPASS BYPASS_RET LCGTH LOG0 LOG1 QBOUT[0]
+       QBOUT[1] QBOUT[2] QBOUT[3] QB_IN[0] QB_IN[1] QB_IN[2] QB_IN[3]
+       QB_NANDIN[0] QB_NANDIN[1] QB_NANDIN[2] QB_NANDIN[3] QTOUT[0] QTOUT[1]
+       QTOUT[2] QTOUT[3] QT_IN[0] QT_IN[1] QT_IN[2] QT_IN[3] QT_NANDIN[0]
+       QT_NANDIN[1] QT_NANDIN[2] QT_NANDIN[3] RASSISTT[0] RASSISTT[1] RB[0]
+       RB[1] RB[2] RB[3] RT[0] RT[1] RT[2] RT[3] SAEB SAED SAPRB SEL[0] SEL[1]
+       SEL[2] SEL[3] VBN[0] VBN[1] VBN[2] VBN[3] VBP[0] VBP[1] VBP[2] VBP[3]
+       VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+       VSS[0] VSS[1] VSS[2] VSS[3] VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3]
+       WB[0] WB[1] WB[2] WB[3] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WT[0] WT[1]
+       WT[2] WT[3] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3]

*** Jumper Report ***
* Jumper: LOG1 QB_NANDIN[0] QB_NANDIN[1] QB_NANDIN[2] QB_NANDIN[3] QT_NANDIN[0] QT_NANDIN[1] QT_NANDIN[2] QT_NANDIN[3]
* Jumper: VDDP[0] VDDPI[0]
* Jumper: VDDP[1] VDDPI[1]
* Jumper: VDDP[2] VDDPI[2]
* Jumper: VDDP[3] VDDPI[3]

X_mm16a05_u_hdsp_plus_sacm4x1_nand_S0 VDDP[0] VDDPI[0] VSS[0] VSS_WA[0] VBP[0]
+   VBN[0] QBOUT[0] QTOUT[0] BYPASS BYPASS_RET LCGTH LOG0 LOG1 RASSISTT[0]
+   RASSISTT[1] RB[0] RT[0] SAED WB[0] WB_IN[0] WT[0] WT_IN[0] QB_IN[0]
+   QB_NANDIN[0] QT_IN[0] QT_NANDIN[0] SAEB SAPRB SEL[0]
+   mm16a05_u_hdsp_plus_sacm4x1_nand
X_mm16a05_u_hdsp_plus_sacm4x1_nand_S1 VDDP[1] VDDPI[1] VSS[1] VSS_WA[1] VBP[1]
+   VBN[1] QBOUT[1] QTOUT[1] BYPASS BYPASS_RET LCGTH LOG0 LOG1 RASSISTT[0]
+   RASSISTT[1] RB[1] RT[1] SAED WB[1] WB_IN[1] WT[1] WT_IN[1] QB_IN[1]
+   QB_NANDIN[1] QT_IN[1] QT_NANDIN[1] SAEB SAPRB SEL[1]
+   mm16a05_u_hdsp_plus_sacm4x1_nand
X_mm16a05_u_hdsp_plus_sacm4x1_nand_F1 VDDP[2] VDDPI[2] VSS[2] VSS_WA[2] VBP[2]
+   VBN[2] QBOUT[2] QTOUT[2] BYPASS BYPASS_RET LCGTH LOG0 LOG1 RASSISTT[0]
+   RASSISTT[1] RB[2] RT[2] SAED WB[2] WB_IN[2] WT[2] WT_IN[2] QB_IN[2]
+   QB_NANDIN[2] QT_IN[2] QT_NANDIN[2] SAEB SAPRB SEL[2]
+   mm16a05_u_hdsp_plus_sacm4x1_nand
X_mm16a05_u_hdsp_plus_sacm4x1_nand_F0 VDDP[3] VDDPI[3] VSS[3] VSS_WA[3] VBP[3]
+   VBN[3] QBOUT[3] QTOUT[3] BYPASS BYPASS_RET LCGTH LOG0 LOG1 RASSISTT[0]
+   RASSISTT[1] RB[3] RT[3] SAED WB[3] WB_IN[3] WT[3] WT_IN[3] QB_IN[3]
+   QB_NANDIN[3] QT_IN[3] QT_NANDIN[3] SAEB SAPRB SEL[3]
+   mm16a05_u_hdsp_plus_sacm4x1_nand
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_sac_lt_seg1_1 BYPASS BYPASS_RET LCGTH LOG0 LOG1
+       QBOUT[0] QBOUT[1] QBOUT[2] QBOUT[3] QBOUT[4] QBOUT[5] QBOUT[6] QBOUT[7]
+       QBOUT[8] QBOUT[9] QBOUT[10] QBOUT[11] QBOUT[12] QBOUT[13] QBOUT[14]
+       QBOUT[15] QB_IN[0] QB_IN[1] QB_IN[2] QB_IN[3] QB_IN[4] QB_IN[5] QB_IN[6]
+       QB_IN[7] QB_IN[8] QB_IN[9] QB_IN[10] QB_IN[11] QB_IN[12] QB_IN[13]
+       QB_IN[14] QB_IN[15] QB_NANDIN[0] QB_NANDIN[1] QB_NANDIN[2] QB_NANDIN[3]
+       QB_NANDIN[4] QB_NANDIN[5] QB_NANDIN[6] QB_NANDIN[7] QB_NANDIN[8]
+       QB_NANDIN[9] QB_NANDIN[10] QB_NANDIN[11] QB_NANDIN[12] QB_NANDIN[13]
+       QB_NANDIN[14] QB_NANDIN[15] QTOUT[0] QTOUT[1] QTOUT[2] QTOUT[3] QTOUT[4]
+       QTOUT[5] QTOUT[6] QTOUT[7] QTOUT[8] QTOUT[9] QTOUT[10] QTOUT[11]
+       QTOUT[12] QTOUT[13] QTOUT[14] QTOUT[15] QT_IN[0] QT_IN[1] QT_IN[2]
+       QT_IN[3] QT_IN[4] QT_IN[5] QT_IN[6] QT_IN[7] QT_IN[8] QT_IN[9] QT_IN[10]
+       QT_IN[11] QT_IN[12] QT_IN[13] QT_IN[14] QT_IN[15] QT_NANDIN[0]
+       QT_NANDIN[1] QT_NANDIN[2] QT_NANDIN[3] QT_NANDIN[4] QT_NANDIN[5]
+       QT_NANDIN[6] QT_NANDIN[7] QT_NANDIN[8] QT_NANDIN[9] QT_NANDIN[10]
+       QT_NANDIN[11] QT_NANDIN[12] QT_NANDIN[13] QT_NANDIN[14] QT_NANDIN[15]
+       RASSISTT[0] RASSISTT[1] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7]
+       RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RT[0] RT[1] RT[2]
+       RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13]
+       RT[14] RT[15] SAEB SAED SAPRB SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5]
+       SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14]
+       SEL[15] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+       VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBP[0] VBP[1]
+       VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+       VBP[12] VBP[13] VBP[14] VBP[15] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+       VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+       VDDP[13] VDDP[14] VDDP[15] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+       VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+       VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VSS[0] VSS[1] VSS[2] VSS[3]
+       VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+       VSS[13] VSS[14] VSS[15] VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3]
+       VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7] VSS_WA[8] VSS_WA[9] VSS_WA[10]
+       VSS_WA[11] VSS_WA[12] VSS_WA[13] VSS_WA[14] VSS_WA[15] WB[0] WB[1] WB[2]
+       WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13]
+       WB[14] WB[15] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5]
+       WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12]
+       WB_IN[13] WB_IN[14] WB_IN[15] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6]
+       WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WT_IN[0]
+       WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8]
+       WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15]
X_samp_S0 BYPASS BYPASS_RET LCGTH LOG0 LOG1 QBOUT[0] QBOUT[1] QBOUT[2] QBOUT[3]
+   QB_IN[0] QB_IN[1] QB_IN[2] QB_IN[3] QB_NANDIN[0] QB_NANDIN[1] QB_NANDIN[2]
+   QB_NANDIN[3] QTOUT[0] QTOUT[1] QTOUT[2] QTOUT[3] QT_IN[0] QT_IN[1] QT_IN[2]
+   QT_IN[3] QT_NANDIN[0] QT_NANDIN[1] QT_NANDIN[2] QT_NANDIN[3] RASSISTT[0]
+   RASSISTT[1] RB[0] RB[1] RB[2] RB[3] RT[0] RT[1] RT[2] RT[3] SAEB SAED SAPRB
+   SEL[0] SEL[1] SEL[2] SEL[3] VBN[0] VBN[1] VBN[2] VBN[3] VBP[0] VBP[1] VBP[2]
+   VBP[3] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VSS[0] VSS[1] VSS[2] VSS[3] VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3] WB[0]
+   WB[1] WB[2] WB[3] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WT[0] WT[1] WT[2]
+   WT[3] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] SNPS_SP_HD_16Kx8_samp_1
X_samp_S1 BYPASS BYPASS_RET LCGTH LOG0 LOG1 QBOUT[4] QBOUT[5] QBOUT[6] QBOUT[7]
+   QB_IN[4] QB_IN[5] QB_IN[6] QB_IN[7] QB_NANDIN[4] QB_NANDIN[5] QB_NANDIN[6]
+   QB_NANDIN[7] QTOUT[4] QTOUT[5] QTOUT[6] QTOUT[7] QT_IN[4] QT_IN[5] QT_IN[6]
+   QT_IN[7] QT_NANDIN[4] QT_NANDIN[5] QT_NANDIN[6] QT_NANDIN[7] RASSISTT[0]
+   RASSISTT[1] RB[4] RB[5] RB[6] RB[7] RT[4] RT[5] RT[6] RT[7] SAEB SAED SAPRB
+   SEL[4] SEL[5] SEL[6] SEL[7] VBN[4] VBN[5] VBN[6] VBN[7] VBP[4] VBP[5] VBP[6]
+   VBP[7] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+   VSS[4] VSS[5] VSS[6] VSS[7] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7] WB[4]
+   WB[5] WB[6] WB[7] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WT[4] WT[5] WT[6]
+   WT[7] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] SNPS_SP_HD_16Kx8_samp_1
X_samp_F1 BYPASS BYPASS_RET LCGTH LOG0 LOG1 QBOUT[8] QBOUT[9] QBOUT[10]
+   QBOUT[11] QB_IN[8] QB_IN[9] QB_IN[10] QB_IN[11] QB_NANDIN[8] QB_NANDIN[9]
+   QB_NANDIN[10] QB_NANDIN[11] QTOUT[8] QTOUT[9] QTOUT[10] QTOUT[11] QT_IN[8]
+   QT_IN[9] QT_IN[10] QT_IN[11] QT_NANDIN[8] QT_NANDIN[9] QT_NANDIN[10]
+   QT_NANDIN[11] RASSISTT[0] RASSISTT[1] RB[8] RB[9] RB[10] RB[11] RT[8] RT[9]
+   RT[10] RT[11] SAEB SAED SAPRB SEL[8] SEL[9] SEL[10] SEL[11] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBP[8] VBP[9] VBP[10] VBP[11] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VSS[8] VSS[9] VSS[10] VSS[11]
+   VSS_WA[8] VSS_WA[9] VSS_WA[10] VSS_WA[11] WB[8] WB[9] WB[10] WB[11] WB_IN[8]
+   WB_IN[9] WB_IN[10] WB_IN[11] WT[8] WT[9] WT[10] WT[11] WT_IN[8] WT_IN[9]
+   WT_IN[10] WT_IN[11] SNPS_SP_HD_16Kx8_samp_1
X_samp_F0 BYPASS BYPASS_RET LCGTH LOG0 LOG1 QBOUT[12] QBOUT[13] QBOUT[14]
+   QBOUT[15] QB_IN[12] QB_IN[13] QB_IN[14] QB_IN[15] QB_NANDIN[12]
+   QB_NANDIN[13] QB_NANDIN[14] QB_NANDIN[15] QTOUT[12] QTOUT[13] QTOUT[14]
+   QTOUT[15] QT_IN[12] QT_IN[13] QT_IN[14] QT_IN[15] QT_NANDIN[12]
+   QT_NANDIN[13] QT_NANDIN[14] QT_NANDIN[15] RASSISTT[0] RASSISTT[1] RB[12]
+   RB[13] RB[14] RB[15] RT[12] RT[13] RT[14] RT[15] SAEB SAED SAPRB SEL[12]
+   SEL[13] SEL[14] SEL[15] VBN[12] VBN[13] VBN[14] VBN[15] VBP[12] VBP[13]
+   VBP[14] VBP[15] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDPI[12] VDDPI[13]
+   VDDPI[14] VDDPI[15] VSS[12] VSS[13] VSS[14] VSS[15] VSS_WA[12] VSS_WA[13]
+   VSS_WA[14] VSS_WA[15] WB[12] WB[13] WB[14] WB[15] WB_IN[12] WB_IN[13]
+   WB_IN[14] WB_IN[15] WT[12] WT[13] WT[14] WT[15] WT_IN[12] WT_IN[13]
+   WT_IN[14] WT_IN[15] SNPS_SP_HD_16Kx8_samp_1
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_sac_lt_1 BYPASS BYPASS_RET LCGTH LOG0 LOG1 PWDO
+       QBOUT[0] QBOUT[1] QBOUT[2] QBOUT[3] QBOUT[4] QBOUT[5] QBOUT[6] QBOUT[7]
+       QBOUT[8] QBOUT[9] QBOUT[10] QBOUT[11] QBOUT[12] QBOUT[13] QBOUT[14]
+       QBOUT[15] QB_IN[0] QB_IN[1] QB_IN[2] QB_IN[3] QB_IN[4] QB_IN[5] QB_IN[6]
+       QB_IN[7] QB_IN[8] QB_IN[9] QB_IN[10] QB_IN[11] QB_IN[12] QB_IN[13]
+       QB_IN[14] QB_IN[15] QB_NANDIN[0] QB_NANDIN[1] QB_NANDIN[2] QB_NANDIN[3]
+       QB_NANDIN[4] QB_NANDIN[5] QB_NANDIN[6] QB_NANDIN[7] QB_NANDIN[8]
+       QB_NANDIN[9] QB_NANDIN[10] QB_NANDIN[11] QB_NANDIN[12] QB_NANDIN[13]
+       QB_NANDIN[14] QB_NANDIN[15] QTOUT[0] QTOUT[1] QTOUT[2] QTOUT[3] QTOUT[4]
+       QTOUT[5] QTOUT[6] QTOUT[7] QTOUT[8] QTOUT[9] QTOUT[10] QTOUT[11]
+       QTOUT[12] QTOUT[13] QTOUT[14] QTOUT[15] QT_IN[0] QT_IN[1] QT_IN[2]
+       QT_IN[3] QT_IN[4] QT_IN[5] QT_IN[6] QT_IN[7] QT_IN[8] QT_IN[9] QT_IN[10]
+       QT_IN[11] QT_IN[12] QT_IN[13] QT_IN[14] QT_IN[15] QT_NANDIN[0]
+       QT_NANDIN[1] QT_NANDIN[2] QT_NANDIN[3] QT_NANDIN[4] QT_NANDIN[5]
+       QT_NANDIN[6] QT_NANDIN[7] QT_NANDIN[8] QT_NANDIN[9] QT_NANDIN[10]
+       QT_NANDIN[11] QT_NANDIN[12] QT_NANDIN[13] QT_NANDIN[14] QT_NANDIN[15]
+       RASSISTT[0] RASSISTT[1] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7]
+       RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RT[0] RT[1] RT[2]
+       RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13]
+       RT[14] RT[15] SAEB SAED SAPRB SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5]
+       SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14]
+       SEL[15] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+       VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0]
+       VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10]
+       VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDP[0] VDDP[1] VDDP[2]
+       VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+       VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1]
+       VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9]
+       VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16]
+       VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+       VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS_WA[0]
+       VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7]
+       VSS_WA[8] VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12] VSS_WA[13]
+       VSS_WA[14] VSS_WA[15] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7]
+       WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WB_IN[0] WB_IN[1]
+       WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9]
+       WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WT[0] WT[1]
+       WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12]
+       WT[13] WT[14] WT[15] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4]
+       WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11]
+       WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15]
X_mm16a05_u_hdsp_plus_capsac VDDP[0] VDDPI[0] VSS[0] VBP[0] VBN[0] SAED LOG0
+   LOG1 PWDO VEDGE SAEB mm16a05_u_hdsp_plus_capsac
X_sac_lt_seg1 BYPASS BYPASS_RET LCGTH LOG0 LOG1 QBOUT[0] QBOUT[1] QBOUT[2]
+   QBOUT[3] QBOUT[4] QBOUT[5] QBOUT[6] QBOUT[7] QBOUT[8] QBOUT[9] QBOUT[10]
+   QBOUT[11] QBOUT[12] QBOUT[13] QBOUT[14] QBOUT[15] QB_IN[0] QB_IN[1] QB_IN[2]
+   QB_IN[3] QB_IN[4] QB_IN[5] QB_IN[6] QB_IN[7] QB_IN[8] QB_IN[9] QB_IN[10]
+   QB_IN[11] QB_IN[12] QB_IN[13] QB_IN[14] QB_IN[15] QB_NANDIN[0] QB_NANDIN[1]
+   QB_NANDIN[2] QB_NANDIN[3] QB_NANDIN[4] QB_NANDIN[5] QB_NANDIN[6]
+   QB_NANDIN[7] QB_NANDIN[8] QB_NANDIN[9] QB_NANDIN[10] QB_NANDIN[11]
+   QB_NANDIN[12] QB_NANDIN[13] QB_NANDIN[14] QB_NANDIN[15] QTOUT[0] QTOUT[1]
+   QTOUT[2] QTOUT[3] QTOUT[4] QTOUT[5] QTOUT[6] QTOUT[7] QTOUT[8] QTOUT[9]
+   QTOUT[10] QTOUT[11] QTOUT[12] QTOUT[13] QTOUT[14] QTOUT[15] QT_IN[0]
+   QT_IN[1] QT_IN[2] QT_IN[3] QT_IN[4] QT_IN[5] QT_IN[6] QT_IN[7] QT_IN[8]
+   QT_IN[9] QT_IN[10] QT_IN[11] QT_IN[12] QT_IN[13] QT_IN[14] QT_IN[15]
+   QT_NANDIN[0] QT_NANDIN[1] QT_NANDIN[2] QT_NANDIN[3] QT_NANDIN[4]
+   QT_NANDIN[5] QT_NANDIN[6] QT_NANDIN[7] QT_NANDIN[8] QT_NANDIN[9]
+   QT_NANDIN[10] QT_NANDIN[11] QT_NANDIN[12] QT_NANDIN[13] QT_NANDIN[14]
+   QT_NANDIN[15] RASSISTT[0] RASSISTT[1] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5]
+   RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RT[0]
+   RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12]
+   RT[13] RT[14] RT[15] SAEB SAED SAPRB SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14]
+   SEL[15] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6]
+   VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14]
+   VDDP[15] VDDP[16] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6]
+   VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+   VDDPI[15] VDDPI[16] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+   VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS_WA[0]
+   VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7]
+   VSS_WA[8] VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12] VSS_WA[13] VSS_WA[14]
+   VSS_WA[15] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9]
+   WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WB_IN[0] WB_IN[1] WB_IN[2]
+   WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10]
+   WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WT[0] WT[1] WT[2] WT[3]
+   WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14]
+   WT[15] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6]
+   WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14]
+   WT_IN[15] SNPS_SP_HD_16Kx8_sac_lt_seg1_1
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_sac_cen_1 BYPASS BYP_VLOAD CENDP DEF_MODE ENLPGB FAST1B
+       FAST1_MODE FAST2_MODE FLOAT FLOATT FLOATT_PGM FLOAT_RET
+       FLOAT_RET_TIMER_PROG LBKADR[0] LBKADR[1] LBKADR[2] LCGTB LCGTHB LCGTHHV
+       LCGTHLV LCGTH_PCHG LDFTX LITESLP LLBKADRB[0] LLBKADRB[1] LLBKADRB[2]
+       LLBKADRT[0] LLBKADRT[1] LLBKADRT[2] LMATCH LMATCHB LMATCHB_I_BBK
+       LMATCHB_I_TBK LOG0 LOG1 LWEIB LWERD LWEWR LXADR[0] LXADR[1] LXADR[2]
+       LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+       PLBKADR[0] PLBKADR[1] PLBKADR[2] PLBKADRB PM[0] PM[1] PM[2] PM[3]
+       PRCKE_B PRCKE_T PRCLKB RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2]
+       RMT[3] RWLBHV RWLBLV RWLB_SAC SAEDL SAEDR SAET SAPRT T1T TEST_RNMB VBN
+       VBP VDDA VDDMINB VDDP VDDPI VSS WABUF[0] WABUF[1] WABUF[2]
+       WAPRCLKBUFB_RET WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]

*** Jumper Report ***
* Jumper: FLOAT_RET FLOAT_RET_TIMER_PROG PRCLKB
* Jumper: LBKADR[0] PLBKADR[0]
* Jumper: LBKADR[1] PLBKADR[1]
* Jumper: LCGTHHV LCGTHLV
* Jumper: LLBKADRB[0] PLBKADRB
* Jumper: LLBKADRB[2] PLBKADR[2]
* Jumper: LOG0 ENLPGB LBKADR[2] LDFTX
* Jumper: LOG1 FLOATT_PGM LMATCHB LMATCHB_I_BBK LMATCHB_I_TBK
* Jumper: RWLBHV RWLBLV
* Jumper: VDDA VDDP VDDPI

X_mm16a05_u_hdsp_plus_sactrl VDDA VDDMINB VDDP VDDPI VSS VBP VBN FAST1B LCGTB
+   LCGTHB LCGTHLV LCGTH_PCHG LLBKADRB[0] LLBKADRB[1] LLBKADRB[2] LLBKADRT[0]
+   LLBKADRT[1] LLBKADRT[2] LMATCH LWERD LWEWR PM[0] PM[1] PM[2] PM[3] PRCKE_B
+   PRCKE_T PRCLKB RWLBLV SAET SAPRT BYPASS BYP_VLOAD DEF_MODE FAST1_MODE
+   FAST2_MODE FLOAT FLOATT_PGM FLOAT_RET LOG0 LOG1 RBLRD RBLWA RBLWR RMT[0]
+   RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2]
+   WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] CENDP ENLPGB FLOATT
+   FLOAT_RET_TIMER_PROG LBKADR[0] LBKADR[1] LBKADR[2] LCGTHHV LDFTX LITESLP
+   LMATCHB LMATCHB_I_BBK LMATCHB_I_TBK LWEIB LXADR[0] LXADR[1] LXADR[2]
+   LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PLBKADR[0]
+   PLBKADR[1] PLBKADR[2] PLBKADRB RM3CNT RWLBHV SAEDL SAEDR WAPRCLKBUFB_RET
+   mm16a05_u_hdsp_plus_sactrl
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_sac_cnt_1 ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1]
+       ARYSD_BC2[0] ARYSD_BC2[1] BYPASS[0] BYPASS[1] BYPASS_RET[0]
+       BYPASS_RET[1] BYP_VLOAD CENDP DEF_MODE ENLPGB FAST1B FAST1_MODE
+       FAST2_MODE FLOAT FLOATT FLOATT_PGM FLOAT_RET FLOAT_RET_TIMER_PROG
+       LBKADR0 LBKADR1 LCGTH[0] LCGTH[1] LCGTH_PCHG LDFTX LITESLP LLBKADRB[0]
+       LLBKADRB[1] LLBKADRB[2] LLBKADRT[0] LLBKADRT[1] LLBKADRT[2] LMATCH
+       LMATCHB LMATCHB_I_BBK LMATCHB_I_TBK LOG0 LOG1 LWEIB LWERD LWEWR LXADR[0]
+       LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+       LYADR[1] PLBKADR[0] PLBKADR[1] PLBKADR[2] PLBKADRB PM[0] PM[1] PM[2]
+       PM[3] PRCKE_B PRCKE_T PRCLKB RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3]
+       RASSISTTH[0] RASSISTTH[1] RASSISTTL[0] RASSISTTL[1] RBLRD RBLWA RBLWR
+       RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC SAEBL SAEBR SAEDL SAEDR
+       SAPRB[0] SAPRB[1] T1T TEST_RNMB VBN[0] VBN[1] VBN[2] VBP[0] VBP[1]
+       VBP[2] VDDA[0] VDDA[1] VDDA[2] VDDMINB VDDP[0] VDDP[1] VDDP[2] VDDPI[0]
+       VDDPI[1] VDDPI[2] VSS[0] VSS[1] VSS[2] WABUF[0] WABUF[1] WABUF[2]
+       WAPRCLKBUFB_RET WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]

*** Jumper Report ***
* Jumper: LCGTHB LCGTHB_IN[0]
* Jumper: VDDA[0] VDDP[0] VDDPI[0]

X_mm16a05_u_hdsp_plus_sacbuf_left VDDA[0] VDDP[0] VDDPI[0] VSS[0] VBP[0] VBN[0]
+   LCGTH[0] SAEBL SAPRB[0] ARYSD[0] ARYSD_BC1[0] ARYSD_BC2[0] BYPASS[0]
+   BYPASS_RET[0] LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTTL[0] RASSISTTL[1]
+   SAEDL LCGTHB LCGTHB LCGTHHV SAET SAPRT mm16a05_u_hdsp_plus_sacbuf
X_sac_cen BYPASS[1] BYP_VLOAD CENDP DEF_MODE ENLPGB FAST1B FAST1_MODE FAST2_MODE
+   FLOAT FLOATT FLOATT_PGM FLOAT_RET FLOAT_RET_TIMER_PROG LBKADR0 LBKADR1 LOG0
+   LCGTB LCGTHB LCGTHHV LCGTHHV LCGTH_PCHG LDFTX LITESLP LLBKADRB[0]
+   LLBKADRB[1] LLBKADRB[2] LLBKADRT[0] LLBKADRT[1] LLBKADRT[2] LMATCH LMATCHB
+   LMATCHB_I_BBK LMATCHB_I_TBK LOG0 LOG1 LWEIB LWERD LWEWR LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PLBKADR[0] PLBKADR[1] PLBKADR[2] PLBKADRB PM[0] PM[1] PM[2] PM[3] PRCKE_B
+   PRCKE_T PRCLKB RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLBHV
+   RWLBHV RWLB_SAC SAEDL SAEDR SAET SAPRT T1T TEST_RNMB VBN[1] VBP[1] VDDA[1]
+   VDDMINB VDDP[1] VDDPI[1] VSS[1] WABUF[0] WABUF[1] WABUF[2] WAPRCLKBUFB_RET
+   WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]
+   SNPS_SP_HD_16Kx8_sac_cen_1
X_sac_buf ARYSD[1] ARYSD_BC1[1] ARYSD_BC2[1] BYPASS[1] BYPASS_RET[1] LCGTH[1]
+   LCGTHB LCGTHB LCGTHHV LOG0 LOG1 RASSIST[2] RASSIST[3] RASSISTTH[0]
+   RASSISTTH[1] SAEBR SAEDR SAET SAPRB[1] SAPRT VBN[2] VBP[2] VDDA[2] VDDP[2]
+   VDDPI[2] VSS[2] SNPS_SP_HD_16Kx8_sac_buf
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_sac_rt_1 BYPASS BYPASS_RET LCGTH LOG0 LOG1 PWDO
+       QBOUT[0] QBOUT[1] QBOUT[2] QBOUT[3] QBOUT[4] QBOUT[5] QBOUT[6] QBOUT[7]
+       QBOUT[8] QBOUT[9] QBOUT[10] QBOUT[11] QBOUT[12] QBOUT[13] QBOUT[14]
+       QBOUT[15] QB_IN[0] QB_IN[1] QB_IN[2] QB_IN[3] QB_IN[4] QB_IN[5] QB_IN[6]
+       QB_IN[7] QB_IN[8] QB_IN[9] QB_IN[10] QB_IN[11] QB_IN[12] QB_IN[13]
+       QB_IN[14] QB_IN[15] QB_NANDIN[0] QB_NANDIN[1] QB_NANDIN[2] QB_NANDIN[3]
+       QB_NANDIN[4] QB_NANDIN[5] QB_NANDIN[6] QB_NANDIN[7] QB_NANDIN[8]
+       QB_NANDIN[9] QB_NANDIN[10] QB_NANDIN[11] QB_NANDIN[12] QB_NANDIN[13]
+       QB_NANDIN[14] QB_NANDIN[15] QTOUT[0] QTOUT[1] QTOUT[2] QTOUT[3] QTOUT[4]
+       QTOUT[5] QTOUT[6] QTOUT[7] QTOUT[8] QTOUT[9] QTOUT[10] QTOUT[11]
+       QTOUT[12] QTOUT[13] QTOUT[14] QTOUT[15] QT_IN[0] QT_IN[1] QT_IN[2]
+       QT_IN[3] QT_IN[4] QT_IN[5] QT_IN[6] QT_IN[7] QT_IN[8] QT_IN[9] QT_IN[10]
+       QT_IN[11] QT_IN[12] QT_IN[13] QT_IN[14] QT_IN[15] QT_NANDIN[0]
+       QT_NANDIN[1] QT_NANDIN[2] QT_NANDIN[3] QT_NANDIN[4] QT_NANDIN[5]
+       QT_NANDIN[6] QT_NANDIN[7] QT_NANDIN[8] QT_NANDIN[9] QT_NANDIN[10]
+       QT_NANDIN[11] QT_NANDIN[12] QT_NANDIN[13] QT_NANDIN[14] QT_NANDIN[15]
+       RASSISTT[0] RASSISTT[1] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7]
+       RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RT[0] RT[1] RT[2]
+       RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13]
+       RT[14] RT[15] SAEB SAED SAPRB SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5]
+       SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14]
+       SEL[15] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+       VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0]
+       VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10]
+       VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDP[0] VDDP[1] VDDP[2]
+       VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+       VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1]
+       VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9]
+       VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16]
+       VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+       VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS_WA[0]
+       VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7]
+       VSS_WA[8] VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12] VSS_WA[13]
+       VSS_WA[14] VSS_WA[15] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7]
+       WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WB_IN[0] WB_IN[1]
+       WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9]
+       WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WT[0] WT[1]
+       WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12]
+       WT[13] WT[14] WT[15] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4]
+       WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11]
+       WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15]
X_sac_lt_seg1 BYPASS BYPASS_RET LCGTH LOG0 LOG1 QBOUT[0] QBOUT[1] QBOUT[2]
+   QBOUT[3] QBOUT[4] QBOUT[5] QBOUT[6] QBOUT[7] QBOUT[8] QBOUT[9] QBOUT[10]
+   QBOUT[11] QBOUT[12] QBOUT[13] QBOUT[14] QBOUT[15] QB_IN[0] QB_IN[1] QB_IN[2]
+   QB_IN[3] QB_IN[4] QB_IN[5] QB_IN[6] QB_IN[7] QB_IN[8] QB_IN[9] QB_IN[10]
+   QB_IN[11] QB_IN[12] QB_IN[13] QB_IN[14] QB_IN[15] QB_NANDIN[0] QB_NANDIN[1]
+   QB_NANDIN[2] QB_NANDIN[3] QB_NANDIN[4] QB_NANDIN[5] QB_NANDIN[6]
+   QB_NANDIN[7] QB_NANDIN[8] QB_NANDIN[9] QB_NANDIN[10] QB_NANDIN[11]
+   QB_NANDIN[12] QB_NANDIN[13] QB_NANDIN[14] QB_NANDIN[15] QTOUT[0] QTOUT[1]
+   QTOUT[2] QTOUT[3] QTOUT[4] QTOUT[5] QTOUT[6] QTOUT[7] QTOUT[8] QTOUT[9]
+   QTOUT[10] QTOUT[11] QTOUT[12] QTOUT[13] QTOUT[14] QTOUT[15] QT_IN[0]
+   QT_IN[1] QT_IN[2] QT_IN[3] QT_IN[4] QT_IN[5] QT_IN[6] QT_IN[7] QT_IN[8]
+   QT_IN[9] QT_IN[10] QT_IN[11] QT_IN[12] QT_IN[13] QT_IN[14] QT_IN[15]
+   QT_NANDIN[0] QT_NANDIN[1] QT_NANDIN[2] QT_NANDIN[3] QT_NANDIN[4]
+   QT_NANDIN[5] QT_NANDIN[6] QT_NANDIN[7] QT_NANDIN[8] QT_NANDIN[9]
+   QT_NANDIN[10] QT_NANDIN[11] QT_NANDIN[12] QT_NANDIN[13] QT_NANDIN[14]
+   QT_NANDIN[15] RASSISTT[0] RASSISTT[1] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5]
+   RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RT[0]
+   RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12]
+   RT[13] RT[14] RT[15] SAEB SAED SAPRB SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14]
+   SEL[15] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBP[0] VBP[1] VBP[2]
+   VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+   VBP[13] VBP[14] VBP[15] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5]
+   VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14]
+   VDDP[15] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6]
+   VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+   VDDPI[15] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+   VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS_WA[0] VSS_WA[1]
+   VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7] VSS_WA[8]
+   VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12] VSS_WA[13] VSS_WA[14] VSS_WA[15]
+   WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11]
+   WB[12] WB[13] WB[14] WB[15] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4]
+   WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12]
+   WB_IN[13] WB_IN[14] WB_IN[15] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6]
+   WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WT_IN[0]
+   WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8]
+   WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15]
+   SNPS_SP_HD_16Kx8_sac_lt_seg1_1
X_mm16a05_u_hdsp_plus_capsac VDDP[16] VDDPI[16] VSS[16] VBP[16] VBN[16] SAED
+   LOG0 LOG1 PWDO VEDGE SAEB mm16a05_u_hdsp_plus_capsac
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_sac_row_4 ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1]
+       ARYSD_BC2[0] ARYSD_BC2[1] BYP_VLOAD CENDP DEF_MODE ENLPGB FAST1B
+       FAST1_MODE FAST2_MODE FLOAT FLOATT FLOATT_PGM FLOAT_RET
+       FLOAT_RET_TIMER_PROG LBKADR0 LBKADR1 LCGTH[0] LCGTH[1] LCGTH_PCHG LDFTX
+       LITESLP LLBKADRB[0] LLBKADRB[1] LLBKADRB[2] LLBKADRT[0] LLBKADRT[1]
+       LLBKADRT[2] LMATCH LMATCHB LMATCHB_I_BBK LMATCHB_I_TBK LOG0 LOG1 LWEIB
+       LWERD LWEWR LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+       LXADR[6] LXADR[7] LYADR[0] LYADR[1] PLBKADR[0] PLBKADR[1] PLBKADR[2]
+       PLBKADRB PM[0] PM[1] PM[2] PM[3] PRCKE_B PRCKE_T PRCLKB PWDO[0] PWDO[1]
+       QBOUT[0] QBOUT[1] QBOUT[2] QBOUT[3] QBOUT[4] QBOUT[5] QBOUT[6] QBOUT[7]
+       QBOUT[8] QBOUT[9] QBOUT[10] QBOUT[11] QBOUT[12] QBOUT[13] QBOUT[14]
+       QBOUT[15] QBOUT[16] QBOUT[17] QBOUT[18] QBOUT[19] QBOUT[20] QBOUT[21]
+       QBOUT[22] QBOUT[23] QBOUT[24] QBOUT[25] QBOUT[26] QBOUT[27] QBOUT[28]
+       QBOUT[29] QBOUT[30] QBOUT[31] QB_IN[0] QB_IN[1] QB_IN[2] QB_IN[3]
+       QB_IN[4] QB_IN[5] QB_IN[6] QB_IN[7] QB_IN[8] QB_IN[9] QB_IN[10]
+       QB_IN[11] QB_IN[12] QB_IN[13] QB_IN[14] QB_IN[15] QB_IN[16] QB_IN[17]
+       QB_IN[18] QB_IN[19] QB_IN[20] QB_IN[21] QB_IN[22] QB_IN[23] QB_IN[24]
+       QB_IN[25] QB_IN[26] QB_IN[27] QB_IN[28] QB_IN[29] QB_IN[30] QB_IN[31]
+       QB_NANDIN[0] QB_NANDIN[1] QB_NANDIN[2] QB_NANDIN[3] QB_NANDIN[4]
+       QB_NANDIN[5] QB_NANDIN[6] QB_NANDIN[7] QB_NANDIN[8] QB_NANDIN[9]
+       QB_NANDIN[10] QB_NANDIN[11] QB_NANDIN[12] QB_NANDIN[13] QB_NANDIN[14]
+       QB_NANDIN[15] QB_NANDIN[16] QB_NANDIN[17] QB_NANDIN[18] QB_NANDIN[19]
+       QB_NANDIN[20] QB_NANDIN[21] QB_NANDIN[22] QB_NANDIN[23] QB_NANDIN[24]
+       QB_NANDIN[25] QB_NANDIN[26] QB_NANDIN[27] QB_NANDIN[28] QB_NANDIN[29]
+       QB_NANDIN[30] QB_NANDIN[31] QTOUT[0] QTOUT[1] QTOUT[2] QTOUT[3] QTOUT[4]
+       QTOUT[5] QTOUT[6] QTOUT[7] QTOUT[8] QTOUT[9] QTOUT[10] QTOUT[11]
+       QTOUT[12] QTOUT[13] QTOUT[14] QTOUT[15] QTOUT[16] QTOUT[17] QTOUT[18]
+       QTOUT[19] QTOUT[20] QTOUT[21] QTOUT[22] QTOUT[23] QTOUT[24] QTOUT[25]
+       QTOUT[26] QTOUT[27] QTOUT[28] QTOUT[29] QTOUT[30] QTOUT[31] QT_IN[0]
+       QT_IN[1] QT_IN[2] QT_IN[3] QT_IN[4] QT_IN[5] QT_IN[6] QT_IN[7] QT_IN[8]
+       QT_IN[9] QT_IN[10] QT_IN[11] QT_IN[12] QT_IN[13] QT_IN[14] QT_IN[15]
+       QT_IN[16] QT_IN[17] QT_IN[18] QT_IN[19] QT_IN[20] QT_IN[21] QT_IN[22]
+       QT_IN[23] QT_IN[24] QT_IN[25] QT_IN[26] QT_IN[27] QT_IN[28] QT_IN[29]
+       QT_IN[30] QT_IN[31] QT_NANDIN[0] QT_NANDIN[1] QT_NANDIN[2] QT_NANDIN[3]
+       QT_NANDIN[4] QT_NANDIN[5] QT_NANDIN[6] QT_NANDIN[7] QT_NANDIN[8]
+       QT_NANDIN[9] QT_NANDIN[10] QT_NANDIN[11] QT_NANDIN[12] QT_NANDIN[13]
+       QT_NANDIN[14] QT_NANDIN[15] QT_NANDIN[16] QT_NANDIN[17] QT_NANDIN[18]
+       QT_NANDIN[19] QT_NANDIN[20] QT_NANDIN[21] QT_NANDIN[22] QT_NANDIN[23]
+       QT_NANDIN[24] QT_NANDIN[25] QT_NANDIN[26] QT_NANDIN[27] QT_NANDIN[28]
+       QT_NANDIN[29] QT_NANDIN[30] QT_NANDIN[31] RASSIST[0] RASSIST[1]
+       RASSIST[2] RASSIST[3] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7]
+       RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RB[16] RB[17]
+       RB[18] RB[19] RB[20] RB[21] RB[22] RB[23] RB[24] RB[25] RB[26] RB[27]
+       RB[28] RB[29] RB[30] RB[31] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1]
+       RMT[2] RMT[3] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8]
+       RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15] RT[16] RT[17] RT[18]
+       RT[19] RT[20] RT[21] RT[22] RT[23] RT[24] RT[25] RT[26] RT[27] RT[28]
+       RT[29] RT[30] RT[31] RWLB_SAC SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5]
+       SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14]
+       SEL[15] SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21] SEL[22] SEL[23]
+       SEL[24] SEL[25] SEL[26] SEL[27] SEL[28] SEL[29] SEL[30] SEL[31] T1T
+       TEST_RNMB VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+       VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+       VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+       VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+       VBN[36] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8]
+       VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VBP[17]
+       VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25] VBP[26]
+       VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32] VBP[33] VBP[34] VBP[35]
+       VBP[36] VDDA[0] VDDA[1] VDDA[2] VDDMINB VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+       VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11]
+       VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19]
+       VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27]
+       VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34] VDDP[35]
+       VDDP[36] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6]
+       VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13]
+       VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20]
+       VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27]
+       VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34]
+       VDDPI[35] VDDPI[36] VEDGE[0] VEDGE[1] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4]
+       VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13]
+       VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22]
+       VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31]
+       VSS[32] VSS[33] VSS[34] VSS[35] VSS[36] VSS_WA[0] VSS_WA[1] VSS_WA[2]
+       VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7] VSS_WA[8] VSS_WA[9]
+       VSS_WA[10] VSS_WA[11] VSS_WA[12] VSS_WA[13] VSS_WA[14] VSS_WA[15]
+       VSS_WA[16] VSS_WA[17] VSS_WA[18] VSS_WA[19] VSS_WA[20] VSS_WA[21]
+       VSS_WA[22] VSS_WA[23] VSS_WA[24] VSS_WA[25] VSS_WA[26] VSS_WA[27]
+       VSS_WA[28] VSS_WA[29] VSS_WA[30] VSS_WA[31] WABUF[0] WABUF[1] WABUF[2]
+       WAPRCLKBUFB_RET WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8]
+       WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WB[16] WB[17] WB[18]
+       WB[19] WB[20] WB[21] WB[22] WB[23] WB[24] WB[25] WB[26] WB[27] WB[28]
+       WB[29] WB[30] WB[31] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4]
+       WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11]
+       WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WB_IN[16] WB_IN[17] WB_IN[18]
+       WB_IN[19] WB_IN[20] WB_IN[21] WB_IN[22] WB_IN[23] WB_IN[24] WB_IN[25]
+       WB_IN[26] WB_IN[27] WB_IN[28] WB_IN[29] WB_IN[30] WB_IN[31] WMT[0]
+       WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT[0] WT[1] WT[2] WT[3]
+       WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14]
+       WT[15] WT[16] WT[17] WT[18] WT[19] WT[20] WT[21] WT[22] WT[23] WT[24]
+       WT[25] WT[26] WT[27] WT[28] WT[29] WT[30] WT[31] WT_IN[0] WT_IN[1]
+       WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9]
+       WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15] WT_IN[16]
+       WT_IN[17] WT_IN[18] WT_IN[19] WT_IN[20] WT_IN[21] WT_IN[22] WT_IN[23]
+       WT_IN[24] WT_IN[25] WT_IN[26] WT_IN[27] WT_IN[28] WT_IN[29] WT_IN[30]
+       WT_IN[31]
X_sac_lt BYPASS[0] BYPASS_RET[0] LCGTH[0] LOG0 LOG1 PWDO[0] QBOUT[0] QBOUT[1]
+   QBOUT[2] QBOUT[3] QBOUT[4] QBOUT[5] QBOUT[6] QBOUT[7] QBOUT[8] QBOUT[9]
+   QBOUT[10] QBOUT[11] QBOUT[12] QBOUT[13] QBOUT[14] QBOUT[15] QB_IN[0]
+   QB_IN[1] QB_IN[2] QB_IN[3] QB_IN[4] QB_IN[5] QB_IN[6] QB_IN[7] QB_IN[8]
+   QB_IN[9] QB_IN[10] QB_IN[11] QB_IN[12] QB_IN[13] QB_IN[14] QB_IN[15]
+   QB_NANDIN[0] QB_NANDIN[1] QB_NANDIN[2] QB_NANDIN[3] QB_NANDIN[4]
+   QB_NANDIN[5] QB_NANDIN[6] QB_NANDIN[7] QB_NANDIN[8] QB_NANDIN[9]
+   QB_NANDIN[10] QB_NANDIN[11] QB_NANDIN[12] QB_NANDIN[13] QB_NANDIN[14]
+   QB_NANDIN[15] QTOUT[0] QTOUT[1] QTOUT[2] QTOUT[3] QTOUT[4] QTOUT[5] QTOUT[6]
+   QTOUT[7] QTOUT[8] QTOUT[9] QTOUT[10] QTOUT[11] QTOUT[12] QTOUT[13] QTOUT[14]
+   QTOUT[15] QT_IN[0] QT_IN[1] QT_IN[2] QT_IN[3] QT_IN[4] QT_IN[5] QT_IN[6]
+   QT_IN[7] QT_IN[8] QT_IN[9] QT_IN[10] QT_IN[11] QT_IN[12] QT_IN[13] QT_IN[14]
+   QT_IN[15] QT_NANDIN[0] QT_NANDIN[1] QT_NANDIN[2] QT_NANDIN[3] QT_NANDIN[4]
+   QT_NANDIN[5] QT_NANDIN[6] QT_NANDIN[7] QT_NANDIN[8] QT_NANDIN[9]
+   QT_NANDIN[10] QT_NANDIN[11] QT_NANDIN[12] QT_NANDIN[13] QT_NANDIN[14]
+   QT_NANDIN[15] RASSISTTL[0] RASSISTTL[1] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5]
+   RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RT[0]
+   RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12]
+   RT[13] RT[14] RT[15] SAEBL SAEDL SAPRB[0] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14]
+   SEL[15] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+   VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE[0] VSS[0] VSS[1]
+   VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11]
+   VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS_WA[0] VSS_WA[1] VSS_WA[2]
+   VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7] VSS_WA[8] VSS_WA[9]
+   VSS_WA[10] VSS_WA[11] VSS_WA[12] VSS_WA[13] VSS_WA[14] VSS_WA[15] WB[0]
+   WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11] WB[12]
+   WB[13] WB[14] WB[15] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5]
+   WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13]
+   WB_IN[14] WB_IN[15] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8]
+   WT[9] WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WT_IN[0] WT_IN[1] WT_IN[2]
+   WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10]
+   WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15] SNPS_SP_HD_16Kx8_sac_lt_1
X_sac_cnt ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1]
+   BYPASS[0] BYPASS[1] BYPASS_RET[0] BYPASS_RET[1] BYP_VLOAD CENDP DEF_MODE
+   ENLPGB FAST1B FAST1_MODE FAST2_MODE FLOAT FLOATT FLOATT_PGM FLOAT_RET
+   FLOAT_RET_TIMER_PROG LBKADR0 LBKADR1 LCGTH[0] LCGTH[1] LCGTH_PCHG LDFTX
+   LITESLP LLBKADRB[0] LLBKADRB[1] LLBKADRB[2] LLBKADRT[0] LLBKADRT[1]
+   LLBKADRT[2] LMATCH LMATCHB LMATCHB_I_BBK LMATCHB_I_TBK LOG0 LOG1 LWEIB LWERD
+   LWEWR LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6]
+   LXADR[7] LYADR[0] LYADR[1] PLBKADR[0] PLBKADR[1] PLBKADR[2] PLBKADRB PM[0]
+   PM[1] PM[2] PM[3] PRCKE_B PRCKE_T PRCLKB RASSIST[0] RASSIST[1] RASSIST[2]
+   RASSIST[3] RASSISTTH[0] RASSISTTH[1] RASSISTTL[0] RASSISTTL[1] RBLRD RBLWA
+   RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC SAEBL SAEBR SAEDL SAEDR
+   SAPRB[0] SAPRB[1] T1T TEST_RNMB VBN[17] VBN[18] VBN[19] VBP[17] VBP[18]
+   VBP[19] VDDA[0] VDDA[1] VDDA[2] VDDMINB VDDP[17] VDDP[18] VDDP[19] VDDPI[17]
+   VDDPI[18] VDDPI[19] VSS[17] VSS[18] VSS[19] WABUF[0] WABUF[1] WABUF[2]
+   WAPRCLKBUFB_RET WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]
+   SNPS_SP_HD_16Kx8_sac_cnt_1
X_sac_rt BYPASS[1] BYPASS_RET[1] LCGTH[1] LOG0 LOG1 PWDO[1] QBOUT[16] QBOUT[17]
+   QBOUT[18] QBOUT[19] QBOUT[20] QBOUT[21] QBOUT[22] QBOUT[23] QBOUT[24]
+   QBOUT[25] QBOUT[26] QBOUT[27] QBOUT[28] QBOUT[29] QBOUT[30] QBOUT[31]
+   QB_IN[16] QB_IN[17] QB_IN[18] QB_IN[19] QB_IN[20] QB_IN[21] QB_IN[22]
+   QB_IN[23] QB_IN[24] QB_IN[25] QB_IN[26] QB_IN[27] QB_IN[28] QB_IN[29]
+   QB_IN[30] QB_IN[31] QB_NANDIN[16] QB_NANDIN[17] QB_NANDIN[18] QB_NANDIN[19]
+   QB_NANDIN[20] QB_NANDIN[21] QB_NANDIN[22] QB_NANDIN[23] QB_NANDIN[24]
+   QB_NANDIN[25] QB_NANDIN[26] QB_NANDIN[27] QB_NANDIN[28] QB_NANDIN[29]
+   QB_NANDIN[30] QB_NANDIN[31] QTOUT[16] QTOUT[17] QTOUT[18] QTOUT[19]
+   QTOUT[20] QTOUT[21] QTOUT[22] QTOUT[23] QTOUT[24] QTOUT[25] QTOUT[26]
+   QTOUT[27] QTOUT[28] QTOUT[29] QTOUT[30] QTOUT[31] QT_IN[16] QT_IN[17]
+   QT_IN[18] QT_IN[19] QT_IN[20] QT_IN[21] QT_IN[22] QT_IN[23] QT_IN[24]
+   QT_IN[25] QT_IN[26] QT_IN[27] QT_IN[28] QT_IN[29] QT_IN[30] QT_IN[31]
+   QT_NANDIN[16] QT_NANDIN[17] QT_NANDIN[18] QT_NANDIN[19] QT_NANDIN[20]
+   QT_NANDIN[21] QT_NANDIN[22] QT_NANDIN[23] QT_NANDIN[24] QT_NANDIN[25]
+   QT_NANDIN[26] QT_NANDIN[27] QT_NANDIN[28] QT_NANDIN[29] QT_NANDIN[30]
+   QT_NANDIN[31] RASSISTTH[0] RASSISTTH[1] RB[16] RB[17] RB[18] RB[19] RB[20]
+   RB[21] RB[22] RB[23] RB[24] RB[25] RB[26] RB[27] RB[28] RB[29] RB[30] RB[31]
+   RT[16] RT[17] RT[18] RT[19] RT[20] RT[21] RT[22] RT[23] RT[24] RT[25] RT[26]
+   RT[27] RT[28] RT[29] RT[30] RT[31] SAEBR SAEDR SAPRB[1] SEL[16] SEL[17]
+   SEL[18] SEL[19] SEL[20] SEL[21] SEL[22] SEL[23] SEL[24] SEL[25] SEL[26]
+   SEL[27] SEL[28] SEL[29] SEL[30] SEL[31] VBN[20] VBN[21] VBN[22] VBN[23]
+   VBN[24] VBN[25] VBN[26] VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32]
+   VBN[33] VBN[34] VBN[35] VBN[36] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24]
+   VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32] VBP[33]
+   VBP[34] VBP[35] VBP[36] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24]
+   VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32]
+   VDDP[33] VDDP[34] VDDP[35] VDDP[36] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23]
+   VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30]
+   VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36] VEDGE[1] VSS[20]
+   VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28] VSS[29]
+   VSS[30] VSS[31] VSS[32] VSS[33] VSS[34] VSS[35] VSS[36] VSS_WA[16]
+   VSS_WA[17] VSS_WA[18] VSS_WA[19] VSS_WA[20] VSS_WA[21] VSS_WA[22] VSS_WA[23]
+   VSS_WA[24] VSS_WA[25] VSS_WA[26] VSS_WA[27] VSS_WA[28] VSS_WA[29] VSS_WA[30]
+   VSS_WA[31] WB[16] WB[17] WB[18] WB[19] WB[20] WB[21] WB[22] WB[23] WB[24]
+   WB[25] WB[26] WB[27] WB[28] WB[29] WB[30] WB[31] WB_IN[16] WB_IN[17]
+   WB_IN[18] WB_IN[19] WB_IN[20] WB_IN[21] WB_IN[22] WB_IN[23] WB_IN[24]
+   WB_IN[25] WB_IN[26] WB_IN[27] WB_IN[28] WB_IN[29] WB_IN[30] WB_IN[31] WT[16]
+   WT[17] WT[18] WT[19] WT[20] WT[21] WT[22] WT[23] WT[24] WT[25] WT[26] WT[27]
+   WT[28] WT[29] WT[30] WT[31] WT_IN[16] WT_IN[17] WT_IN[18] WT_IN[19]
+   WT_IN[20] WT_IN[21] WT_IN[22] WT_IN[23] WT_IN[24] WT_IN[25] WT_IN[26]
+   WT_IN[27] WT_IN[28] WT_IN[29] WT_IN[30] WT_IN[31] SNPS_SP_HD_16Kx8_sac_rt_1
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_cmux_tile_1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1]
+       BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+       BT[13] BT[14] BT[15] CKPRCH LOG0 LOG1 PO[0] PO[1] POWINT[0] POWINT[1]
+       PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+       PRCHWRB[2] PRCHWRB[3] QB[0] QB[1] QB[2] QB[3] QT[0] QT[1] QT[2] QT[3]
+       RB[0] RB[1] RB[2] RB[3] RT[0] RT[1] RT[2] RT[3] SEL[0] SEL[1] SEL[2]
+       SEL[3] VBA[0] VBA[1] VBA[2] VBA[3] VBN[0] VBN[1] VBN[2] VBN[3] VBP[0]
+       VBP[1] VBP[2] VBP[3] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDAI[0] VDDAI[1]
+       VDDAI[2] VDDAI[3] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDPI[0] VDDPI[1]
+       VDDPI[2] VDDPI[3] VSS[0] VSS[1] VSS[2] VSS[3] WB[0] WB[1] WB[2] WB[3]
+       WBI[0] WBI[1] WBI[2] WBI[3] WT[0] WT[1] WT[2] WT[3] WTI[0] WTI[1] WTI[2]
+       WTI[3]

*** Jumper Report ***
* Jumper: VBA[0] VSS[0]
* Jumper: VBA[1] VSS[1]
* Jumper: VBA[2] VSS[2]
* Jumper: VBA[3] VSS[3]
* Jumper: VDDA[0] VDDP[0] VDDPI[0]
* Jumper: VDDA[1] VDDP[1] VDDPI[1]
* Jumper: VDDA[2] VDDP[2] VDDPI[2]
* Jumper: VDDA[3] VDDP[3] VDDPI[3]

X_mm16a05_u_hdsp_plus_hc_cmux4x1_S0 VDDA[0] VDDAI[0] VDDP[0] VDDPI[0] VSS[0]
+   VBP[0] VBN[0] BB[0] BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3] LOG0 LOG1
+   PO[0] PO[1] POWINT[0] POWINT[1] QB[0] QT[0] RB[0] RT[0] VBA[0] WB[0] WBI[0]
+   WT[0] WTI[0] CKPRCH PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0]
+   PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] SEL[0] mm16a05_u_hdsp_plus_hc_cmux4x1
X_mm16a05_u_hdsp_plus_hc_cmux4x1_S1 VDDA[1] VDDAI[1] VDDP[1] VDDPI[1] VSS[1]
+   VBP[1] VBN[1] BB[4] BB[5] BB[6] BB[7] BT[4] BT[5] BT[6] BT[7] LOG0 LOG1
+   PO[0] PO[1] POWINT[0] POWINT[1] QB[1] QT[1] RB[1] RT[1] VBA[1] WB[1] WBI[1]
+   WT[1] WTI[1] CKPRCH PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0]
+   PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] SEL[1] mm16a05_u_hdsp_plus_hc_cmux4x1
X_mm16a05_u_hdsp_plus_hc_cmux4x1_F1 VDDA[2] VDDAI[2] VDDP[2] VDDPI[2] VSS[2]
+   VBP[2] VBN[2] BB[8] BB[9] BB[10] BB[11] BT[8] BT[9] BT[10] BT[11] LOG0 LOG1
+   PO[0] PO[1] POWINT[0] POWINT[1] QB[2] QT[2] RB[2] RT[2] VBA[2] WB[2] WBI[2]
+   WT[2] WTI[2] CKPRCH PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0]
+   PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] SEL[2] mm16a05_u_hdsp_plus_hc_cmux4x1
X_mm16a05_u_hdsp_plus_hc_cmux4x1_F0 VDDA[3] VDDAI[3] VDDP[3] VDDPI[3] VSS[3]
+   VBP[3] VBN[3] BB[12] BB[13] BB[14] BB[15] BT[12] BT[13] BT[14] BT[15] LOG0
+   LOG1 PO[0] PO[1] POWINT[0] POWINT[1] QB[3] QT[3] RB[3] RT[3] VBA[3] WB[3]
+   WBI[3] WT[3] WTI[3] CKPRCH PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3]
+   PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] SEL[3]
+   mm16a05_u_hdsp_plus_hc_cmux4x1
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_mux_lt_seg1_1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+       BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+       BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+       BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1] BT[2] BT[3]
+       BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14]
+       BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+       BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34]
+       BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44]
+       BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54]
+       BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] CKPRCH
+       LOG0 LOG1 PO[0] PO[1] POWINT[0] POWINT[1] PRCHRDB[0] PRCHRDB[1]
+       PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] QB[0]
+       QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+       QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+       QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] RB[0] RB[1]
+       RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12]
+       RB[13] RB[14] RB[15] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7]
+       RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15] SEL[0] SEL[1]
+       SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+       SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4]
+       VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13]
+       VBA[14] VBA[15] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7]
+       VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBP[0]
+       VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10]
+       VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+       VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11]
+       VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDAI[0] VDDAI[1] VDDAI[2] VDDAI[3]
+       VDDAI[4] VDDAI[5] VDDAI[6] VDDAI[7] VDDAI[8] VDDAI[9] VDDAI[10]
+       VDDAI[11] VDDAI[12] VDDAI[13] VDDAI[14] VDDAI[15] VDDP[0] VDDP[1]
+       VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+       VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDPI[0] VDDPI[1] VDDPI[2]
+       VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+       VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VSS[0] VSS[1] VSS[2]
+       VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+       VSS[13] VSS[14] VSS[15] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7]
+       WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WBI[0] WBI[1]
+       WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11]
+       WBI[12] WBI[13] WBI[14] WBI[15] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5]
+       WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WTI[0]
+       WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10]
+       WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
X_cmux_tile_S0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9]
+   BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BT[0] BT[1] BT[2] BT[3] BT[4]
+   BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15]
+   CKPRCH LOG0 LOG1 PO[0] PO[1] POWINT[0] POWINT[1] PRCHRDB[0] PRCHRDB[1]
+   PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] QB[0]
+   QB[1] QB[2] QB[3] QT[0] QT[1] QT[2] QT[3] RB[0] RB[1] RB[2] RB[3] RT[0]
+   RT[1] RT[2] RT[3] SEL[0] SEL[1] SEL[2] SEL[3] VBA[0] VBA[1] VBA[2] VBA[3]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBP[0] VBP[1] VBP[2] VBP[3] VDDA[0] VDDA[1]
+   VDDA[2] VDDA[3] VDDAI[0] VDDAI[1] VDDAI[2] VDDAI[3] VDDP[0] VDDP[1] VDDP[2]
+   VDDP[3] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VSS[0] VSS[1] VSS[2] VSS[3]
+   WB[0] WB[1] WB[2] WB[3] WBI[0] WBI[1] WBI[2] WBI[3] WT[0] WT[1] WT[2] WT[3]
+   WTI[0] WTI[1] WTI[2] WTI[3] SNPS_SP_HD_16Kx8_cmux_tile_1
X_cmux_tile_S1 BB[16] BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24]
+   BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[16] BT[17] BT[18] BT[19]
+   BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30]
+   BT[31] CKPRCH LOG0 LOG1 PO[0] PO[1] POWINT[0] POWINT[1] PRCHRDB[0]
+   PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3]
+   QB[4] QB[5] QB[6] QB[7] QT[4] QT[5] QT[6] QT[7] RB[4] RB[5] RB[6] RB[7]
+   RT[4] RT[5] RT[6] RT[7] SEL[4] SEL[5] SEL[6] SEL[7] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBN[4] VBN[5] VBN[6] VBN[7] VBP[4] VBP[5] VBP[6] VBP[7] VDDA[4]
+   VDDA[5] VDDA[6] VDDA[7] VDDAI[4] VDDAI[5] VDDAI[6] VDDAI[7] VDDP[4] VDDP[5]
+   VDDP[6] VDDP[7] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VSS[4] VSS[5] VSS[6]
+   VSS[7] WB[4] WB[5] WB[6] WB[7] WBI[4] WBI[5] WBI[6] WBI[7] WT[4] WT[5] WT[6]
+   WT[7] WTI[4] WTI[5] WTI[6] WTI[7] SNPS_SP_HD_16Kx8_cmux_tile_1
X_cmux_tile_F1 BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40]
+   BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] CKPRCH LOG0 LOG1 PO[0] PO[1] POWINT[0] POWINT[1] PRCHRDB[0]
+   PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3]
+   QB[8] QB[9] QB[10] QB[11] QT[8] QT[9] QT[10] QT[11] RB[8] RB[9] RB[10]
+   RB[11] RT[8] RT[9] RT[10] RT[11] SEL[8] SEL[9] SEL[10] SEL[11] VBA[8] VBA[9]
+   VBA[10] VBA[11] VBN[8] VBN[9] VBN[10] VBN[11] VBP[8] VBP[9] VBP[10] VBP[11]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDAI[8] VDDAI[9] VDDAI[10] VDDAI[11]
+   VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VSS[8] VSS[9] VSS[10] VSS[11] WB[8] WB[9] WB[10] WB[11] WBI[8] WBI[9]
+   WBI[10] WBI[11] WT[8] WT[9] WT[10] WT[11] WTI[8] WTI[9] WTI[10] WTI[11]
+   SNPS_SP_HD_16Kx8_cmux_tile_1
X_cmux_tile_F0 BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+   BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[48] BT[49] BT[50] BT[51]
+   BT[52] BT[53] BT[54] BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62]
+   BT[63] CKPRCH LOG0 LOG1 PO[0] PO[1] POWINT[0] POWINT[1] PRCHRDB[0]
+   PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3]
+   QB[12] QB[13] QB[14] QB[15] QT[12] QT[13] QT[14] QT[15] RB[12] RB[13] RB[14]
+   RB[15] RT[12] RT[13] RT[14] RT[15] SEL[12] SEL[13] SEL[14] SEL[15] VBA[12]
+   VBA[13] VBA[14] VBA[15] VBN[12] VBN[13] VBN[14] VBN[15] VBP[12] VBP[13]
+   VBP[14] VBP[15] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDAI[12] VDDAI[13]
+   VDDAI[14] VDDAI[15] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDPI[12] VDDPI[13]
+   VDDPI[14] VDDPI[15] VSS[12] VSS[13] VSS[14] VSS[15] WB[12] WB[13] WB[14]
+   WB[15] WBI[12] WBI[13] WBI[14] WBI[15] WT[12] WT[13] WT[14] WT[15] WTI[12]
+   WTI[13] WTI[14] WTI[15] SNPS_SP_HD_16Kx8_cmux_tile_1
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_mux_lt_1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+       BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+       BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+       BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BOTEDGE BT[0] BT[1]
+       BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+       BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22]
+       BT[23] BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32]
+       BT[33] BT[34] BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42]
+       BT[43] BT[44] BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52]
+       BT[53] BT[54] BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62]
+       BT[63] CKPRCH LOG0 LOG1 PGIOI PO POWINT[0] POWINT[1] PRCHRDB[0]
+       PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2]
+       PRCHWRB[3] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9]
+       QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4]
+       QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15]
+       RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10]
+       RB[11] RB[12] RB[13] RB[14] RB[15] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5]
+       RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15] SEL[0]
+       SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10]
+       SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3]
+       VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12]
+       VBA[13] VBA[14] VBA[15] VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4]
+       VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13]
+       VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+       VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15]
+       VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+       VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+       VDDA[16] VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6]
+       VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14]
+       VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5]
+       VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+       VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+       VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+       VSS[13] VSS[14] VSS[15] VSS[16] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5]
+       WB[6] WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WBI[0]
+       WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10]
+       WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WT[0] WT[1] WT[2] WT[3] WT[4]
+       WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14] WT[15]
+       WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9]
+       WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]

*** Jumper Report ***
* Jumper: VDDA[0] VDDP[0] VDDPI[0]

X_mm16a05_u_hdsp_plus_capmux VDDA[0] VDDP[0] VDDPI[0] VSS[0] VBP[0] VBN[0]
+   BOTEDGE LOG0 LOG1 PGIOI PO VBA[0] VEDGE mm16a05_u_hdsp_plus_capmux
X_mux_lt_seg1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] CKPRCH LOG0 LOG1 PO PO POWINT[0]
+   POWINT[1] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+   PRCHWRB[2] PRCHWRB[3] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8]
+   QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3]
+   QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10]
+   RB[11] RB[12] RB[13] RB[14] RB[15] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6]
+   RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16]
+   VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10]
+   VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[1] VBP[2] VBP[3] VBP[4]
+   VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14]
+   VBP[15] VBP[16] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+   VDDA[16] VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1
+   VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[1] VDDPI[2]
+   VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+   VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6]
+   WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WBI[0] WBI[1]
+   WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11]
+   WBI[12] WBI[13] WBI[14] WBI[15] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6]
+   WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WTI[0] WTI[1]
+   WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11]
+   WTI[12] WTI[13] WTI[14] WTI[15] SNPS_SP_HD_16Kx8_mux_lt_seg1_1
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_mux_cnt_2 ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1]
+       ARYSD_BC2[0] ARYSD_BC2[1] BOTEDGE[0] BOTEDGE[1] BYP_VLOAD CENDP CKPRCHH
+       CKPRCHL DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR0
+       LBKADR1 LCGTH[0] LCGTH[1] LCGTH_PCHG LDFTX LITESLP LMATCH LMATCHB LOG0
+       LOG1 LWEIB LWERD LWEWR LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+       LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3]
+       PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5]
+       PCB[6] PCB[7] PM[0] PM[1] PM[2] PM[3] PO[0] PO[1] PRCHRDBH[0]
+       PRCHRDBH[1] PRCHRDBH[2] PRCHRDBH[3] PRCHRDBL[0] PRCHRDBL[1] PRCHRDBL[2]
+       PRCHRDBL[3] PRCHWRBH[0] PRCHWRBH[1] PRCHWRBH[2] PRCHWRBH[3] PRCHWRBL[0]
+       PRCHWRBL[1] PRCHWRBL[2] PRCHWRBL[3] PRCKE_T RASSIST[0] RASSIST[1]
+       RASSIST[2] RASSIST[3] RASSISTBH[0] RASSISTBH[1] RASSISTBL[0]
+       RASSISTBL[1] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3]
+       RWLB_SAC T1T TEST_RNMB VBA[0] VBA[1] VBN[0] VBN[1] VBN[2] VBP[0] VBP[1]
+       VBP[2] VDDA[0] VDDA[1] VDDA[2] VDDMINB VDDP[0] VDDP[1] VDDP[2] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDWL[0] VDDWL[1] VSS[0] VSS[1] VSS[2] VSSC_WL_L
+       VSSC_WL_R WABUF[0] WABUF[1] WABUF[2] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+       WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]

*** Jumper Report ***
* Jumper: CLK_WLBH CLK_WLBL
* Jumper: LOG1 LMATCHB
* Jumper: PRCHWR[0] PRCHWRH[0]
* Jumper: PRCHWR[1] PRCHWRH[1]
* Jumper: PRCHWR[2] PRCHWRH[2]
* Jumper: PRCHWR[3] PRCHWRH[3]
* Jumper: VDDA[0] VDDP[0] VDDPI[0]
* Jumper: VDDA[1] VDDP[1] VDDPI[1]
* Jumper: VDDA[2] VDDP[2] VDDPI[2]
* Jumper: XPRBH[0] XPRBL[0]
* Jumper: XPRBH[1] XPRBL[1]
* Jumper: XPRBH[2] XPRBL[2]
* Jumper: XPRBH[3] XPRBL[3]

X_mm16a05_u_hdsp_plus_lcenbuf_left VDDA[0] VDDP[0] VDDPI[0] VDDWL[0] VSS[0]
+   VBP[0] VBN[0] CKPRCHL LCGTHB[0] PRCHRDBL[0] PRCHRDBL[1] PRCHRDBL[2]
+   PRCHRDBL[3] PRCHWRBL[0] PRCHWRBL[1] PRCHWRBL[2] PRCHWRBL[3] RASSISTBL[0]
+   RASSISTBL[1] ARYSD[0] ARYSD_BC1[0] ARYSD_BC2[0] BOTEDGE[0] PO[0] VBA[0]
+   CKPRCHB LCGTH[0] LOG0 LOG1 PRCHRD[0] PRCHRD[1] PRCHRD[2] PRCHRD[3] PRCHWR[0]
+   PRCHWR[1] PRCHWR[2] PRCHWR[3] RASSIST[0] RASSIST[1]
+   mm16a05_u_hdsp_plus_lcenbuf
X_mm16a05_u_hdsp_plus_lcen VDDA[1] VDDMINB VDDP[1] VDDPI[1] VSS[1] VSSC_WL_L
+   VSSC_WL_R VBP[1] VBN[1] CKPRCHB LMATCH PBB[0] PBB[1] PBB[2] PBB[3] PBB[4]
+   PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7]
+   PRCHRD[0] PRCHRD[1] PRCHRD[2] PRCHRD[3] PRCHWR[0] PRCHWR[1] PRCHWR[2]
+   PRCHWR[3] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] BYP_VLOAD CENDP CLK_WLBH
+   CLK_WLBH DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LDFTX LITESLP
+   LOG0 LOG1 LWEIB LWERD LWEWR PRCHWR[0] PRCHWR[1] PRCHWR[2] PRCHWR[3] RBLRD
+   RBLWA RBLWR RWLB_SAC WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3]
+   WPBUF[0] WPBUF[1] WPBUF[2] XPRBH[0] XPRBH[1] XPRBH[2] XPRBH[3] XPRBH[0]
+   XPRBH[1] XPRBH[2] XPRBH[3] LBKADR0 LBKADR1 LBKADR LCGTHB[1] LCGTH_PCHG
+   LMATCHB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6]
+   LXADR[7] LYADR[0] LYADR[1] PM[0] PM[1] PM[2] PM[3] PRCKE_T RM3CNT RMT[0]
+   RMT[1] RMT[2] RMT[3] T1T TEST_RNMB mm16a05_u_hdsp_plus_lcen
X_mm16a05_u_hdsp_plus_lcenbuf VDDA[2] VDDP[2] VDDPI[2] VDDWL[1] VSS[2] VBP[2]
+   VBN[2] CKPRCHH LCGTHB[1] PRCHRDBH[0] PRCHRDBH[1] PRCHRDBH[2] PRCHRDBH[3]
+   PRCHWRBH[0] PRCHWRBH[1] PRCHWRBH[2] PRCHWRBH[3] RASSISTBH[0] RASSISTBH[1]
+   ARYSD[1] ARYSD_BC1[1] ARYSD_BC2[1] BOTEDGE[1] PO[1] VBA[1] CKPRCHB LCGTH[1]
+   LOG0 LOG1 PRCHRD[0] PRCHRD[1] PRCHRD[2] PRCHRD[3] PRCHWR[0] PRCHWR[1]
+   PRCHWR[2] PRCHWR[3] RASSIST[2] RASSIST[3] mm16a05_u_hdsp_plus_lcenbuf
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_mux_rt_1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+       BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+       BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+       BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BOTEDGE BT[0] BT[1]
+       BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+       BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22]
+       BT[23] BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32]
+       BT[33] BT[34] BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42]
+       BT[43] BT[44] BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52]
+       BT[53] BT[54] BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62]
+       BT[63] CKPRCH LOG0 LOG1 PGIOI PO POWINT[0] POWINT[1] PRCHRDB[0]
+       PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2]
+       PRCHWRB[3] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9]
+       QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4]
+       QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15]
+       RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10]
+       RB[11] RB[12] RB[13] RB[14] RB[15] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5]
+       RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15] SEL[0]
+       SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10]
+       SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3]
+       VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12]
+       VBA[13] VBA[14] VBA[15] VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4]
+       VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13]
+       VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+       VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15]
+       VBP[16] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+       VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+       VDDA[16] VDDAIR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6]
+       VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14]
+       VDDP[15] VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5]
+       VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+       VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2]
+       VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+       VSS[13] VSS[14] VSS[15] VSS[16] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5]
+       WB[6] WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WBI[0]
+       WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10]
+       WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WT[0] WT[1] WT[2] WT[3] WT[4]
+       WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14] WT[15]
+       WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9]
+       WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]

*** Jumper Report ***
* Jumper: VDDA[16] VDDP[16] VDDPI[16]

X_mux_lt_seg1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1]
+   BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13]
+   BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35]
+   BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46]
+   BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+   BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] CKPRCH LOG0 LOG1 PO PO POWINT[0]
+   POWINT[1] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+   PRCHWRB[2] PRCHWRB[3] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8]
+   QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3]
+   QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10]
+   RB[11] RB[12] RB[13] RB[14] RB[15] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6]
+   RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6]
+   VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+   VDDA[15] VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1
+   VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9]
+   VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDPI[0] VDDPI[1]
+   VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9]
+   VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VSS[0] VSS[1]
+   VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11]
+   VSS[12] VSS[13] VSS[14] VSS[15] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6]
+   WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WBI[0] WBI[1]
+   WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11]
+   WBI[12] WBI[13] WBI[14] WBI[15] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6]
+   WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WTI[0] WTI[1]
+   WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11]
+   WTI[12] WTI[13] WTI[14] WTI[15] SNPS_SP_HD_16Kx8_mux_lt_seg1_1
X_mm16a05_u_hdsp_plus_capmux VDDA[16] VDDP[16] VDDPI[16] VSS[16] VBP[16] VBN[16]
+   BOTEDGE LOG0 LOG1 PGIOI PO VBA[16] VEDGE mm16a05_u_hdsp_plus_capmux
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_mux_row_4 ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1]
+       ARYSD_BC2[0] ARYSD_BC2[1] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+       BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+       BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+       BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BB[64] BB[65] BB[66]
+       BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75] BB[76]
+       BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83] BB[84] BB[85] BB[86]
+       BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95] BB[96]
+       BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103] BB[104] BB[105]
+       BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BB[112] BB[113] BB[114]
+       BB[115] BB[116] BB[117] BB[118] BB[119] BB[120] BB[121] BB[122] BB[123]
+       BB[124] BB[125] BB[126] BB[127] BOTEDGE[0] BOTEDGE[1] BOTEDGE[2]
+       BOTEDGE[3] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9]
+       BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19]
+       BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28] BT[29]
+       BT[30] BT[31] BT[32] BT[33] BT[34] BT[35] BT[36] BT[37] BT[38] BT[39]
+       BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47] BT[48] BT[49]
+       BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57] BT[58] BT[59]
+       BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67] BT[68] BT[69]
+       BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78] BT[79]
+       BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89]
+       BT[90] BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99]
+       BT[100] BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108]
+       BT[109] BT[110] BT[111] BT[112] BT[113] BT[114] BT[115] BT[116] BT[117]
+       BT[118] BT[119] BT[120] BT[121] BT[122] BT[123] BT[124] BT[125] BT[126]
+       BT[127] BYP_VLOAD CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT
+       FLOAT_RET LBKADR0 LBKADR1 LCGTH[0] LCGTH[1] LCGTH_PCHG LDFTX LITESLP
+       LMATCH LMATCHB LOG0 LOG1 LWEIB LWERD LWEWR LXADR[0] LXADR[1] LXADR[2]
+       LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0]
+       PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+       PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] PGIOI[0] PGIOI[1] PM[0] PM[1] PM[2]
+       PM[3] PRCKE_T QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8]
+       QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QB[16] QB[17] QB[18]
+       QB[19] QB[20] QB[21] QB[22] QB[23] QB[24] QB[25] QB[26] QB[27] QB[28]
+       QB[29] QB[30] QB[31] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+       QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17]
+       QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27]
+       QT[28] QT[29] QT[30] QT[31] RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3]
+       RASSISTBH[0] RASSISTBH[1] RASSISTBL[0] RASSISTBL[1] RB[0] RB[1] RB[2]
+       RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13]
+       RB[14] RB[15] RB[16] RB[17] RB[18] RB[19] RB[20] RB[21] RB[22] RB[23]
+       RB[24] RB[25] RB[26] RB[27] RB[28] RB[29] RB[30] RB[31] RBLRD RBLWA
+       RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RT[0] RT[1] RT[2] RT[3] RT[4]
+       RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15]
+       RT[16] RT[17] RT[18] RT[19] RT[20] RT[21] RT[22] RT[23] RT[24] RT[25]
+       RT[26] RT[27] RT[28] RT[29] RT[30] RT[31] RWLB_SAC SEL[0] SEL[1] SEL[2]
+       SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+       SEL[13] SEL[14] SEL[15] SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21]
+       SEL[22] SEL[23] SEL[24] SEL[25] SEL[26] SEL[27] SEL[28] SEL[29] SEL[30]
+       SEL[31] T1T TEST_RNMB VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+       VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+       VBA[16] VBA[17] VBA[18] VBA[19] VBA[20] VBA[21] VBA[22] VBA[23] VBA[24]
+       VBA[25] VBA[26] VBA[27] VBA[28] VBA[29] VBA[30] VBA[31] VBA[32] VBA[33]
+       VBA[34] VBA[35] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7]
+       VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+       VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25]
+       VBN[26] VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34]
+       VBN[35] VBN[36] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7]
+       VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+       VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+       VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32] VBP[33] VBP[34]
+       VBP[35] VBP[36] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6]
+       VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+       VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22]
+       VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30]
+       VDDA[31] VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDAIL1 VDDAIR1
+       VDDMINB VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7]
+       VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15]
+       VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23]
+       VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31]
+       VDDP[32] VDDP[33] VDDP[34] VDDP[35] VDDP[36] VDDPI[0] VDDPI[1] VDDPI[2]
+       VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+       VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17]
+       VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24]
+       VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31]
+       VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36] VDDWL[0] VDDWL[1]
+       VEDGE[0] VEDGE[1] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6]
+       VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15]
+       VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24]
+       VSS[25] VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33]
+       VSS[34] VSS[35] VSS[36] VSSC_WL_L VSSC_WL_R WABUF[0] WABUF[1] WABUF[2]
+       WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10]
+       WB[11] WB[12] WB[13] WB[14] WB[15] WB[16] WB[17] WB[18] WB[19] WB[20]
+       WB[21] WB[22] WB[23] WB[24] WB[25] WB[26] WB[27] WB[28] WB[29] WB[30]
+       WB[31] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8]
+       WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17]
+       WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26]
+       WBI[27] WBI[28] WBI[29] WBI[30] WBI[31] WCLKB[0] WCLKB[1] WCLKB[2]
+       WCLKB[3] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT[0]
+       WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11]
+       WT[12] WT[13] WT[14] WT[15] WT[16] WT[17] WT[18] WT[19] WT[20] WT[21]
+       WT[22] WT[23] WT[24] WT[25] WT[26] WT[27] WT[28] WT[29] WT[30] WT[31]
+       WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9]
+       WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18]
+       WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27]
+       WTI[28] WTI[29] WTI[30] WTI[31]
X_mux_lt BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BOTEDGE[0]
+   BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11]
+   BT[12] BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22]
+   BT[23] BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33]
+   BT[34] BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44]
+   BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55]
+   BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] CKPRCHL LOG0 LOG1
+   PGIOI[0] PO[0] POWINT[0] POWINT[1] PRCHRDBL[0] PRCHRDBL[1] PRCHRDBL[2]
+   PRCHRDBL[3] PRCHWRBL[0] PRCHWRBL[1] PRCHWRBL[2] PRCHWRBL[3] QB[0] QB[1]
+   QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13]
+   QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9]
+   QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] RB[0] RB[1] RB[2] RB[3] RB[4]
+   RB[5] RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15]
+   RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11]
+   RT[12] RT[13] RT[14] RT[15] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+   SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] VBA[0]
+   VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10]
+   VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16] VBN[0] VBN[1] VBN[2] VBN[3]
+   VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13]
+   VBN[14] VBN[15] VBN[16] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+   VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+   VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8]
+   VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16]
+   VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7]
+   VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15]
+   VDDP[16] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6]
+   VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+   VDDPI[15] VDDPI[16] VEDGE[0] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+   VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15]
+   VSS[16] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10]
+   WB[11] WB[12] WB[13] WB[14] WB[15] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11]
+   WT[12] WT[13] WT[14] WT[15] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+   WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_mux_lt_1
X_mux_cnt ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1]
+   BOTEDGE[1] BOTEDGE[2] BYP_VLOAD CENDP CKPRCHH CKPRCHL DEF_MODE FAST1_MODE
+   FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR0 LBKADR1 LCGTH[0] LCGTH[1]
+   LCGTH_PCHG LDFTX LITESLP LMATCH LMATCHB LOG0 LOG1 LWEIB LWERD LWEWR LXADR[0]
+   LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+   LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0]
+   PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] PM[0] PM[1] PM[2] PM[3]
+   PO[0] PO[1] PRCHRDBH[0] PRCHRDBH[1] PRCHRDBH[2] PRCHRDBH[3] PRCHRDBL[0]
+   PRCHRDBL[1] PRCHRDBL[2] PRCHRDBL[3] PRCHWRBH[0] PRCHWRBH[1] PRCHWRBH[2]
+   PRCHWRBH[3] PRCHWRBL[0] PRCHWRBL[1] PRCHWRBL[2] PRCHWRBL[3] PRCKE_T
+   RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RASSISTBH[0] RASSISTBH[1]
+   RASSISTBL[0] RASSISTBL[1] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2]
+   RMT[3] RWLB_SAC T1T TEST_RNMB VBA[17] VBA[18] VBN[17] VBN[18] VBN[19]
+   VBP[17] VBP[18] VBP[19] VDDA[17] VDDA[18] VDDA[19] VDDMINB VDDP[17] VDDP[18]
+   VDDP[19] VDDPI[17] VDDPI[18] VDDPI[19] VDDWL[0] VDDWL[1] VSS[17] VSS[18]
+   VSS[19] VSSC_WL_L VSSC_WL_R WABUF[0] WABUF[1] WABUF[2] WCLKB[0] WCLKB[1]
+   WCLKB[2] WCLKB[3] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]
+   SNPS_SP_HD_16Kx8_mux_cnt_2
X_mux_rt BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73]
+   BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83] BB[84]
+   BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95]
+   BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103] BB[104] BB[105]
+   BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BB[112] BB[113] BB[114]
+   BB[115] BB[116] BB[117] BB[118] BB[119] BB[120] BB[121] BB[122] BB[123]
+   BB[124] BB[125] BB[126] BB[127] BOTEDGE[3] BT[64] BT[65] BT[66] BT[67]
+   BT[68] BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78]
+   BT[79] BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89]
+   BT[90] BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99]
+   BT[100] BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108]
+   BT[109] BT[110] BT[111] BT[112] BT[113] BT[114] BT[115] BT[116] BT[117]
+   BT[118] BT[119] BT[120] BT[121] BT[122] BT[123] BT[124] BT[125] BT[126]
+   BT[127] CKPRCHH LOG0 LOG1 PGIOI[1] PO[1] POWINT[2] POWINT[3] PRCHRDBH[0]
+   PRCHRDBH[1] PRCHRDBH[2] PRCHRDBH[3] PRCHWRBH[0] PRCHWRBH[1] PRCHWRBH[2]
+   PRCHWRBH[3] QB[16] QB[17] QB[18] QB[19] QB[20] QB[21] QB[22] QB[23] QB[24]
+   QB[25] QB[26] QB[27] QB[28] QB[29] QB[30] QB[31] QT[16] QT[17] QT[18] QT[19]
+   QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28] QT[29] QT[30]
+   QT[31] RB[16] RB[17] RB[18] RB[19] RB[20] RB[21] RB[22] RB[23] RB[24] RB[25]
+   RB[26] RB[27] RB[28] RB[29] RB[30] RB[31] RT[16] RT[17] RT[18] RT[19] RT[20]
+   RT[21] RT[22] RT[23] RT[24] RT[25] RT[26] RT[27] RT[28] RT[29] RT[30] RT[31]
+   SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21] SEL[22] SEL[23] SEL[24]
+   SEL[25] SEL[26] SEL[27] SEL[28] SEL[29] SEL[30] SEL[31] VBA[19] VBA[20]
+   VBA[21] VBA[22] VBA[23] VBA[24] VBA[25] VBA[26] VBA[27] VBA[28] VBA[29]
+   VBA[30] VBA[31] VBA[32] VBA[33] VBA[34] VBA[35] VBN[20] VBN[21] VBN[22]
+   VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28] VBN[29] VBN[30] VBN[31]
+   VBN[32] VBN[33] VBN[34] VBN[35] VBN[36] VBP[20] VBP[21] VBP[22] VBP[23]
+   VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32]
+   VBP[33] VBP[34] VBP[35] VBP[36] VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24]
+   VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31] VDDA[32]
+   VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDAIR1 VDDP[20] VDDP[21] VDDP[22]
+   VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDP[29] VDDP[30]
+   VDDP[31] VDDP[32] VDDP[33] VDDP[34] VDDP[35] VDDP[36] VDDPI[20] VDDPI[21]
+   VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28]
+   VDDPI[29] VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35]
+   VDDPI[36] VEDGE[1] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26]
+   VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34] VSS[35]
+   VSS[36] WB[16] WB[17] WB[18] WB[19] WB[20] WB[21] WB[22] WB[23] WB[24]
+   WB[25] WB[26] WB[27] WB[28] WB[29] WB[30] WB[31] WBI[16] WBI[17] WBI[18]
+   WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27]
+   WBI[28] WBI[29] WBI[30] WBI[31] WT[16] WT[17] WT[18] WT[19] WT[20] WT[21]
+   WT[22] WT[23] WT[24] WT[25] WT[26] WT[27] WT[28] WT[29] WT[30] WT[31]
+   WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24]
+   WTI[25] WTI[26] WTI[27] WTI[28] WTI[29] WTI[30] WTI[31]
+   SNPS_SP_HD_16Kx8_mux_rt_1
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_lt_seg1_3 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+       BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+       BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+       BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] LLSB LOG0 LOG1 QB[0]
+       QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+       QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+       QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SDB_BC1T
+       SDB_BC2T SDOR SDOR_RET SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+       SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15]
+       VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9]
+       VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBN[0] VBN[1] VBN[2]
+       VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12]
+       VBN[13] VBN[14] VBN[15] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+       VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15]
+       VDDA VDDAI[0] VDDAI[1] VDDAI[2] VDDAI[3] VDDAI[4] VDDAI[5] VDDAI[6]
+       VDDAI[7] VDDAI[8] VDDAI[9] VDDAI[10] VDDAI[11] VDDAI[12] VDDAI[13]
+       VDDAI[14] VDDAI[15] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5]
+       VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+       VDDP[14] VDDP[15] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5]
+       VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+       VDDPI[13] VDDPI[14] VDDPI[15] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+       VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14]
+       VSS[15] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8]
+       WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WTI[0] WTI[1]
+       WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11]
+       WTI[12] WTI[13] WTI[14] WTI[15]

*** Jumper Report ***
* Jumper: VBA[0] VSS[0]
* Jumper: VBA[1] VSS[1]
* Jumper: VBA[2] VSS[2]
* Jumper: VBA[3] VSS[3]
* Jumper: VBA[4] VSS[4]
* Jumper: VBA[5] VSS[5]
* Jumper: VBA[6] VSS[6]
* Jumper: VBA[7] VSS[7]
* Jumper: VBA[8] VSS[8]
* Jumper: VBA[9] VSS[9]
* Jumper: VBA[10] VSS[10]
* Jumper: VBA[11] VSS[11]
* Jumper: VBA[12] VSS[12]
* Jumper: VBA[13] VSS[13]
* Jumper: VBA[14] VSS[14]
* Jumper: VBA[15] VSS[15]
* Jumper: VDDA VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15]

X_mm16a05_u_hdsp_plus_rar4x1_top_S0 VDDA VDDAI[0] VDDP[0] VDDPI[0] VSS[0] VBP[0]
+   VBN[0] BB[0] BB[1] BB[2] BB[3] LOG0 LOG1 QB[0] QT[0] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[0] VBA[0] WBI[0] WTI[0] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_S1 VDDA VDDAI[1] VDDP[1] VDDPI[1] VSS[1] VBP[1]
+   VBN[1] BB[4] BB[5] BB[6] BB[7] LOG0 LOG1 QB[1] QT[1] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[1] VBA[1] WBI[1] WTI[1] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_S2 VDDA VDDAI[2] VDDP[2] VDDPI[2] VSS[2] VBP[2]
+   VBN[2] BB[8] BB[9] BB[10] BB[11] LOG0 LOG1 QB[2] QT[2] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[2] VBA[2] WBI[2] WTI[2] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_S3 VDDA VDDAI[3] VDDP[3] VDDPI[3] VSS[3] VBP[3]
+   VBN[3] BB[12] BB[13] BB[14] BB[15] LOG0 LOG1 QB[3] QT[3] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[3] VBA[3] WBI[3] WTI[3] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_S4 VDDA VDDAI[4] VDDP[4] VDDPI[4] VSS[4] VBP[4]
+   VBN[4] BB[16] BB[17] BB[18] BB[19] LOG0 LOG1 QB[4] QT[4] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[4] VBA[4] WBI[4] WTI[4] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_S5 VDDA VDDAI[5] VDDP[5] VDDPI[5] VSS[5] VBP[5]
+   VBN[5] BB[20] BB[21] BB[22] BB[23] LOG0 LOG1 QB[5] QT[5] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[5] VBA[5] WBI[5] WTI[5] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_S6 VDDA VDDAI[6] VDDP[6] VDDPI[6] VSS[6] VBP[6]
+   VBN[6] BB[24] BB[25] BB[26] BB[27] LOG0 LOG1 QB[6] QT[6] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[6] VBA[6] WBI[6] WTI[6] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_S7 VDDA VDDAI[7] VDDP[7] VDDPI[7] VSS[7] VBP[7]
+   VBN[7] BB[28] BB[29] BB[30] BB[31] LOG0 LOG1 QB[7] QT[7] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[7] VBA[7] WBI[7] WTI[7] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_F7 VDDA VDDAI[8] VDDP[8] VDDPI[8] VSS[8] VBP[8]
+   VBN[8] BB[32] BB[33] BB[34] BB[35] LOG0 LOG1 QB[8] QT[8] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[8] VBA[8] WBI[8] WTI[8] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_F6 VDDA VDDAI[9] VDDP[9] VDDPI[9] VSS[9] VBP[9]
+   VBN[9] BB[36] BB[37] BB[38] BB[39] LOG0 LOG1 QB[9] QT[9] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[9] VBA[9] WBI[9] WTI[9] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_F5 VDDA VDDAI[10] VDDP[10] VDDPI[10] VSS[10]
+   VBP[10] VBN[10] BB[40] BB[41] BB[42] BB[43] LOG0 LOG1 QB[10] QT[10] LOG0
+   LOG0 LOG0 LOG0 SDOR SDOR_RET SEL[10] VBA[10] WBI[10] WTI[10] LLSB SDB_BC1T
+   SDB_BC2T mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_F4 VDDA VDDAI[11] VDDP[11] VDDPI[11] VSS[11]
+   VBP[11] VBN[11] BB[44] BB[45] BB[46] BB[47] LOG0 LOG1 QB[11] QT[11] LOG0
+   LOG0 LOG0 LOG0 SDOR SDOR_RET SEL[11] VBA[11] WBI[11] WTI[11] LLSB SDB_BC1T
+   SDB_BC2T mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_F3 VDDA VDDAI[12] VDDP[12] VDDPI[12] VSS[12]
+   VBP[12] VBN[12] BB[48] BB[49] BB[50] BB[51] LOG0 LOG1 QB[12] QT[12] LOG0
+   LOG0 LOG0 LOG0 SDOR SDOR_RET SEL[12] VBA[12] WBI[12] WTI[12] LLSB SDB_BC1T
+   SDB_BC2T mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_F2 VDDA VDDAI[13] VDDP[13] VDDPI[13] VSS[13]
+   VBP[13] VBN[13] BB[52] BB[53] BB[54] BB[55] LOG0 LOG1 QB[13] QT[13] LOG0
+   LOG0 LOG0 LOG0 SDOR SDOR_RET SEL[13] VBA[13] WBI[13] WTI[13] LLSB SDB_BC1T
+   SDB_BC2T mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_F1 VDDA VDDAI[14] VDDP[14] VDDPI[14] VSS[14]
+   VBP[14] VBN[14] BB[56] BB[57] BB[58] BB[59] LOG0 LOG1 QB[14] QT[14] LOG0
+   LOG0 LOG0 LOG0 SDOR SDOR_RET SEL[14] VBA[14] WBI[14] WTI[14] LLSB SDB_BC1T
+   SDB_BC2T mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_F0 VDDA VDDAI[15] VDDP[15] VDDPI[15] VSS[15]
+   VBP[15] VBN[15] BB[60] BB[61] BB[62] BB[63] LOG0 LOG1 QB[15] QT[15] LOG0
+   LOG0 LOG0 LOG0 SDOR SDOR_RET SEL[15] VBA[15] WBI[15] WTI[15] LLSB SDB_BC1T
+   SDB_BC2T mm16a05_u_hdsp_plus_rar4x1
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_lt_3 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+       BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+       BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+       BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] LLSB LOG0 LOG1 PGIOI
+       QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+       QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5]
+       QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15]
+       SDB_BC1T SDB_BC2T SDOR SDOR_RET SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+       SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13]
+       SEL[14] SEL[15] TOPEDGE VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+       VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+       VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+       VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0]
+       VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10]
+       VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA VDDAIL1 VDDP[0]
+       VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9]
+       VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+       VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+       VDDPI[16] VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+       VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+       WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9]
+       WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WTI[0] WTI[1] WTI[2]
+       WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12]
+       WTI[13] WTI[14] WTI[15]

*** Jumper Report ***
* Jumper: LOG1 PGIOI

X_mm16a05_u_hdsp_plus_pg_pwedge_top VDDA VDDP[0] VDDPI[0] VSS[0] VBP[0] VBN[0]
+   LOG0 LOG1 PGIOI PO SDOR_RET TOPEDGE VBA[0] VEDGE SDOR
+   mm16a05_u_hdsp_plus_pg_pwedge
X_ref_lt_seg1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] LLSB LOG0
+   LOG1 QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] SDB_BC1T
+   SDB_BC2T SDOR SDOR_RET SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+   SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] VBA[1]
+   VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11]
+   VBA[12] VBA[13] VBA[14] VBA[15] VBA[16] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5]
+   VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15]
+   VBN[16] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9]
+   VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA VDDAIL1 VDDAIL1
+   VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1
+   VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5]
+   VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13]
+   VDDPI[14] VDDPI[15] VDDPI[16] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6]
+   VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9]
+   WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WTI[0] WTI[1] WTI[2] WTI[3]
+   WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13]
+   WTI[14] WTI[15] SNPS_SP_HD_16Kx8_ref_lt_seg1_3
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_cnt_3 ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+       ARYSD_BC2[1] ARYSD_IN[0] ARYSD_IN[1] ARYSD_TOP[0] ARYSD_TOP[1] CENDP
+       DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET FLOAT_RET_PROG
+       LBKADR0 LBKADR1 LCGTH[0] LCGTH[1] LDFTX LITESLP LLBKADRB[0] LLBKADRB[1]
+       LLSB[0] LLSB[1] LMATCHB LMATCHB_I LOG0[0] LOG0[1] LOG0[2] LOG0[3]
+       LOG1[0] LOG1[3] LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+       LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PLBKADR[0] PLBKADR[1]
+       RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RASSISTBH[0] RASSISTBH[1]
+       RASSISTBL[0] RASSISTBL[1] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2]
+       RMT[3] RWLB_SAC RWLD_RD RWLD_WR RWL_DLY_0 RWL_DLY_2 RWL_DLY_4
+       RWL_DLY_RD_PGM RWL_DLY_WR_PGM RWL_RD[1] RWL_RWLD_AND RWL_RWLD_AND_WR
+       RWL_WR[1] SDB_BC1T[0] SDB_BC1T[1] SDB_BC2T[0] SDB_BC2T[1] SDOR[0]
+       SDOR[1] SDOR_RET[0] SDOR_RET[1] T1T TEST_RNMB TOPEDGE[0] TOPEDGE[1]
+       VBA[0] VBA[1] VBN[0] VBN[1] VBN[2] VBP[0] VBP[1] VBP[2] VDDA[0] VDDA[1]
+       VDDA[2] VDDMINB VDDP[0] VDDP[1] VDDP[2] VDDPI[0] VDDPI[1] VDDPI[2]
+       VDDWL[0] VDDWL[1] VSS[0] VSS[1] VSS[2] VSSC_WL_L VSSC_WL_R WABUF[0]
+       WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]

*** Jumper Report ***
* Jumper: FLOAT_RET_PROG LMATCHB_I LOG1[3]
* Jumper: LBKADR1 PLBKADR[0]
* Jumper: LLBKADRB[1] PLBKADR[1]
* Jumper: LOG0[3] LBKADR
* Jumper: RWLB_RD RWLHVBRD
* Jumper: RWLB_WR RWLHVBWR
* Jumper: RWL_DLY_0 RWL_DLY_RD_PGM RWL_DLY_WR_PGM
* Jumper: VDDA[0] VDDP[0]
* Jumper: VDDA[1] VDDP[1] VDDPI[1]
* Jumper: VDDA[2] VDDP[2]

X_mm16a05_u_hdsp_plus_rwbuf_top_left VDDA[0] VDDP[0] VDDPI[0] VDDWL[0] VSS[0]
+   VBP[0] VBN[0] SDB_BC1T[0] SDB_BC2T[0] ARYSD_TOP[0] LLSB[0] RWL_RD[0]
+   RWL_WR[0] SDOR[0] LOG0[0] LOG1[0] PO[0] RASSIST[0] RASSIST[1] RASSISTBL[0]
+   RASSISTBL[1] LOG0[1] LOG0[2] TOPEDGE[0] VBA[0] ARYSD_BC1[0] ARYSD_BC2[0]
+   ARYSD_IN[0] LCGTH[0] LOG1[1] LOG1[2] SDOR_RET[0]
+   mm16a05_u_hdsp_plus_rwbuf_left
X_mm16a05_u_hdsp_plus_rw_top VDDMINB VDDA[1] VDDP[1] VDDPI[1] VSS[1] VSSC_WL_L
+   VSSC_WL_R VBP[1] VBN[1] RWLB_RD RWLB_WR RWL_DLY_0 RWL_DLY_2 RWL_DLY_4
+   RWL_RWLD_AND RWL_RWLD_AND_WR CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT_RET
+   FLOAT_RET_PROG LBKADR0 LBKADR1 LOG0[3] LCGTHB LDFTX LITESLP LLBKADRB[0]
+   LLBKADRB[1] LMATCHB LMATCHB_I LOG0[3] LOG1[3] LXADR[0] LXADR[1] LXADR[2]
+   LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PLBKADR[0]
+   PLBKADR[1] RBLRD RBLWA RBLWR RM3CNT RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WPBUF[0] WPBUF[1] WPBUF[2] FLOAT FLOATT LWEIB RMT[0] RMT[1] RMT[2]
+   RMT[3] RWLD_RD RWLD_WR RWLB_RD RWLB_WR RWL_DLY_RD_PGM RWL_DLY_WR_PGM WMT[0]
+   WMT[1] WMT[2] WMT[3] mm16a05_u_hdsp_plus_rw_gf22
X_mm16a05_u_hdsp_plus_rwbuf_top VDDA[2] VDDP[2] VDDPI[2] VDDWL[1] VSS[2] VBP[2]
+   VBN[2] SDB_BC1T[1] SDB_BC2T[1] ARYSD_TOP[1] LLSB[1] RWL_RD[1] RWL_WR[1]
+   SDOR[1] LCGTHB LOG0[3] LOG1[3] PO[1] RASSIST[2] RASSIST[3] RASSISTBH[0]
+   RASSISTBH[1] RWLD_RD RWLD_WR TOPEDGE[1] VBA[1] ARYSD_BC1[1] ARYSD_BC2[1]
+   ARYSD_IN[1] LCGTH[1] RWLB_RD RWLB_WR SDOR_RET[1] mm16a05_u_hdsp_plus_rwbuf
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_rt_rwl_3 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] LLSB LOG0 LOG1 QB[0] QB[1] QB[2] QT[0]
+       QT[1] QT[2] RWLD_RD RWLD_WR RWL_RD RWL_WR SDB_BC1T SDB_BC2T SDOR
+       SDOR_RET SEL[0] SEL[1] SEL[2] VBA[0] VBA[1] VBA[2] VBN[0] VBN[1] VBN[2]
+       VBP[0] VBP[1] VBP[2] VDDA VDDAI[0] VDDAI[1] VDDAI[2] VDDP[0] VDDP[1]
+       VDDP[2] VDDPI[0] VDDPI[1] VDDPI[2] VSS[0] VSS[1] VSS[2] WBI[0] WBI[1]
+       WBI[2] WTI[0] WTI[1] WTI[2]

*** Jumper Report ***
* Jumper: VBA[0] VSS[0]
* Jumper: VBA[1] VSS[1]
* Jumper: VBA[2] VSS[2]
* Jumper: VDDA VDDP[0] VDDP[1] VDDP[2]

X_mm16a05_u_hdsp_plus_rar4x1_top_S0 VDDA VDDAI[0] VDDP[0] VDDPI[0] VSS[0] VBP[0]
+   VBN[0] BB[0] BB[1] BB[2] BB[3] LOG0 LOG1 QB[0] QT[0] RWLD_RD RWLD_WR RWL_RD
+   RWL_WR SDOR SDOR_RET SEL[0] VBA[0] WBI[0] WTI[0] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_F1 VDDA VDDAI[1] VDDP[1] VDDPI[1] VSS[1] VBP[1]
+   VBN[1] BB[4] BB[5] BB[6] BB[7] LOG0 LOG1 QB[1] QT[1] RWLD_RD RWLD_WR RWL_RD
+   RWL_WR SDOR SDOR_RET SEL[1] VBA[1] WBI[1] WTI[1] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_F0 VDDA VDDAI[2] VDDP[2] VDDPI[2] VSS[2] VBP[2]
+   VBN[2] BB[8] BB[9] BB[10] BB[11] LOG0 LOG1 QB[2] QT[2] RWLD_RD RWLD_WR
+   RWL_RD RWL_WR SDOR SDOR_RET SEL[2] VBA[2] WBI[2] WTI[2] LLSB SDB_BC1T
+   SDB_BC2T mm16a05_u_hdsp_plus_rar4x1
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_cnt_rt_rwl_3 ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+       ARYSD_BC2[1] ARYSD_IN[0] ARYSD_IN[1] ARYSD_TOP[0] ARYSD_TOP[1] BB[0]
+       BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11]
+       CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET
+       FLOAT_RET_PROG LBKADR0 LBKADR1 LCGTH[0] LCGTH[1] LDFTX LITESLP
+       LLBKADRB[0] LLBKADRB[1] LLSB[0] LLSB[1] LMATCHB LMATCHB_I LOG0[0]
+       LOG0[1] LOG0[2] LOG0[3] LOG1[0] LOG1[1] LWEIB LXADR[0] LXADR[1] LXADR[2]
+       LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+       PLBKADR[0] PLBKADR[1] QB[0] QB[1] QB[2] QT[0] QT[1] QT[2] RASSIST[0]
+       RASSIST[1] RASSIST[2] RASSIST[3] RASSISTBH[0] RASSISTBH[1] RASSISTBL[0]
+       RASSISTBL[1] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3]
+       RWLB_SAC RWLD_RD RWLD_WR RWL_DLY_0 RWL_DLY_2 RWL_DLY_4 RWL_DLY_RD_PGM
+       RWL_DLY_WR_PGM RWL_RD RWL_RWLD_AND RWL_RWLD_AND_WR RWL_WR SDB_BC1T[0]
+       SDB_BC1T[1] SDB_BC2T[0] SDB_BC2T[1] SDOR[0] SDOR[1] SDOR_RET[0]
+       SDOR_RET[1] SEL[0] SEL[1] SEL[2] T1T TEST_RNMB TOPEDGE[0] TOPEDGE[1]
+       VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4]
+       VBN[5] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VDDA[0] VDDA[1] VDDA[2]
+       VDDAI[0] VDDAI[1] VDDAI[2] VDDMINB VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+       VDDP[4] VDDP[5] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5]
+       VDDWL[0] VDDWL[1] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSSC_WL_L
+       VSSC_WL_R WABUF[0] WABUF[1] WABUF[2] WBI[0] WBI[1] WBI[2] WMT[0] WMT[1]
+       WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WTI[0] WTI[1] WTI[2]
X_ref_cnt ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1] ARYSD_IN[0]
+   ARYSD_IN[1] ARYSD_TOP[0] ARYSD_TOP[1] CENDP DEF_MODE FAST1_MODE FAST2_MODE
+   FLOAT FLOATT FLOAT_RET FLOAT_RET_PROG LBKADR0 LBKADR1 LCGTH[0] LCGTH[1]
+   LDFTX LITESLP LLBKADRB[0] LLBKADRB[1] LLSB[0] LLSB[1] LMATCHB LMATCHB_I
+   LOG0[0] LOG0[1] LOG0[2] LOG0[3] LOG1[0] LOG1[1] LWEIB LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PLBKADR[0] PLBKADR[1] RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3]
+   RASSISTBH[0] RASSISTBH[1] RASSISTBL[0] RASSISTBL[1] RBLRD RBLWA RBLWR RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC RWLD_RD RWLD_WR RWL_DLY_0 RWL_DLY_2
+   RWL_DLY_4 RWL_DLY_RD_PGM RWL_DLY_WR_PGM RWL_RD RWL_RWLD_AND RWL_RWLD_AND_WR
+   RWL_WR SDB_BC1T[0] SDB_BC1T[1] SDB_BC2T[0] SDB_BC2T[1] SDOR[0] SDOR[1]
+   SDOR_RET[0] SDOR_RET[1] T1T TEST_RNMB TOPEDGE[0] TOPEDGE[1] VBA[0] VBA[1]
+   VBN[0] VBN[1] VBN[2] VBP[0] VBP[1] VBP[2] VDDA[0] VDDA[1] VDDA[2] VDDMINB
+   VDDP[0] VDDP[1] VDDP[2] VDDPI[0] VDDPI[1] VDDPI[2] VDDWL[0] VDDWL[1] VSS[0]
+   VSS[1] VSS[2] VSSC_WL_L VSSC_WL_R WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1]
+   WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] SNPS_SP_HD_16Kx8_ref_cnt_3
X_ref_rt_rwl BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] LLSB[1] LOG0[3] LOG1[1] QB[0] QB[1] QB[2] QT[0] QT[1] QT[2] RWLD_RD
+   RWLD_WR RWL_RD RWL_WR SDB_BC1T[1] SDB_BC2T[1] SDOR[1] SDOR_RET[1] SEL[0]
+   SEL[1] SEL[2] VBA[2] VBA[3] VBA[4] VBN[3] VBN[4] VBN[5] VBP[3] VBP[4] VBP[5]
+   VDDA[2] VDDAI[0] VDDAI[1] VDDAI[2] VDDP[3] VDDP[4] VDDP[5] VDDPI[3] VDDPI[4]
+   VDDPI[5] VSS[3] VSS[4] VSS[5] WBI[0] WBI[1] WBI[2] WTI[0] WTI[1] WTI[2]
+   SNPS_SP_HD_16Kx8_ref_rt_rwl_3
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_rt_log0_3 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+       BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+       BB[47] LLSB LOG0 LOG1 QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7]
+       QB[8] QB[9] QB[10] QB[11] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+       QT[7] QT[8] QT[9] QT[10] QT[11] SDB_BC1T SDB_BC2T SDOR SDOR_RET SEL[0]
+       SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10]
+       SEL[11] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8]
+       VBA[9] VBA[10] VBA[11] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+       VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4]
+       VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VDDA VDDAI[0]
+       VDDAI[1] VDDAI[2] VDDAI[3] VDDAI[4] VDDAI[5] VDDAI[6] VDDAI[7] VDDAI[8]
+       VDDAI[9] VDDAI[10] VDDAI[11] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+       VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+       VDDPI[9] VDDPI[10] VDDPI[11] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+       VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] WBI[0] WBI[1] WBI[2] WBI[3]
+       WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WTI[0] WTI[1]
+       WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11]

*** Jumper Report ***
* Jumper: VBA[0] VSS[0]
* Jumper: VBA[1] VSS[1]
* Jumper: VBA[2] VSS[2]
* Jumper: VBA[3] VSS[3]
* Jumper: VBA[4] VSS[4]
* Jumper: VBA[5] VSS[5]
* Jumper: VBA[6] VSS[6]
* Jumper: VBA[7] VSS[7]
* Jumper: VBA[8] VSS[8]
* Jumper: VBA[9] VSS[9]
* Jumper: VBA[10] VSS[10]
* Jumper: VBA[11] VSS[11]
* Jumper: VDDA VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11]

X_mm16a05_u_hdsp_plus_rar4x1_top_S0 VDDA VDDAI[0] VDDP[0] VDDPI[0] VSS[0] VBP[0]
+   VBN[0] BB[0] BB[1] BB[2] BB[3] LOG0 LOG1 QB[0] QT[0] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[0] VBA[0] WBI[0] WTI[0] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_S1 VDDA VDDAI[1] VDDP[1] VDDPI[1] VSS[1] VBP[1]
+   VBN[1] BB[4] BB[5] BB[6] BB[7] LOG0 LOG1 QB[1] QT[1] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[1] VBA[1] WBI[1] WTI[1] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_S2 VDDA VDDAI[2] VDDP[2] VDDPI[2] VSS[2] VBP[2]
+   VBN[2] BB[8] BB[9] BB[10] BB[11] LOG0 LOG1 QB[2] QT[2] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[2] VBA[2] WBI[2] WTI[2] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_S3 VDDA VDDAI[3] VDDP[3] VDDPI[3] VSS[3] VBP[3]
+   VBN[3] BB[12] BB[13] BB[14] BB[15] LOG0 LOG1 QB[3] QT[3] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[3] VBA[3] WBI[3] WTI[3] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_S4 VDDA VDDAI[4] VDDP[4] VDDPI[4] VSS[4] VBP[4]
+   VBN[4] BB[16] BB[17] BB[18] BB[19] LOG0 LOG1 QB[4] QT[4] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[4] VBA[4] WBI[4] WTI[4] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_S5 VDDA VDDAI[5] VDDP[5] VDDPI[5] VSS[5] VBP[5]
+   VBN[5] BB[20] BB[21] BB[22] BB[23] LOG0 LOG1 QB[5] QT[5] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[5] VBA[5] WBI[5] WTI[5] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_F5 VDDA VDDAI[6] VDDP[6] VDDPI[6] VSS[6] VBP[6]
+   VBN[6] BB[24] BB[25] BB[26] BB[27] LOG0 LOG1 QB[6] QT[6] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[6] VBA[6] WBI[6] WTI[6] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_F4 VDDA VDDAI[7] VDDP[7] VDDPI[7] VSS[7] VBP[7]
+   VBN[7] BB[28] BB[29] BB[30] BB[31] LOG0 LOG1 QB[7] QT[7] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[7] VBA[7] WBI[7] WTI[7] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_F3 VDDA VDDAI[8] VDDP[8] VDDPI[8] VSS[8] VBP[8]
+   VBN[8] BB[32] BB[33] BB[34] BB[35] LOG0 LOG1 QB[8] QT[8] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[8] VBA[8] WBI[8] WTI[8] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_F2 VDDA VDDAI[9] VDDP[9] VDDPI[9] VSS[9] VBP[9]
+   VBN[9] BB[36] BB[37] BB[38] BB[39] LOG0 LOG1 QB[9] QT[9] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[9] VBA[9] WBI[9] WTI[9] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_F1 VDDA VDDAI[10] VDDP[10] VDDPI[10] VSS[10]
+   VBP[10] VBN[10] BB[40] BB[41] BB[42] BB[43] LOG0 LOG1 QB[10] QT[10] LOG0
+   LOG0 LOG0 LOG0 SDOR SDOR_RET SEL[10] VBA[10] WBI[10] WTI[10] LLSB SDB_BC1T
+   SDB_BC2T mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_F0 VDDA VDDAI[11] VDDP[11] VDDPI[11] VSS[11]
+   VBP[11] VBN[11] BB[44] BB[45] BB[46] BB[47] LOG0 LOG1 QB[11] QT[11] LOG0
+   LOG0 LOG0 LOG0 SDOR SDOR_RET SEL[11] VBA[11] WBI[11] WTI[11] LLSB SDB_BC1T
+   SDB_BC2T mm16a05_u_hdsp_plus_rar4x1
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_ref_row_4 ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+       ARYSD_BC2[1] ARYSD_IN[0] ARYSD_IN[1] ARYSD_TOP[0] ARYSD_TOP[1] BB[0]
+       BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11]
+       BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+       BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31]
+       BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41]
+       BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51]
+       BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61]
+       BB[62] BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71]
+       BB[72] BB[73] BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81]
+       BB[82] BB[83] BB[84] BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91]
+       BB[92] BB[93] BB[94] BB[95] BB[96] BB[97] BB[98] BB[99] BB[100] BB[101]
+       BB[102] BB[103] BB[104] BB[105] BB[106] BB[107] BB[108] BB[109] BB[110]
+       BB[111] BB[112] BB[113] BB[114] BB[115] BB[116] BB[117] BB[118] BB[119]
+       BB[120] BB[121] BB[122] BB[123] BB[124] BB[125] BB[126] BB[127] CENDP
+       DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET FLOAT_RET_PROG
+       LBKADR0 LBKADR1 LCGTH[0] LCGTH[1] LDFTX LITESLP LLBKADRB[0] LLBKADRB[1]
+       LMATCHB LMATCHB_I LOG0[0] LOG0[1] LOG1[0] LOG1[1] LWEIB LXADR[0]
+       LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+       LYADR[1] PGIOI[0] PGIOI[1] PLBKADR[0] PLBKADR[1] QB[0] QB[1] QB[2] QB[3]
+       QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14]
+       QB[15] QB[16] QB[17] QB[18] QB[19] QB[20] QB[21] QB[22] QB[23] QB[24]
+       QB[25] QB[26] QB[27] QB[28] QB[29] QB[30] QB[31] QT[0] QT[1] QT[2] QT[3]
+       QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+       QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24]
+       QT[25] QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] RASSIST[0] RASSIST[1]
+       RASSIST[2] RASSIST[3] RASSISTBH[0] RASSISTBH[1] RASSISTBL[0]
+       RASSISTBL[1] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3]
+       RWLB_SAC RWL_DLY_0 RWL_DLY_2 RWL_DLY_4 RWL_DLY_RD_PGM RWL_DLY_WR_PGM
+       RWL_RWLD_AND RWL_RWLD_AND_WR SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5]
+       SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14]
+       SEL[15] SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21] SEL[22] SEL[23]
+       SEL[24] SEL[25] SEL[26] SEL[27] SEL[28] SEL[29] SEL[30] SEL[31] T1T
+       TEST_RNMB TOPEDGE[0] TOPEDGE[1] TOPEDGE[2] TOPEDGE[3] VBA[0] VBA[1]
+       VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11]
+       VBA[12] VBA[13] VBA[14] VBA[15] VBA[16] VBA[17] VBA[18] VBA[19] VBA[20]
+       VBA[21] VBA[22] VBA[23] VBA[24] VBA[25] VBA[26] VBA[27] VBA[28] VBA[29]
+       VBA[30] VBA[31] VBA[32] VBA[33] VBA[34] VBA[35] VBN[0] VBN[1] VBN[2]
+       VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12]
+       VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20] VBN[21]
+       VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28] VBN[29] VBN[30]
+       VBN[31] VBN[32] VBN[33] VBN[34] VBN[35] VBN[36] VBP[0] VBP[1] VBP[2]
+       VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+       VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21]
+       VBP[22] VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30]
+       VBP[31] VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VDDA[0] VDDA[1] VDDA[2]
+       VDDAIL1 VDDAIR1 VDDMINB VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5]
+       VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+       VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21]
+       VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDP[29]
+       VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34] VDDP[35] VDDP[36] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+       VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+       VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+       VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+       VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+       VDDWL[0] VDDWL[1] VEDGE[0] VEDGE[1] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4]
+       VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13]
+       VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22]
+       VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31]
+       VSS[32] VSS[33] VSS[34] VSS[35] VSS[36] VSSC_WL_L VSSC_WL_R WABUF[0]
+       WABUF[1] WABUF[2] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+       WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+       WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24]
+       WBI[25] WBI[26] WBI[27] WBI[28] WBI[29] WBI[30] WBI[31] WMT[0] WMT[1]
+       WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WTI[0] WTI[1] WTI[2] WTI[3]
+       WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12]
+       WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21]
+       WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27] WTI[28] WTI[29] WTI[30]
+       WTI[31]

*** Jumper Report ***
* Jumper: LOG1[1] PGIOI[1]
* Jumper: VBA[22] VSS[23]
* Jumper: VDDA[2] VDDP[23]

X_ref_lt BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32]
+   BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43]
+   BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54]
+   BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] LLSB[0]
+   LOG0[0] LOG1[0] PGIOI[0] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7]
+   QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] SDB_BC1T[0] SDB_BC2T[0] SDOR[0] SDOR_RET[0] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+   SEL[13] SEL[14] SEL[15] TOPEDGE[0] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15]
+   VBA[16] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBP[0] VBP[1]
+   VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VDDA[0] VDDAIL1 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDPI[0] VDDPI[1]
+   VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9]
+   VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16]
+   VEDGE[0] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+   VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] WBI[0] WBI[1]
+   WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11]
+   WBI[12] WBI[13] WBI[14] WBI[15] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_16Kx8_ref_lt_3
X_ref_cnt_rt_rwl ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1] ARYSD_IN[0]
+   ARYSD_IN[1] ARYSD_TOP[0] ARYSD_TOP[1] BB[64] BB[65] BB[66] BB[67] BB[68]
+   BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75] CENDP DEF_MODE FAST1_MODE
+   FAST2_MODE FLOAT FLOATT FLOAT_RET FLOAT_RET_PROG LBKADR0 LBKADR1 LCGTH[0]
+   LCGTH[1] LDFTX LITESLP LLBKADRB[0] LLBKADRB[1] LLSB[0] LLSB[1] LMATCHB
+   LMATCHB_I LOG0[0] LOG0[0] LOG0[0] LOG0[1] LOG1[0] LOG1[1] LWEIB LXADR[0]
+   LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+   LYADR[1] PLBKADR[0] PLBKADR[1] QB[16] QB[17] QB[18] QT[16] QT[17] QT[18]
+   RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RASSISTBH[0] RASSISTBH[1]
+   RASSISTBL[0] RASSISTBL[1] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2]
+   RMT[3] RWLB_SAC RWLD_RD RWLD_WR RWL_DLY_0 RWL_DLY_2 RWL_DLY_4 RWL_DLY_RD_PGM
+   RWL_DLY_WR_PGM RWLD_RD RWL_RWLD_AND RWL_RWLD_AND_WR RWLD_WR SDB_BC1T[0]
+   SDB_BC1T[1] SDB_BC2T[0] SDB_BC2T[1] SDOR[0] SDOR[1] SDOR_RET[0] SDOR_RET[1]
+   SEL[16] SEL[17] SEL[18] T1T TEST_RNMB TOPEDGE[1] TOPEDGE[2] VBA[17] VBA[18]
+   VBA[19] VBA[20] VBA[21] VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22]
+   VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VDDA[0] VDDA[1] VDDA[2]
+   VDDAIR1 VDDAIR1 VDDAIR1 VDDMINB VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21]
+   VDDP[22] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDWL[0] VDDWL[1] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSSC_WL_L
+   VSSC_WL_R WABUF[0] WABUF[1] WABUF[2] WBI[16] WBI[17] WBI[18] WMT[0] WMT[1]
+   WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WTI[16] WTI[17] WTI[18]
+   SNPS_SP_HD_16Kx8_ref_cnt_rt_rwl_3
X_mm16a05_u_hdsp_plus_rrtar4x1_top VDDA[2] VDDAIR1 VDDP[23] VDDPI[23] VSS[23]
+   VBP[23] VBN[23] BB[76] BB[77] BB[78] BB[79] LOG0[1] LOG1[1] QB[19] QT[19]
+   RWLD_RD RWLD_WR RWLD_RD RWLD_WR SDOR[1] SDOR_RET[1] SEL[19] VBA[22] WBI[19]
+   WTI[19] LLSB[1] SDB_BC1T[1] SDB_BC2T[1] mm16a05_u_hdsp_plus_rar4x1
X_ref_rt_log0 BB[80] BB[81] BB[82] BB[83] BB[84] BB[85] BB[86] BB[87] BB[88]
+   BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95] BB[96] BB[97] BB[98] BB[99]
+   BB[100] BB[101] BB[102] BB[103] BB[104] BB[105] BB[106] BB[107] BB[108]
+   BB[109] BB[110] BB[111] BB[112] BB[113] BB[114] BB[115] BB[116] BB[117]
+   BB[118] BB[119] BB[120] BB[121] BB[122] BB[123] BB[124] BB[125] BB[126]
+   BB[127] LLSB[1] LOG0[1] LOG1[1] QB[20] QB[21] QB[22] QB[23] QB[24] QB[25]
+   QB[26] QB[27] QB[28] QB[29] QB[30] QB[31] QT[20] QT[21] QT[22] QT[23] QT[24]
+   QT[25] QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] SDB_BC1T[1] SDB_BC2T[1]
+   SDOR[1] SDOR_RET[1] SEL[20] SEL[21] SEL[22] SEL[23] SEL[24] SEL[25] SEL[26]
+   SEL[27] SEL[28] SEL[29] SEL[30] SEL[31] VBA[23] VBA[24] VBA[25] VBA[26]
+   VBA[27] VBA[28] VBA[29] VBA[30] VBA[31] VBA[32] VBA[33] VBA[34] VBN[24]
+   VBN[25] VBN[26] VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33]
+   VBN[34] VBN[35] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30]
+   VBP[31] VBP[32] VBP[33] VBP[34] VBP[35] VDDA[2] VDDAIR1 VDDAIR1 VDDAIR1
+   VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1
+   VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31]
+   VDDP[32] VDDP[33] VDDP[34] VDDP[35] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27]
+   VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34]
+   VDDPI[35] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31]
+   VSS[32] VSS[33] VSS[34] VSS[35] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24]
+   WBI[25] WBI[26] WBI[27] WBI[28] WBI[29] WBI[30] WBI[31] WTI[20] WTI[21]
+   WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27] WTI[28] WTI[29] WTI[30]
+   WTI[31] SNPS_SP_HD_16Kx8_ref_rt_log0_3
X_mm16a05_u_hdsp_plus_pg_pwedge_top VDDA[2] VDDP[36] VDDPI[36] VSS[36] VBP[36]
+   VBN[36] LOG0[1] LOG1[1] PGIOI[1] PO SDOR_RET[1] TOPEDGE[3] VBA[35] VEDGE[1]
+   SDOR[1] mm16a05_u_hdsp_plus_pg_pwedge
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_top ARYSD[8] ARYSD[9] ARYSD_BC1[0] ARYSD_BC1[1]
+       ARYSD_BC2[0] ARYSD_BC2[1] BC0 BC1 BC2 CENDP CLK D[0] D[1] D[2] D[3] D[4]
+       D[5] D[6] D[7] DEF_MODE DS FAST1_MODE FAST2_MODE FISO FLOAT FLOATT
+       FLOAT_RET FLOAT_RET_PROG[1] LBKADR0 LBKADR1 LDFTX LITESLP LMATCHB LOG0
+       LOG1 LS LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+       LXADR[6] LXADR[7] LYADR[0] LYADR[1] ME PWDO[0] PWDO[1] Q[0] Q[1] Q[2]
+       Q[3] Q[4] Q[5] Q[6] Q[7] QB[64] QB[65] QB[66] QB[67] QB[68] QB[69]
+       QB[70] QB[71] QB[72] QB[73] QB[74] QB[75] QB[76] QB[77] QB[78] QB[79]
+       QB[80] QB[81] QB[82] QB[83] QB[84] QB[85] QB[86] QB[87] QB[88] QB[89]
+       QB[90] QB[91] QB[92] QB[93] QB[94] QB[95] QT[64] QT[65] QT[66] QT[67]
+       QT[68] QT[69] QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77]
+       QT[78] QT[79] QT[80] QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87]
+       QT[88] QT[89] QT[90] QT[91] QT[92] QT[93] QT[94] QT[95] RA[0] RA[1]
+       RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RM[0] RM[1] RM[2] RM[3]
+       RM3CNT RME RMT[0] RMT[1] RMT[2] RMT[3] ROP RWLB_SAC[2] RWL_RWLD_AND[1]
+       RWL_RWLD_AND_WR[1] SD SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+       SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15]
+       SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21] SEL[22] SEL[23] SEL[24]
+       SEL[25] SEL[26] SEL[27] SEL[28] SEL[29] SEL[30] SEL[31] SO_D[0] SO_D[1]
+       SO_Q[0] SO_Q[1] T1T TEST1 TEST_RNM TEST_RNMB TOPEDGE[8] TOPEDGE[9]
+       TOPEDGE[10] TOPEDGE[11] VBA VBN VBP VDDA VDDMINB VDDP VDDPI VEDGE[0]
+       VEDGE[1] VSS WA[0] WA[1] WABUF[0] WABUF[1] WABUF[2] WB_IN[0] WB_IN[1]
+       WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9]
+       WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WB_IN[16]
+       WB_IN[17] WB_IN[18] WB_IN[19] WB_IN[20] WB_IN[21] WB_IN[22] WB_IN[23]
+       WB_IN[24] WB_IN[25] WB_IN[26] WB_IN[27] WB_IN[28] WB_IN[29] WB_IN[30]
+       WB_IN[31] WE WEM[0] WEM[1] WEM[2] WEM[3] WEM[4] WEM[5] WEM[6] WEM[7]
+       WLH[0] WLH[1] WLH[2] WLH[3] WLH[4] WLH[5] WLH[6] WLH[7] WLH[8] WLH[9]
+       WLH[10] WLH[11] WLH[12] WLH[13] WLH[14] WLH[15] WLH[16] WLH[17] WLH[18]
+       WLH[19] WLH[20] WLH[21] WLH[22] WLH[23] WLH[24] WLH[25] WLH[26] WLH[27]
+       WLH[28] WLH[29] WLH[30] WLH[31] WLH[32] WLH[33] WLH[34] WLH[35] WLH[36]
+       WLH[37] WLH[38] WLH[39] WLH[40] WLH[41] WLH[42] WLH[43] WLH[44] WLH[45]
+       WLH[46] WLH[47] WLH[48] WLH[49] WLH[50] WLH[51] WLH[52] WLH[53] WLH[54]
+       WLH[55] WLH[56] WLH[57] WLH[58] WLH[59] WLH[60] WLH[61] WLH[62] WLH[63]
+       WLH[64] WLH[65] WLH[66] WLH[67] WLH[68] WLH[69] WLH[70] WLH[71] WLH[72]
+       WLH[73] WLH[74] WLH[75] WLH[76] WLH[77] WLH[78] WLH[79] WLH[80] WLH[81]
+       WLH[82] WLH[83] WLH[84] WLH[85] WLH[86] WLH[87] WLH[88] WLH[89] WLH[90]
+       WLH[91] WLH[92] WLH[93] WLH[94] WLH[95] WLH[96] WLH[97] WLH[98] WLH[99]
+       WLH[100] WLH[101] WLH[102] WLH[103] WLH[104] WLH[105] WLH[106] WLH[107]
+       WLH[108] WLH[109] WLH[110] WLH[111] WLH[112] WLH[113] WLH[114] WLH[115]
+       WLH[116] WLH[117] WLH[118] WLH[119] WLH[120] WLH[121] WLH[122] WLH[123]
+       WLH[124] WLH[125] WLH[126] WLH[127] WLH[128] WLH[129] WLH[130] WLH[131]
+       WLH[132] WLH[133] WLH[134] WLH[135] WLH[136] WLH[137] WLH[138] WLH[139]
+       WLH[140] WLH[141] WLH[142] WLH[143] WLH[144] WLH[145] WLH[146] WLH[147]
+       WLH[148] WLH[149] WLH[150] WLH[151] WLH[152] WLH[153] WLH[154] WLH[155]
+       WLH[156] WLH[157] WLH[158] WLH[159] WLH[160] WLH[161] WLH[162] WLH[163]
+       WLH[164] WLH[165] WLH[166] WLH[167] WLH[168] WLH[169] WLH[170] WLH[171]
+       WLH[172] WLH[173] WLH[174] WLH[175] WLH[176] WLH[177] WLH[178] WLH[179]
+       WLH[180] WLH[181] WLH[182] WLH[183] WLH[184] WLH[185] WLH[186] WLH[187]
+       WLH[188] WLH[189] WLH[190] WLH[191] WLH[192] WLH[193] WLH[194] WLH[195]
+       WLH[196] WLH[197] WLH[198] WLH[199] WLH[200] WLH[201] WLH[202] WLH[203]
+       WLH[204] WLH[205] WLH[206] WLH[207] WLH[208] WLH[209] WLH[210] WLH[211]
+       WLH[212] WLH[213] WLH[214] WLH[215] WLH[216] WLH[217] WLH[218] WLH[219]
+       WLH[220] WLH[221] WLH[222] WLH[223] WLH[224] WLH[225] WLH[226] WLH[227]
+       WLH[228] WLH[229] WLH[230] WLH[231] WLH[232] WLH[233] WLH[234] WLH[235]
+       WLH[236] WLH[237] WLH[238] WLH[239] WLH[240] WLH[241] WLH[242] WLH[243]
+       WLH[244] WLH[245] WLH[246] WLH[247] WLH[248] WLH[249] WLH[250] WLH[251]
+       WLH[252] WLH[253] WLH[254] WLH[255] WLH[256] WLH[257] WLH[258] WLH[259]
+       WLH[260] WLH[261] WLH[262] WLH[263] WLH[264] WLH[265] WLH[266] WLH[267]
+       WLH[268] WLH[269] WLH[270] WLH[271] WLH[272] WLH[273] WLH[274] WLH[275]
+       WLH[276] WLH[277] WLH[278] WLH[279] WLH[280] WLH[281] WLH[282] WLH[283]
+       WLH[284] WLH[285] WLH[286] WLH[287] WLH[288] WLH[289] WLH[290] WLH[291]
+       WLH[292] WLH[293] WLH[294] WLH[295] WLH[296] WLH[297] WLH[298] WLH[299]
+       WLH[300] WLH[301] WLH[302] WLH[303] WLH[304] WLH[305] WLH[306] WLH[307]
+       WLH[308] WLH[309] WLH[310] WLH[311] WLH[312] WLH[313] WLH[314] WLH[315]
+       WLH[316] WLH[317] WLH[318] WLH[319] WLH[320] WLH[321] WLH[322] WLH[323]
+       WLH[324] WLH[325] WLH[326] WLH[327] WLH[328] WLH[329] WLH[330] WLH[331]
+       WLH[332] WLH[333] WLH[334] WLH[335] WLH[336] WLH[337] WLH[338] WLH[339]
+       WLH[340] WLH[341] WLH[342] WLH[343] WLH[344] WLH[345] WLH[346] WLH[347]
+       WLH[348] WLH[349] WLH[350] WLH[351] WLH[352] WLH[353] WLH[354] WLH[355]
+       WLH[356] WLH[357] WLH[358] WLH[359] WLH[360] WLH[361] WLH[362] WLH[363]
+       WLH[364] WLH[365] WLH[366] WLH[367] WLH[368] WLH[369] WLH[370] WLH[371]
+       WLH[372] WLH[373] WLH[374] WLH[375] WLH[376] WLH[377] WLH[378] WLH[379]
+       WLH[380] WLH[381] WLH[382] WLH[383] WLH[384] WLH[385] WLH[386] WLH[387]
+       WLH[388] WLH[389] WLH[390] WLH[391] WLH[392] WLH[393] WLH[394] WLH[395]
+       WLH[396] WLH[397] WLH[398] WLH[399] WLH[400] WLH[401] WLH[402] WLH[403]
+       WLH[404] WLH[405] WLH[406] WLH[407] WLH[408] WLH[409] WLH[410] WLH[411]
+       WLH[412] WLH[413] WLH[414] WLH[415] WLH[416] WLH[417] WLH[418] WLH[419]
+       WLH[420] WLH[421] WLH[422] WLH[423] WLH[424] WLH[425] WLH[426] WLH[427]
+       WLH[428] WLH[429] WLH[430] WLH[431] WLH[432] WLH[433] WLH[434] WLH[435]
+       WLH[436] WLH[437] WLH[438] WLH[439] WLH[440] WLH[441] WLH[442] WLH[443]
+       WLH[444] WLH[445] WLH[446] WLH[447] WLH[448] WLH[449] WLH[450] WLH[451]
+       WLH[452] WLH[453] WLH[454] WLH[455] WLH[456] WLH[457] WLH[458] WLH[459]
+       WLH[460] WLH[461] WLH[462] WLH[463] WLH[464] WLH[465] WLH[466] WLH[467]
+       WLH[468] WLH[469] WLH[470] WLH[471] WLH[472] WLH[473] WLH[474] WLH[475]
+       WLH[476] WLH[477] WLH[478] WLH[479] WLH[480] WLH[481] WLH[482] WLH[483]
+       WLH[484] WLH[485] WLH[486] WLH[487] WLH[488] WLH[489] WLH[490] WLH[491]
+       WLH[492] WLH[493] WLH[494] WLH[495] WLH[496] WLH[497] WLH[498] WLH[499]
+       WLH[500] WLH[501] WLH[502] WLH[503] WLH[504] WLH[505] WLH[506] WLH[507]
+       WLH[508] WLH[509] WLH[510] WLH[511] WLH[512] WLH[513] WLH[514] WLH[515]
+       WLH[516] WLH[517] WLH[518] WLH[519] WLH[520] WLH[521] WLH[522] WLH[523]
+       WLH[524] WLH[525] WLH[526] WLH[527] WLH[528] WLH[529] WLH[530] WLH[531]
+       WLH[532] WLH[533] WLH[534] WLH[535] WLH[536] WLH[537] WLH[538] WLH[539]
+       WLH[540] WLH[541] WLH[542] WLH[543] WLH[544] WLH[545] WLH[546] WLH[547]
+       WLH[548] WLH[549] WLH[550] WLH[551] WLH[552] WLH[553] WLH[554] WLH[555]
+       WLH[556] WLH[557] WLH[558] WLH[559] WLH[560] WLH[561] WLH[562] WLH[563]
+       WLH[564] WLH[565] WLH[566] WLH[567] WLH[568] WLH[569] WLH[570] WLH[571]
+       WLH[572] WLH[573] WLH[574] WLH[575] WLH[576] WLH[577] WLH[578] WLH[579]
+       WLH[580] WLH[581] WLH[582] WLH[583] WLH[584] WLH[585] WLH[586] WLH[587]
+       WLH[588] WLH[589] WLH[590] WLH[591] WLH[592] WLH[593] WLH[594] WLH[595]
+       WLH[596] WLH[597] WLH[598] WLH[599] WLH[600] WLH[601] WLH[602] WLH[603]
+       WLH[604] WLH[605] WLH[606] WLH[607] WLH[608] WLH[609] WLH[610] WLH[611]
+       WLH[612] WLH[613] WLH[614] WLH[615] WLH[616] WLH[617] WLH[618] WLH[619]
+       WLH[620] WLH[621] WLH[622] WLH[623] WLH[624] WLH[625] WLH[626] WLH[627]
+       WLH[628] WLH[629] WLH[630] WLH[631] WLH[632] WLH[633] WLH[634] WLH[635]
+       WLH[636] WLH[637] WLH[638] WLH[639] WLH[640] WLH[641] WLH[642] WLH[643]
+       WLH[644] WLH[645] WLH[646] WLH[647] WLH[648] WLH[649] WLH[650] WLH[651]
+       WLH[652] WLH[653] WLH[654] WLH[655] WLH[656] WLH[657] WLH[658] WLH[659]
+       WLH[660] WLH[661] WLH[662] WLH[663] WLH[664] WLH[665] WLH[666] WLH[667]
+       WLH[668] WLH[669] WLH[670] WLH[671] WLH[672] WLH[673] WLH[674] WLH[675]
+       WLH[676] WLH[677] WLH[678] WLH[679] WLH[680] WLH[681] WLH[682] WLH[683]
+       WLH[684] WLH[685] WLH[686] WLH[687] WLH[688] WLH[689] WLH[690] WLH[691]
+       WLH[692] WLH[693] WLH[694] WLH[695] WLH[696] WLH[697] WLH[698] WLH[699]
+       WLH[700] WLH[701] WLH[702] WLH[703] WLH[704] WLH[705] WLH[706] WLH[707]
+       WLH[708] WLH[709] WLH[710] WLH[711] WLH[712] WLH[713] WLH[714] WLH[715]
+       WLH[716] WLH[717] WLH[718] WLH[719] WLH[720] WLH[721] WLH[722] WLH[723]
+       WLH[724] WLH[725] WLH[726] WLH[727] WLH[728] WLH[729] WLH[730] WLH[731]
+       WLH[732] WLH[733] WLH[734] WLH[735] WLH[736] WLH[737] WLH[738] WLH[739]
+       WLH[740] WLH[741] WLH[742] WLH[743] WLH[744] WLH[745] WLH[746] WLH[747]
+       WLH[748] WLH[749] WLH[750] WLH[751] WLH[752] WLH[753] WLH[754] WLH[755]
+       WLH[756] WLH[757] WLH[758] WLH[759] WLH[760] WLH[761] WLH[762] WLH[763]
+       WLH[764] WLH[765] WLH[766] WLH[767] WLH[768] WLH[769] WLH[770] WLH[771]
+       WLH[772] WLH[773] WLH[774] WLH[775] WLH[776] WLH[777] WLH[778] WLH[779]
+       WLH[780] WLH[781] WLH[782] WLH[783] WLH[784] WLH[785] WLH[786] WLH[787]
+       WLH[788] WLH[789] WLH[790] WLH[791] WLH[792] WLH[793] WLH[794] WLH[795]
+       WLH[796] WLH[797] WLH[798] WLH[799] WLH[800] WLH[801] WLH[802] WLH[803]
+       WLH[804] WLH[805] WLH[806] WLH[807] WLH[808] WLH[809] WLH[810] WLH[811]
+       WLH[812] WLH[813] WLH[814] WLH[815] WLH[816] WLH[817] WLH[818] WLH[819]
+       WLH[820] WLH[821] WLH[822] WLH[823] WLH[824] WLH[825] WLH[826] WLH[827]
+       WLH[828] WLH[829] WLH[830] WLH[831] WLH[832] WLH[833] WLH[834] WLH[835]
+       WLH[836] WLH[837] WLH[838] WLH[839] WLH[840] WLH[841] WLH[842] WLH[843]
+       WLH[844] WLH[845] WLH[846] WLH[847] WLH[848] WLH[849] WLH[850] WLH[851]
+       WLH[852] WLH[853] WLH[854] WLH[855] WLH[856] WLH[857] WLH[858] WLH[859]
+       WLH[860] WLH[861] WLH[862] WLH[863] WLH[864] WLH[865] WLH[866] WLH[867]
+       WLH[868] WLH[869] WLH[870] WLH[871] WLH[872] WLH[873] WLH[874] WLH[875]
+       WLH[876] WLH[877] WLH[878] WLH[879] WLH[880] WLH[881] WLH[882] WLH[883]
+       WLH[884] WLH[885] WLH[886] WLH[887] WLH[888] WLH[889] WLH[890] WLH[891]
+       WLH[892] WLH[893] WLH[894] WLH[895] WLH[896] WLH[897] WLH[898] WLH[899]
+       WLH[900] WLH[901] WLH[902] WLH[903] WLH[904] WLH[905] WLH[906] WLH[907]
+       WLH[908] WLH[909] WLH[910] WLH[911] WLH[912] WLH[913] WLH[914] WLH[915]
+       WLH[916] WLH[917] WLH[918] WLH[919] WLH[920] WLH[921] WLH[922] WLH[923]
+       WLH[924] WLH[925] WLH[926] WLH[927] WLH[928] WLH[929] WLH[930] WLH[931]
+       WLH[932] WLH[933] WLH[934] WLH[935] WLH[936] WLH[937] WLH[938] WLH[939]
+       WLH[940] WLH[941] WLH[942] WLH[943] WLH[944] WLH[945] WLH[946] WLH[947]
+       WLH[948] WLH[949] WLH[950] WLH[951] WLH[952] WLH[953] WLH[954] WLH[955]
+       WLH[956] WLH[957] WLH[958] WLH[959] WLH[960] WLH[961] WLH[962] WLH[963]
+       WLH[964] WLH[965] WLH[966] WLH[967] WLH[968] WLH[969] WLH[970] WLH[971]
+       WLH[972] WLH[973] WLH[974] WLH[975] WLH[976] WLH[977] WLH[978] WLH[979]
+       WLH[980] WLH[981] WLH[982] WLH[983] WLH[984] WLH[985] WLH[986] WLH[987]
+       WLH[988] WLH[989] WLH[990] WLH[991] WLH[992] WLH[993] WLH[994] WLH[995]
+       WLH[996] WLH[997] WLH[998] WLH[999] WLH[1000] WLH[1001] WLH[1002]
+       WLH[1003] WLH[1004] WLH[1005] WLH[1006] WLH[1007] WLH[1008] WLH[1009]
+       WLH[1010] WLH[1011] WLH[1012] WLH[1013] WLH[1014] WLH[1015] WLH[1016]
+       WLH[1017] WLH[1018] WLH[1019] WLH[1020] WLH[1021] WLH[1022] WLH[1023]
+       WLL[0] WLL[1] WLL[2] WLL[3] WLL[4] WLL[5] WLL[6] WLL[7] WLL[8] WLL[9]
+       WLL[10] WLL[11] WLL[12] WLL[13] WLL[14] WLL[15] WLL[16] WLL[17] WLL[18]
+       WLL[19] WLL[20] WLL[21] WLL[22] WLL[23] WLL[24] WLL[25] WLL[26] WLL[27]
+       WLL[28] WLL[29] WLL[30] WLL[31] WLL[32] WLL[33] WLL[34] WLL[35] WLL[36]
+       WLL[37] WLL[38] WLL[39] WLL[40] WLL[41] WLL[42] WLL[43] WLL[44] WLL[45]
+       WLL[46] WLL[47] WLL[48] WLL[49] WLL[50] WLL[51] WLL[52] WLL[53] WLL[54]
+       WLL[55] WLL[56] WLL[57] WLL[58] WLL[59] WLL[60] WLL[61] WLL[62] WLL[63]
+       WLL[64] WLL[65] WLL[66] WLL[67] WLL[68] WLL[69] WLL[70] WLL[71] WLL[72]
+       WLL[73] WLL[74] WLL[75] WLL[76] WLL[77] WLL[78] WLL[79] WLL[80] WLL[81]
+       WLL[82] WLL[83] WLL[84] WLL[85] WLL[86] WLL[87] WLL[88] WLL[89] WLL[90]
+       WLL[91] WLL[92] WLL[93] WLL[94] WLL[95] WLL[96] WLL[97] WLL[98] WLL[99]
+       WLL[100] WLL[101] WLL[102] WLL[103] WLL[104] WLL[105] WLL[106] WLL[107]
+       WLL[108] WLL[109] WLL[110] WLL[111] WLL[112] WLL[113] WLL[114] WLL[115]
+       WLL[116] WLL[117] WLL[118] WLL[119] WLL[120] WLL[121] WLL[122] WLL[123]
+       WLL[124] WLL[125] WLL[126] WLL[127] WLL[128] WLL[129] WLL[130] WLL[131]
+       WLL[132] WLL[133] WLL[134] WLL[135] WLL[136] WLL[137] WLL[138] WLL[139]
+       WLL[140] WLL[141] WLL[142] WLL[143] WLL[144] WLL[145] WLL[146] WLL[147]
+       WLL[148] WLL[149] WLL[150] WLL[151] WLL[152] WLL[153] WLL[154] WLL[155]
+       WLL[156] WLL[157] WLL[158] WLL[159] WLL[160] WLL[161] WLL[162] WLL[163]
+       WLL[164] WLL[165] WLL[166] WLL[167] WLL[168] WLL[169] WLL[170] WLL[171]
+       WLL[172] WLL[173] WLL[174] WLL[175] WLL[176] WLL[177] WLL[178] WLL[179]
+       WLL[180] WLL[181] WLL[182] WLL[183] WLL[184] WLL[185] WLL[186] WLL[187]
+       WLL[188] WLL[189] WLL[190] WLL[191] WLL[192] WLL[193] WLL[194] WLL[195]
+       WLL[196] WLL[197] WLL[198] WLL[199] WLL[200] WLL[201] WLL[202] WLL[203]
+       WLL[204] WLL[205] WLL[206] WLL[207] WLL[208] WLL[209] WLL[210] WLL[211]
+       WLL[212] WLL[213] WLL[214] WLL[215] WLL[216] WLL[217] WLL[218] WLL[219]
+       WLL[220] WLL[221] WLL[222] WLL[223] WLL[224] WLL[225] WLL[226] WLL[227]
+       WLL[228] WLL[229] WLL[230] WLL[231] WLL[232] WLL[233] WLL[234] WLL[235]
+       WLL[236] WLL[237] WLL[238] WLL[239] WLL[240] WLL[241] WLL[242] WLL[243]
+       WLL[244] WLL[245] WLL[246] WLL[247] WLL[248] WLL[249] WLL[250] WLL[251]
+       WLL[252] WLL[253] WLL[254] WLL[255] WLL[256] WLL[257] WLL[258] WLL[259]
+       WLL[260] WLL[261] WLL[262] WLL[263] WLL[264] WLL[265] WLL[266] WLL[267]
+       WLL[268] WLL[269] WLL[270] WLL[271] WLL[272] WLL[273] WLL[274] WLL[275]
+       WLL[276] WLL[277] WLL[278] WLL[279] WLL[280] WLL[281] WLL[282] WLL[283]
+       WLL[284] WLL[285] WLL[286] WLL[287] WLL[288] WLL[289] WLL[290] WLL[291]
+       WLL[292] WLL[293] WLL[294] WLL[295] WLL[296] WLL[297] WLL[298] WLL[299]
+       WLL[300] WLL[301] WLL[302] WLL[303] WLL[304] WLL[305] WLL[306] WLL[307]
+       WLL[308] WLL[309] WLL[310] WLL[311] WLL[312] WLL[313] WLL[314] WLL[315]
+       WLL[316] WLL[317] WLL[318] WLL[319] WLL[320] WLL[321] WLL[322] WLL[323]
+       WLL[324] WLL[325] WLL[326] WLL[327] WLL[328] WLL[329] WLL[330] WLL[331]
+       WLL[332] WLL[333] WLL[334] WLL[335] WLL[336] WLL[337] WLL[338] WLL[339]
+       WLL[340] WLL[341] WLL[342] WLL[343] WLL[344] WLL[345] WLL[346] WLL[347]
+       WLL[348] WLL[349] WLL[350] WLL[351] WLL[352] WLL[353] WLL[354] WLL[355]
+       WLL[356] WLL[357] WLL[358] WLL[359] WLL[360] WLL[361] WLL[362] WLL[363]
+       WLL[364] WLL[365] WLL[366] WLL[367] WLL[368] WLL[369] WLL[370] WLL[371]
+       WLL[372] WLL[373] WLL[374] WLL[375] WLL[376] WLL[377] WLL[378] WLL[379]
+       WLL[380] WLL[381] WLL[382] WLL[383] WLL[384] WLL[385] WLL[386] WLL[387]
+       WLL[388] WLL[389] WLL[390] WLL[391] WLL[392] WLL[393] WLL[394] WLL[395]
+       WLL[396] WLL[397] WLL[398] WLL[399] WLL[400] WLL[401] WLL[402] WLL[403]
+       WLL[404] WLL[405] WLL[406] WLL[407] WLL[408] WLL[409] WLL[410] WLL[411]
+       WLL[412] WLL[413] WLL[414] WLL[415] WLL[416] WLL[417] WLL[418] WLL[419]
+       WLL[420] WLL[421] WLL[422] WLL[423] WLL[424] WLL[425] WLL[426] WLL[427]
+       WLL[428] WLL[429] WLL[430] WLL[431] WLL[432] WLL[433] WLL[434] WLL[435]
+       WLL[436] WLL[437] WLL[438] WLL[439] WLL[440] WLL[441] WLL[442] WLL[443]
+       WLL[444] WLL[445] WLL[446] WLL[447] WLL[448] WLL[449] WLL[450] WLL[451]
+       WLL[452] WLL[453] WLL[454] WLL[455] WLL[456] WLL[457] WLL[458] WLL[459]
+       WLL[460] WLL[461] WLL[462] WLL[463] WLL[464] WLL[465] WLL[466] WLL[467]
+       WLL[468] WLL[469] WLL[470] WLL[471] WLL[472] WLL[473] WLL[474] WLL[475]
+       WLL[476] WLL[477] WLL[478] WLL[479] WLL[480] WLL[481] WLL[482] WLL[483]
+       WLL[484] WLL[485] WLL[486] WLL[487] WLL[488] WLL[489] WLL[490] WLL[491]
+       WLL[492] WLL[493] WLL[494] WLL[495] WLL[496] WLL[497] WLL[498] WLL[499]
+       WLL[500] WLL[501] WLL[502] WLL[503] WLL[504] WLL[505] WLL[506] WLL[507]
+       WLL[508] WLL[509] WLL[510] WLL[511] WLL[512] WLL[513] WLL[514] WLL[515]
+       WLL[516] WLL[517] WLL[518] WLL[519] WLL[520] WLL[521] WLL[522] WLL[523]
+       WLL[524] WLL[525] WLL[526] WLL[527] WLL[528] WLL[529] WLL[530] WLL[531]
+       WLL[532] WLL[533] WLL[534] WLL[535] WLL[536] WLL[537] WLL[538] WLL[539]
+       WLL[540] WLL[541] WLL[542] WLL[543] WLL[544] WLL[545] WLL[546] WLL[547]
+       WLL[548] WLL[549] WLL[550] WLL[551] WLL[552] WLL[553] WLL[554] WLL[555]
+       WLL[556] WLL[557] WLL[558] WLL[559] WLL[560] WLL[561] WLL[562] WLL[563]
+       WLL[564] WLL[565] WLL[566] WLL[567] WLL[568] WLL[569] WLL[570] WLL[571]
+       WLL[572] WLL[573] WLL[574] WLL[575] WLL[576] WLL[577] WLL[578] WLL[579]
+       WLL[580] WLL[581] WLL[582] WLL[583] WLL[584] WLL[585] WLL[586] WLL[587]
+       WLL[588] WLL[589] WLL[590] WLL[591] WLL[592] WLL[593] WLL[594] WLL[595]
+       WLL[596] WLL[597] WLL[598] WLL[599] WLL[600] WLL[601] WLL[602] WLL[603]
+       WLL[604] WLL[605] WLL[606] WLL[607] WLL[608] WLL[609] WLL[610] WLL[611]
+       WLL[612] WLL[613] WLL[614] WLL[615] WLL[616] WLL[617] WLL[618] WLL[619]
+       WLL[620] WLL[621] WLL[622] WLL[623] WLL[624] WLL[625] WLL[626] WLL[627]
+       WLL[628] WLL[629] WLL[630] WLL[631] WLL[632] WLL[633] WLL[634] WLL[635]
+       WLL[636] WLL[637] WLL[638] WLL[639] WLL[640] WLL[641] WLL[642] WLL[643]
+       WLL[644] WLL[645] WLL[646] WLL[647] WLL[648] WLL[649] WLL[650] WLL[651]
+       WLL[652] WLL[653] WLL[654] WLL[655] WLL[656] WLL[657] WLL[658] WLL[659]
+       WLL[660] WLL[661] WLL[662] WLL[663] WLL[664] WLL[665] WLL[666] WLL[667]
+       WLL[668] WLL[669] WLL[670] WLL[671] WLL[672] WLL[673] WLL[674] WLL[675]
+       WLL[676] WLL[677] WLL[678] WLL[679] WLL[680] WLL[681] WLL[682] WLL[683]
+       WLL[684] WLL[685] WLL[686] WLL[687] WLL[688] WLL[689] WLL[690] WLL[691]
+       WLL[692] WLL[693] WLL[694] WLL[695] WLL[696] WLL[697] WLL[698] WLL[699]
+       WLL[700] WLL[701] WLL[702] WLL[703] WLL[704] WLL[705] WLL[706] WLL[707]
+       WLL[708] WLL[709] WLL[710] WLL[711] WLL[712] WLL[713] WLL[714] WLL[715]
+       WLL[716] WLL[717] WLL[718] WLL[719] WLL[720] WLL[721] WLL[722] WLL[723]
+       WLL[724] WLL[725] WLL[726] WLL[727] WLL[728] WLL[729] WLL[730] WLL[731]
+       WLL[732] WLL[733] WLL[734] WLL[735] WLL[736] WLL[737] WLL[738] WLL[739]
+       WLL[740] WLL[741] WLL[742] WLL[743] WLL[744] WLL[745] WLL[746] WLL[747]
+       WLL[748] WLL[749] WLL[750] WLL[751] WLL[752] WLL[753] WLL[754] WLL[755]
+       WLL[756] WLL[757] WLL[758] WLL[759] WLL[760] WLL[761] WLL[762] WLL[763]
+       WLL[764] WLL[765] WLL[766] WLL[767] WLL[768] WLL[769] WLL[770] WLL[771]
+       WLL[772] WLL[773] WLL[774] WLL[775] WLL[776] WLL[777] WLL[778] WLL[779]
+       WLL[780] WLL[781] WLL[782] WLL[783] WLL[784] WLL[785] WLL[786] WLL[787]
+       WLL[788] WLL[789] WLL[790] WLL[791] WLL[792] WLL[793] WLL[794] WLL[795]
+       WLL[796] WLL[797] WLL[798] WLL[799] WLL[800] WLL[801] WLL[802] WLL[803]
+       WLL[804] WLL[805] WLL[806] WLL[807] WLL[808] WLL[809] WLL[810] WLL[811]
+       WLL[812] WLL[813] WLL[814] WLL[815] WLL[816] WLL[817] WLL[818] WLL[819]
+       WLL[820] WLL[821] WLL[822] WLL[823] WLL[824] WLL[825] WLL[826] WLL[827]
+       WLL[828] WLL[829] WLL[830] WLL[831] WLL[832] WLL[833] WLL[834] WLL[835]
+       WLL[836] WLL[837] WLL[838] WLL[839] WLL[840] WLL[841] WLL[842] WLL[843]
+       WLL[844] WLL[845] WLL[846] WLL[847] WLL[848] WLL[849] WLL[850] WLL[851]
+       WLL[852] WLL[853] WLL[854] WLL[855] WLL[856] WLL[857] WLL[858] WLL[859]
+       WLL[860] WLL[861] WLL[862] WLL[863] WLL[864] WLL[865] WLL[866] WLL[867]
+       WLL[868] WLL[869] WLL[870] WLL[871] WLL[872] WLL[873] WLL[874] WLL[875]
+       WLL[876] WLL[877] WLL[878] WLL[879] WLL[880] WLL[881] WLL[882] WLL[883]
+       WLL[884] WLL[885] WLL[886] WLL[887] WLL[888] WLL[889] WLL[890] WLL[891]
+       WLL[892] WLL[893] WLL[894] WLL[895] WLL[896] WLL[897] WLL[898] WLL[899]
+       WLL[900] WLL[901] WLL[902] WLL[903] WLL[904] WLL[905] WLL[906] WLL[907]
+       WLL[908] WLL[909] WLL[910] WLL[911] WLL[912] WLL[913] WLL[914] WLL[915]
+       WLL[916] WLL[917] WLL[918] WLL[919] WLL[920] WLL[921] WLL[922] WLL[923]
+       WLL[924] WLL[925] WLL[926] WLL[927] WLL[928] WLL[929] WLL[930] WLL[931]
+       WLL[932] WLL[933] WLL[934] WLL[935] WLL[936] WLL[937] WLL[938] WLL[939]
+       WLL[940] WLL[941] WLL[942] WLL[943] WLL[944] WLL[945] WLL[946] WLL[947]
+       WLL[948] WLL[949] WLL[950] WLL[951] WLL[952] WLL[953] WLL[954] WLL[955]
+       WLL[956] WLL[957] WLL[958] WLL[959] WLL[960] WLL[961] WLL[962] WLL[963]
+       WLL[964] WLL[965] WLL[966] WLL[967] WLL[968] WLL[969] WLL[970] WLL[971]
+       WLL[972] WLL[973] WLL[974] WLL[975] WLL[976] WLL[977] WLL[978] WLL[979]
+       WLL[980] WLL[981] WLL[982] WLL[983] WLL[984] WLL[985] WLL[986] WLL[987]
+       WLL[988] WLL[989] WLL[990] WLL[991] WLL[992] WLL[993] WLL[994] WLL[995]
+       WLL[996] WLL[997] WLL[998] WLL[999] WLL[1000] WLL[1001] WLL[1002]
+       WLL[1003] WLL[1004] WLL[1005] WLL[1006] WLL[1007] WLL[1008] WLL[1009]
+       WLL[1010] WLL[1011] WLL[1012] WLL[1013] WLL[1014] WLL[1015] WLL[1016]
+       WLL[1017] WLL[1018] WLL[1019] WLL[1020] WLL[1021] WLL[1022] WLL[1023]
+       WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WPULSE[0]
+       WPULSE[1] WPULSE[2] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4]
+       WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11]
+       WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15] WT_IN[16] WT_IN[17] WT_IN[18]
+       WT_IN[19] WT_IN[20] WT_IN[21] WT_IN[22] WT_IN[23] WT_IN[24] WT_IN[25]
+       WT_IN[26] WT_IN[27] WT_IN[28] WT_IN[29] WT_IN[30] WT_IN[31] XADR[0]
+       XADR[1] XADR[2] XADR[3] XADR[4] XADR[5] XADR[6] XADR[7] XBKADR[0]
+       XBKADR[1] XBKADR[2] YADR[0] YADR[1] YADR[2] YADR[3]

*** Jumper Report ***
* Jumper: LOG1 WEM[0] WEM[1] WEM[2] WEM[3] WEM[4] WEM[5] WEM[6] WEM[7]

*X_pin_row BC0 BC1 BC2 CLK D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] DS FISO LOG0
*+  LOG0 LOG0 LOG1 LOG1 LOG1 LS ME Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] QP[0]
*+  QP[1] QP[2] QP[3] QP[4] QP[5] QP[6] QP[7] RA[0] RA[1] RM[0] RM[1] RM[2]
*+  RM[3] RME ROP LOG0 LOG0 LOG0 LOG0 LOG0 SD SO_D[0] SO_D[1] SO_Q[0] SO_Q[1]
*+  TEST1 TEST_RNM VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBP VBP
*+  VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VDDP VDDP VDDP VDDP VDDP VDDP
*+  VDDP VDDP VDDP VDDP VDDP VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
*+  VDDPI VDDPI VDDPI VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS WA[0] WA[1] WE
*+  WEM[0] WEM[1] WEM[2] WEM[3] WEM[4] WEM[5] WEM[6] WEM[7] WPULSE[0] WPULSE[1]
*+  WPULSE[2] XADR[0] XADR[1] XADR[2] XADR[3] XADR[4] XADR[5] XADR[6] XADR[7]
*+  XBKADR[0] XBKADR[1] XBKADR[2] YADR[0] YADR[1] YADR[2] YADR[3]
*+  SNPS_SP_HD_16Kx8_pin_row
X_gio_row ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1]
+   BC0 BC1 BC2 CB[0] CB[1] CB[2] CB[3] CB[4] CB[5] CB[6] CB[7] CENDP CLK CLKB
+   CLKDEL CLKDEL CLKB CT[0] CT[1] CT[2] CT[3] CT[4] CT[5] CT[6] CT[7] D[0] D[1]
+   D[2] D[3] D[4] D[5] D[6] D[7] DEF1 DEF12B_PROG DEF12_PROG DEF1B DEF12_PROG
+   DEF12B_PROG DEF_MODE DEF1 LOG0 DIB[0] DIB[1] DIB[2] DIB[3] DIB[4] DIB[5]
+   DIB[6] DIB[7] DINB[0] DINB[1] DINB[2] DINB[3] DINB[4] DINB[5] DINB[6]
+   DINB[7] DISCHG LOG1 LOG1 LOG0 DINB[0] DINB[1] DINB[2] DINB[3] DINB[4]
+   DINB[5] DINB[6] DINB[7] FAST1_MODE FAST2_MODE FISO FLOAT FLOATT FLOAT_RET
+   LOG1 LOG1 LOG0 LOG0 IV_SEL[0] IV_SEL[1] IV_SEL[2] IV_SEL[3] IV_SEL[4]
+   IV_SEL[5] IV_SEL[6] IV_SEL[7] IV_SEL[8] IV_SEL[9] IV_SEL[10] IV_SEL[11]
+   IV_SEL[12] IV_SEL[13] IV_SEL[14] IV_SEL[15] IV_SEL[16] IV_SEL[17] IV_SEL[18]
+   IV_SEL[19] IV_SEL[20] IV_SEL[21] IV_SEL[22] IV_SEL[23] IV_SEL[24] IV_SEL[25]
+   IV_SEL[26] IV_SEL[27] IV_SEL[28] IV_SEL[29] IV_SEL[30] IV_SEL[31] IV_WB[0]
+   IV_WB[1] IV_WB[2] IV_WB[3] IV_WB[4] IV_WB[5] IV_WB[6] IV_WB[7] IV_WB[8]
+   IV_WB[9] IV_WB[10] IV_WB[11] IV_WB[12] IV_WB[13] IV_WB[14] IV_WB[15]
+   IV_WB[16] IV_WB[17] IV_WB[18] IV_WB[19] IV_WB[20] IV_WB[21] IV_WB[22]
+   IV_WB[23] IV_WB[24] IV_WB[25] IV_WB[26] IV_WB[27] IV_WB[28] IV_WB[29]
+   IV_WB[30] IV_WB[31] IV_WT[0] IV_WT[1] IV_WT[2] IV_WT[3] IV_WT[4] IV_WT[5]
+   IV_WT[6] IV_WT[7] IV_WT[8] IV_WT[9] IV_WT[10] IV_WT[11] IV_WT[12] IV_WT[13]
+   IV_WT[14] IV_WT[15] IV_WT[16] IV_WT[17] IV_WT[18] IV_WT[19] IV_WT[20]
+   IV_WT[21] IV_WT[22] IV_WT[23] IV_WT[24] IV_WT[25] IV_WT[26] IV_WT[27]
+   IV_WT[28] IV_WT[29] IV_WT[30] IV_WT[31] LBKADR0 LBKADR1 LBKADR2[0] LCLKB
+   LCLKT LDFTX LOG0 LOG0 LDIB[0] LDIB[1] LDIB[2] LDIB[3] LDIB[4] LDIB[5]
+   LDIB[6] LDIB[7] LITESLP LME LOG0 LOG1 LOG1_RM LQB[0] LQB[1] LQB[2] LQB[3]
+   LQB[4] LQB[5] LQB[6] LQB[7] LS LWE LWEIB LWIB[0] LWIB[1] LWIB[2] LWIB[3]
+   LWIB[4] LWIB[5] LWIB[6] LWIB[7] LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+   LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] LY_ONE LY_TWO MCLKB MCLKT ME
+   MEB_I MEB_I MEORDFTCLKEN LOG1 IV_SEL[0] IV_SEL[1] IV_SEL[2] IV_SEL[3]
+   IV_SEL[4] IV_SEL[5] IV_SEL[6] IV_SEL[7] IV_SEL[8] IV_SEL[9] IV_SEL[10]
+   IV_SEL[11] IV_SEL[12] IV_SEL[13] IV_SEL[14] IV_SEL[15] IV_SEL[16] IV_SEL[17]
+   IV_SEL[18] IV_SEL[19] IV_SEL[20] IV_SEL[21] IV_SEL[22] IV_SEL[23] IV_SEL[24]
+   IV_SEL[25] IV_SEL[26] IV_SEL[27] IV_SEL[28] IV_SEL[29] IV_SEL[30] IV_SEL[31]
+   IV_WB[0] IV_WB[1] IV_WB[2] IV_WB[3] IV_WB[4] IV_WB[5] IV_WB[6] IV_WB[7]
+   IV_WB[8] IV_WB[9] IV_WB[10] IV_WB[11] IV_WB[12] IV_WB[13] IV_WB[14]
+   IV_WB[15] IV_WB[16] IV_WB[17] IV_WB[18] IV_WB[19] IV_WB[20] IV_WB[21]
+   IV_WB[22] IV_WB[23] IV_WB[24] IV_WB[25] IV_WB[26] IV_WB[27] IV_WB[28]
+   IV_WB[29] IV_WB[30] IV_WB[31] IV_WT[0] IV_WT[1] IV_WT[2] IV_WT[3] IV_WT[4]
+   IV_WT[5] IV_WT[6] IV_WT[7] IV_WT[8] IV_WT[9] IV_WT[10] IV_WT[11] IV_WT[12]
+   IV_WT[13] IV_WT[14] IV_WT[15] IV_WT[16] IV_WT[17] IV_WT[18] IV_WT[19]
+   IV_WT[20] IV_WT[21] IV_WT[22] IV_WT[23] IV_WT[24] IV_WT[25] IV_WT[26]
+   IV_WT[27] IV_WT[28] IV_WT[29] IV_WT[30] IV_WT[31] PWDO[0] PWDO[1] Q[0] Q[1]
+   Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6]
+   QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QB[16] QB[17]
+   QB[18] QB[19] QB[20] QB[21] QB[22] QB[23] QB[24] QB[25] QB[26] QB[27] QB[28]
+   QB[29] QB[30] QB[31] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8]
+   QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17] QT[18] QT[19]
+   QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28] QT[29] QT[30]
+   QT[31] RA[0] RA[1] RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RM[0] RM[1]
+   RM[2] RM[3] RM3CNT VBA VBA LOG1_RM LOG1_RM VBA LOG1_RM LOG1_RM LOG1_RM RME
+   LOG1 LOG1 LOG0 LOG1_RM LOG1_RM LOG1_RM LOG1_RM RMT[0] RMT[1] RMT[2] RMT[3]
+   LOG0 LOG0 LOG0 LOG0 LOG0 RWLCKB SD SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5]
+   SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15]
+   SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21] SEL[22] SEL[23] SEL[24]
+   SEL[25] SEL[26] SEL[27] SEL[28] SEL[29] SEL[30] SEL[31] LOG0 T1T TEST1
+   TEST_RNM TEST_RNMB VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VDDA VDDA VDDA VDDMINB VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI_DR VDDPI_DR VDDPI_DR VDDPI_DR VDDPI_DR
+   VDDPI_DR VDDPI_DR VDDPI_DR VEDGE[0] VEDGE[1] VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS WA[0] WA[1] WABUF[0] WABUF[1] WABUF[2] WB_IN[0] WB_IN[1]
+   WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9]
+   WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WB_IN[16]
+   WB_IN[17] WB_IN[18] WB_IN[19] WB_IN[20] WB_IN[21] WB_IN[22] WB_IN[23]
+   WB_IN[24] WB_IN[25] WB_IN[26] WB_IN[27] WB_IN[28] WB_IN[29] WB_IN[30]
+   WB_IN[31] WE WEM[0] WEM[1] WEM[2] WEM[3] WEM[4] WEM[5] WEM[6] WEM[7] WEMB[0]
+   WEMB[1] WEMB[2] WEMB[3] WEMB[4] WEMB[5] WEMB[6] WEMB[7] WEMB[0] WEMB[1]
+   WEMB[2] WEMB[3] WEMB[4] WEMB[5] WEMB[6] WEMB[7] WFLOAT LOG1_RM LOG1_RM
+   LOG1_RM VBA VBA LOG1_RM VBA LOG1_RM LOG1_RM VBA LOG1_RM LOG1_RM WMT[0]
+   WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WPULSE[0] WPULSE[1]
+   WPULSE[2] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6]
+   WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14]
+   WT_IN[15] WT_IN[16] WT_IN[17] WT_IN[18] WT_IN[19] WT_IN[20] WT_IN[21]
+   WT_IN[22] WT_IN[23] WT_IN[24] WT_IN[25] WT_IN[26] WT_IN[27] WT_IN[28]
+   WT_IN[29] WT_IN[30] WT_IN[31] XADR[0] XADR[1] XADR[2] XADR[3] XADR[4]
+   XADR[5] XADR[6] XADR[7] XBKADR[0] XBKADR[1] XBKADR[2] YADR[0] YADR[1]
+   YADR[2] YADR[3] SNPS_SP_HD_16Kx8_gio_row
X_ref_row_mx_2 ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1] ARYSD[0]
+   ARYSD[1] ARYSD[2] ARYSD[3] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7]
+   BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18]
+   BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29]
+   BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40]
+   BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51]
+   BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62]
+   BB[63] BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73]
+   BB[74] BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83] BB[84]
+   BB[85] BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95]
+   BB[96] BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103] BB[104] BB[105]
+   BB[106] BB[107] BB[108] BB[109] BB[110] BB[111] BB[112] BB[113] BB[114]
+   BB[115] BB[116] BB[117] BB[118] BB[119] BB[120] BB[121] BB[122] BB[123]
+   BB[124] BB[125] BB[126] BB[127] CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT
+   FLOATT FLOAT_RET LBKADR0 LBKADR1 LCGTH[0] LCGTH[1] LDFTX LITESLP LLBKADRB[0]
+   LLBKADRB[1] LMATCHB LMATCHB_I[0] LOG0 LOG0 LOG1 LOG1 LWEIB LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PWDO[0] PWDO[1] PLBKADR[0] PLBKADR[1] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5]
+   QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QB[16]
+   QB[17] QB[18] QB[19] QB[20] QB[21] QB[22] QB[23] QB[24] QB[25] QB[26] QB[27]
+   QB[28] QB[29] QB[30] QB[31] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+   QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17] QT[18]
+   QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28] QT[29]
+   QT[30] QT[31] RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RASSISTB[0]
+   RASSISTB[1] RASSISTB[2] RASSISTB[3] RBLRD[0] RBLWA[0] RBLWR[0] RM3CNT RMT[0]
+   RMT[1] RMT[2] RMT[3] RWLB_SAC[0] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5]
+   SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15]
+   SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21] SEL[22] SEL[23] SEL[24]
+   SEL[25] SEL[26] SEL[27] SEL[28] SEL[29] SEL[30] SEL[31] T1T TEST_RNMB
+   TOPEDGE[0] TOPEDGE[1] TOPEDGE[2] TOPEDGE[3] VBA VBA VBA VBA VBA VBA VBA VBA
+   VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA
+   VBA VBA VBA VBA VBA VBA VBA VBA VBA VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VDDA VDDA VDDA VDDAIL1[0] VDDAIR1[0] VDDMINB
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDWL[0] VDDWL[1] VEDGE[0] VEDGE[1] VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS WABUF[0]
+   WABUF[1] WABUF[2] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5]
+   WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13]
+   WB_IN[14] WB_IN[15] WB_IN[16] WB_IN[17] WB_IN[18] WB_IN[19] WB_IN[20]
+   WB_IN[21] WB_IN[22] WB_IN[23] WB_IN[24] WB_IN[25] WB_IN[26] WB_IN[27]
+   WB_IN[28] WB_IN[29] WB_IN[30] WB_IN[31] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0]
+   WPBUF[1] WPBUF[2] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5]
+   WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13]
+   WT_IN[14] WT_IN[15] WT_IN[16] WT_IN[17] WT_IN[18] WT_IN[19] WT_IN[20]
+   WT_IN[21] WT_IN[22] WT_IN[23] WT_IN[24] WT_IN[25] WT_IN[26] WT_IN[27]
+   WT_IN[28] WT_IN[29] WT_IN[30] WT_IN[31] SNPS_SP_HD_16Kx8_ref_row_mx_2
X_ary_row_mx_2_S0 ARYSD[2] ARYSD[3] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+   ARYSD_BC2[1] B[0] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8]
+   BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19]
+   BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30]
+   BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41]
+   BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52]
+   BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63]
+   BB[64] BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73] BB[74]
+   BB[75] BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83] BB[84] BB[85]
+   BB[86] BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95] BB[96]
+   BB[97] BB[98] BB[99] BB[100] BB[101] BB[102] BB[103] BB[104] BB[105] BB[106]
+   BB[107] BB[108] BB[109] BB[110] BB[111] BB[112] BB[113] BB[114] BB[115]
+   BB[116] BB[117] BB[118] BB[119] BB[120] BB[121] BB[122] BB[123] BB[124]
+   BB[125] BB[126] BB[127] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7]
+   BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16] BT[17] BT[18]
+   BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28] BT[29]
+   BT[30] BT[31] BT[32] BT[33] BT[34] BT[35] BT[36] BT[37] BT[38] BT[39] BT[40]
+   BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51]
+   BT[52] BT[53] BT[54] BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62]
+   BT[63] BT[64] BT[65] BT[66] BT[67] BT[68] BT[69] BT[70] BT[71] BT[72] BT[73]
+   BT[74] BT[75] BT[76] BT[77] BT[78] BT[79] BT[80] BT[81] BT[82] BT[83] BT[84]
+   BT[85] BT[86] BT[87] BT[88] BT[89] BT[90] BT[91] BT[92] BT[93] BT[94] BT[95]
+   BT[96] BT[97] BT[98] BT[99] BT[100] BT[101] BT[102] BT[103] BT[104] BT[105]
+   BT[106] BT[107] BT[108] BT[109] BT[110] BT[111] BT[112] BT[113] BT[114]
+   BT[115] BT[116] BT[117] BT[118] BT[119] BT[120] BT[121] BT[122] BT[123]
+   BT[124] BT[125] BT[126] BT[127] BYP_VLOAD[0] C[0] CENDP DEF_MODE EDGEB[0]
+   EDGEB[1] EDGEB[2] EDGEB[3] EDGET[0] EDGET[1] EDGET[2] EDGET[3] FAST1_MODE
+   FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR0 LBKADR1 LCGTH[0] LCGTH[1] LDFTX
+   LITESLP LMATCH[0] LMATCHB LOG0 LOG1 LWEIB LXADR[0] LXADR[1] LXADR[2]
+   LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] B[0] PBB[1]
+   PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] C[0] PCB[1] PCB[2] PCB[3] PCB[4]
+   PCB[5] PCB[6] PCB[7] PWDO[0] PWDO[1] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5]
+   QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QB[16]
+   QB[17] QB[18] QB[19] QB[20] QB[21] QB[22] QB[23] QB[24] QB[25] QB[26] QB[27]
+   QB[28] QB[29] QB[30] QB[31] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+   QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17] QT[18]
+   QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28] QT[29]
+   QT[30] QT[31] RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RASSISTBH[0]
+   RASSISTBH[1] RASSISTBL[0] RASSISTBL[1] RBLRD[0] RBLWA[0] RBLWR[0]
+   RBLWR_LOAD[0] RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC[0] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] SEL[16] SEL[17] SEL[18] SEL[19] SEL[20]
+   SEL[21] SEL[22] SEL[23] SEL[24] SEL[25] SEL[26] SEL[27] SEL[28] SEL[29]
+   SEL[30] SEL[31] T1T TEST_RNMB VBA VBN VBP VDDA VDDAIL1[0] VDDAIR1[0] VDDMINB
+   VDDP VDDPI VDDWL[0] VDDWL[1] VEDGE[0] VEDGE[1] VSS VSSC_WL_L[0] VSSC_WL_R[0]
+   WABUF[0] WABUF[1] WABUF[2] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4]
+   WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12]
+   WB_IN[13] WB_IN[14] WB_IN[15] WB_IN[16] WB_IN[17] WB_IN[18] WB_IN[19]
+   WB_IN[20] WB_IN[21] WB_IN[22] WB_IN[23] WB_IN[24] WB_IN[25] WB_IN[26]
+   WB_IN[27] WB_IN[28] WB_IN[29] WB_IN[30] WB_IN[31] WCLKB[0] WCLKB[1] WCLKB[2]
+   WCLKB[3] WLH[0] WLH[1] WLH[2] WLH[3] WLH[4] WLH[5] WLH[6] WLH[7] WLH[8]
+   WLH[9] WLH[10] WLH[11] WLH[12] WLH[13] WLH[14] WLH[15] WLH[16] WLH[17]
+   WLH[18] WLH[19] WLH[20] WLH[21] WLH[22] WLH[23] WLH[24] WLH[25] WLH[26]
+   WLH[27] WLH[28] WLH[29] WLH[30] WLH[31] WLH[32] WLH[33] WLH[34] WLH[35]
+   WLH[36] WLH[37] WLH[38] WLH[39] WLH[40] WLH[41] WLH[42] WLH[43] WLH[44]
+   WLH[45] WLH[46] WLH[47] WLH[48] WLH[49] WLH[50] WLH[51] WLH[52] WLH[53]
+   WLH[54] WLH[55] WLH[56] WLH[57] WLH[58] WLH[59] WLH[60] WLH[61] WLH[62]
+   WLH[63] WLH[64] WLH[65] WLH[66] WLH[67] WLH[68] WLH[69] WLH[70] WLH[71]
+   WLH[72] WLH[73] WLH[74] WLH[75] WLH[76] WLH[77] WLH[78] WLH[79] WLH[80]
+   WLH[81] WLH[82] WLH[83] WLH[84] WLH[85] WLH[86] WLH[87] WLH[88] WLH[89]
+   WLH[90] WLH[91] WLH[92] WLH[93] WLH[94] WLH[95] WLH[96] WLH[97] WLH[98]
+   WLH[99] WLH[100] WLH[101] WLH[102] WLH[103] WLH[104] WLH[105] WLH[106]
+   WLH[107] WLH[108] WLH[109] WLH[110] WLH[111] WLH[112] WLH[113] WLH[114]
+   WLH[115] WLH[116] WLH[117] WLH[118] WLH[119] WLH[120] WLH[121] WLH[122]
+   WLH[123] WLH[124] WLH[125] WLH[126] WLH[127] WLH[128] WLH[129] WLH[130]
+   WLH[131] WLH[132] WLH[133] WLH[134] WLH[135] WLH[136] WLH[137] WLH[138]
+   WLH[139] WLH[140] WLH[141] WLH[142] WLH[143] WLH[144] WLH[145] WLH[146]
+   WLH[147] WLH[148] WLH[149] WLH[150] WLH[151] WLH[152] WLH[153] WLH[154]
+   WLH[155] WLH[156] WLH[157] WLH[158] WLH[159] WLH[160] WLH[161] WLH[162]
+   WLH[163] WLH[164] WLH[165] WLH[166] WLH[167] WLH[168] WLH[169] WLH[170]
+   WLH[171] WLH[172] WLH[173] WLH[174] WLH[175] WLH[176] WLH[177] WLH[178]
+   WLH[179] WLH[180] WLH[181] WLH[182] WLH[183] WLH[184] WLH[185] WLH[186]
+   WLH[187] WLH[188] WLH[189] WLH[190] WLH[191] WLH[192] WLH[193] WLH[194]
+   WLH[195] WLH[196] WLH[197] WLH[198] WLH[199] WLH[200] WLH[201] WLH[202]
+   WLH[203] WLH[204] WLH[205] WLH[206] WLH[207] WLH[208] WLH[209] WLH[210]
+   WLH[211] WLH[212] WLH[213] WLH[214] WLH[215] WLH[216] WLH[217] WLH[218]
+   WLH[219] WLH[220] WLH[221] WLH[222] WLH[223] WLH[224] WLH[225] WLH[226]
+   WLH[227] WLH[228] WLH[229] WLH[230] WLH[231] WLH[232] WLH[233] WLH[234]
+   WLH[235] WLH[236] WLH[237] WLH[238] WLH[239] WLH[240] WLH[241] WLH[242]
+   WLH[243] WLH[244] WLH[245] WLH[246] WLH[247] WLH[248] WLH[249] WLH[250]
+   WLH[251] WLH[252] WLH[253] WLH[254] WLH[255] WLL[0] WLL[1] WLL[2] WLL[3]
+   WLL[4] WLL[5] WLL[6] WLL[7] WLL[8] WLL[9] WLL[10] WLL[11] WLL[12] WLL[13]
+   WLL[14] WLL[15] WLL[16] WLL[17] WLL[18] WLL[19] WLL[20] WLL[21] WLL[22]
+   WLL[23] WLL[24] WLL[25] WLL[26] WLL[27] WLL[28] WLL[29] WLL[30] WLL[31]
+   WLL[32] WLL[33] WLL[34] WLL[35] WLL[36] WLL[37] WLL[38] WLL[39] WLL[40]
+   WLL[41] WLL[42] WLL[43] WLL[44] WLL[45] WLL[46] WLL[47] WLL[48] WLL[49]
+   WLL[50] WLL[51] WLL[52] WLL[53] WLL[54] WLL[55] WLL[56] WLL[57] WLL[58]
+   WLL[59] WLL[60] WLL[61] WLL[62] WLL[63] WLL[64] WLL[65] WLL[66] WLL[67]
+   WLL[68] WLL[69] WLL[70] WLL[71] WLL[72] WLL[73] WLL[74] WLL[75] WLL[76]
+   WLL[77] WLL[78] WLL[79] WLL[80] WLL[81] WLL[82] WLL[83] WLL[84] WLL[85]
+   WLL[86] WLL[87] WLL[88] WLL[89] WLL[90] WLL[91] WLL[92] WLL[93] WLL[94]
+   WLL[95] WLL[96] WLL[97] WLL[98] WLL[99] WLL[100] WLL[101] WLL[102] WLL[103]
+   WLL[104] WLL[105] WLL[106] WLL[107] WLL[108] WLL[109] WLL[110] WLL[111]
+   WLL[112] WLL[113] WLL[114] WLL[115] WLL[116] WLL[117] WLL[118] WLL[119]
+   WLL[120] WLL[121] WLL[122] WLL[123] WLL[124] WLL[125] WLL[126] WLL[127]
+   WLL[128] WLL[129] WLL[130] WLL[131] WLL[132] WLL[133] WLL[134] WLL[135]
+   WLL[136] WLL[137] WLL[138] WLL[139] WLL[140] WLL[141] WLL[142] WLL[143]
+   WLL[144] WLL[145] WLL[146] WLL[147] WLL[148] WLL[149] WLL[150] WLL[151]
+   WLL[152] WLL[153] WLL[154] WLL[155] WLL[156] WLL[157] WLL[158] WLL[159]
+   WLL[160] WLL[161] WLL[162] WLL[163] WLL[164] WLL[165] WLL[166] WLL[167]
+   WLL[168] WLL[169] WLL[170] WLL[171] WLL[172] WLL[173] WLL[174] WLL[175]
+   WLL[176] WLL[177] WLL[178] WLL[179] WLL[180] WLL[181] WLL[182] WLL[183]
+   WLL[184] WLL[185] WLL[186] WLL[187] WLL[188] WLL[189] WLL[190] WLL[191]
+   WLL[192] WLL[193] WLL[194] WLL[195] WLL[196] WLL[197] WLL[198] WLL[199]
+   WLL[200] WLL[201] WLL[202] WLL[203] WLL[204] WLL[205] WLL[206] WLL[207]
+   WLL[208] WLL[209] WLL[210] WLL[211] WLL[212] WLL[213] WLL[214] WLL[215]
+   WLL[216] WLL[217] WLL[218] WLL[219] WLL[220] WLL[221] WLL[222] WLL[223]
+   WLL[224] WLL[225] WLL[226] WLL[227] WLL[228] WLL[229] WLL[230] WLL[231]
+   WLL[232] WLL[233] WLL[234] WLL[235] WLL[236] WLL[237] WLL[238] WLL[239]
+   WLL[240] WLL[241] WLL[242] WLL[243] WLL[244] WLL[245] WLL[246] WLL[247]
+   WLL[248] WLL[249] WLL[250] WLL[251] WLL[252] WLL[253] WLL[254] WLL[255]
+   WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT_IN[0] WT_IN[1]
+   WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9]
+   WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15] WT_IN[16]
+   WT_IN[17] WT_IN[18] WT_IN[19] WT_IN[20] WT_IN[21] WT_IN[22] WT_IN[23]
+   WT_IN[24] WT_IN[25] WT_IN[26] WT_IN[27] WT_IN[28] WT_IN[29] WT_IN[30]
+   WT_IN[31] SNPS_SP_HD_16Kx8_ary_row_mx_2
X_mux_row_b_mx_S0 ARYSD[2] ARYSD[3] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+   ARYSD_BC2[1] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9]
+   BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20]
+   BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31]
+   BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42]
+   BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53]
+   BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BB[64]
+   BB[65] BB[66] BB[67] BB[68] BB[69] BB[70] BB[71] BB[72] BB[73] BB[74] BB[75]
+   BB[76] BB[77] BB[78] BB[79] BB[80] BB[81] BB[82] BB[83] BB[84] BB[85] BB[86]
+   BB[87] BB[88] BB[89] BB[90] BB[91] BB[92] BB[93] BB[94] BB[95] BB[96] BB[97]
+   BB[98] BB[99] BB[100] BB[101] BB[102] BB[103] BB[104] BB[105] BB[106]
+   BB[107] BB[108] BB[109] BB[110] BB[111] BB[112] BB[113] BB[114] BB[115]
+   BB[116] BB[117] BB[118] BB[119] BB[120] BB[121] BB[122] BB[123] BB[124]
+   BB[125] BB[126] BB[127] BOTEDGE[0] BOTEDGE[1] BOTEDGE[2] BOTEDGE[3] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34]
+   BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45]
+   BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56]
+   BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BT[64] BT[65] BT[66] BT[67]
+   BT[68] BT[69] BT[70] BT[71] BT[72] BT[73] BT[74] BT[75] BT[76] BT[77] BT[78]
+   BT[79] BT[80] BT[81] BT[82] BT[83] BT[84] BT[85] BT[86] BT[87] BT[88] BT[89]
+   BT[90] BT[91] BT[92] BT[93] BT[94] BT[95] BT[96] BT[97] BT[98] BT[99]
+   BT[100] BT[101] BT[102] BT[103] BT[104] BT[105] BT[106] BT[107] BT[108]
+   BT[109] BT[110] BT[111] BT[112] BT[113] BT[114] BT[115] BT[116] BT[117]
+   BT[118] BT[119] BT[120] BT[121] BT[122] BT[123] BT[124] BT[125] BT[126]
+   BT[127] BYP_VLOAD[0] CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT
+   FLOAT_RET LBKADR0 LBKADR1 LCGTH[0] LCGTH[1] LCGTH_PCHG[0] LDFTX LITESLP
+   LMATCH[0] LMATCHB LOG0 LOG1 LWEIB LWERD[0] LWEWR[0] LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] B[0]
+   PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] C[0] PCB[1] PCB[2] PCB[3]
+   PCB[4] PCB[5] PCB[6] PCB[7] PM[0] PM[1] PM[2] PM[3] PRCKE_B[0] PWDO[0]
+   PWDO[1] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QB[16] QB[17] QB[18] QB[19] QB[20] QB[21]
+   QB[22] QB[23] QB[24] QB[25] QB[26] QB[27] QB[28] QB[29] QB[30] QB[31] QT[0]
+   QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12]
+   QT[13] QT[14] QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23]
+   QT[24] QT[25] QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] RASSIST[0]
+   RASSIST[1] RASSIST[2] RASSIST[3] RASSISTBH[0] RASSISTBH[1] RASSISTBL[0]
+   RASSISTBL[1] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9]
+   RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RB[16] RB[17] RB[18] RB[19] RB[20]
+   RB[21] RB[22] RB[23] RB[24] RB[25] RB[26] RB[27] RB[28] RB[29] RB[30] RB[31]
+   RBLRD[0] RBLWA[1] RBLWR[0] RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RT[0] RT[1]
+   RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13]
+   RT[14] RT[15] RT[16] RT[17] RT[18] RT[19] RT[20] RT[21] RT[22] RT[23] RT[24]
+   RT[25] RT[26] RT[27] RT[28] RT[29] RT[30] RT[31] RWLB_SAC[0] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] SEL[16] SEL[17] SEL[18] SEL[19] SEL[20]
+   SEL[21] SEL[22] SEL[23] SEL[24] SEL[25] SEL[26] SEL[27] SEL[28] SEL[29]
+   SEL[30] SEL[31] T1T TEST_RNMB VBA VBN VBP VDDA VDDAIL1[0] VDDAIR1[0] VDDMINB
+   VDDP VDDPI VDDWL[0] VDDWL[1] VEDGE[0] VEDGE[1] VSS VSSC_WL_L[0] VSSC_WL_R[0]
+   WABUF[0] WABUF[1] WABUF[2] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7]
+   WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WB[16] WB[17] WB[18]
+   WB[19] WB[20] WB[21] WB[22] WB[23] WB[24] WB[25] WB[26] WB[27] WB[28] WB[29]
+   WB[30] WB[31] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6]
+   WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14]
+   WB_IN[15] WB_IN[16] WB_IN[17] WB_IN[18] WB_IN[19] WB_IN[20] WB_IN[21]
+   WB_IN[22] WB_IN[23] WB_IN[24] WB_IN[25] WB_IN[26] WB_IN[27] WB_IN[28]
+   WB_IN[29] WB_IN[30] WB_IN[31] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] WMT[0]
+   WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT[0] WT[1] WT[2] WT[3]
+   WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14]
+   WT[15] WT[16] WT[17] WT[18] WT[19] WT[20] WT[21] WT[22] WT[23] WT[24] WT[25]
+   WT[26] WT[27] WT[28] WT[29] WT[30] WT[31] WT_IN[0] WT_IN[1] WT_IN[2]
+   WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10]
+   WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15] WT_IN[16] WT_IN[17]
+   WT_IN[18] WT_IN[19] WT_IN[20] WT_IN[21] WT_IN[22] WT_IN[23] WT_IN[24]
+   WT_IN[25] WT_IN[26] WT_IN[27] WT_IN[28] WT_IN[29] WT_IN[30] WT_IN[31]
+   SNPS_SP_HD_16Kx8_mux_row_b_mx
X_sacwa_row_S0 ARYSD[2] ARYSD[3] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+   ARYSD_BC2[1] CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET
+   LBKADR0 LBKADR1 LBKADR2[1] LCGTH[0] LCGTH[1] LCGTH_PCHG[0] LDFTX LITESLP
+   LMATCHB LOG0 LOG0 LOG0 LOG1 LOG1 LOG1 LWEIB LWERD[0] LWEWR[0] LXADR[0]
+   LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+   LYADR[1] PM[0] PM[1] PM[2] PM[3] PRCKE_B[0] PWDO[0] PWDO[1] QB[0] QB[1]
+   QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13]
+   QB[14] QB[15] QB[16] QB[17] QB[18] QB[19] QB[20] QB[21] QB[22] QB[23] QB[24]
+   QB[25] QB[26] QB[27] QB[28] QB[29] QB[30] QB[31] QT[0] QT[1] QT[2] QT[3]
+   QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] RASSIST[0] RASSIST[1] RASSIST[2]
+   RASSIST[3] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9]
+   RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RB[16] RB[17] RB[18] RB[19] RB[20]
+   RB[21] RB[22] RB[23] RB[24] RB[25] RB[26] RB[27] RB[28] RB[29] RB[30] RB[31]
+   RBLWA[2] RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RT[0] RT[1] RT[2] RT[3] RT[4]
+   RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15]
+   RT[16] RT[17] RT[18] RT[19] RT[20] RT[21] RT[22] RT[23] RT[24] RT[25] RT[26]
+   RT[27] RT[28] RT[29] RT[30] RT[31] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5]
+   SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15]
+   SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21] SEL[22] SEL[23] SEL[24]
+   SEL[25] SEL[26] SEL[27] SEL[28] SEL[29] SEL[30] SEL[31] T1T TEST_RNMB VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VDDA VDDA
+   VDDA VDDMINB VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VEDGE[0] VEDGE[1] VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6]
+   VSS_WA[7] VSS_WA[8] VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12] VSS_WA[13]
+   VSS_WA[14] VSS_WA[15] VSS_WA[16] VSS_WA[17] VSS_WA[18] VSS_WA[19] VSS_WA[20]
+   VSS_WA[21] VSS_WA[22] VSS_WA[23] VSS_WA[24] VSS_WA[25] VSS_WA[26] VSS_WA[27]
+   VSS_WA[28] VSS_WA[29] VSS_WA[30] VSS_WA[31] WABUF[0] WABUF[1] WABUF[2]
+   WAPRCLKBUFB_RET[0] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8]
+   WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WB[16] WB[17] WB[18] WB[19]
+   WB[20] WB[21] WB[22] WB[23] WB[24] WB[25] WB[26] WB[27] WB[28] WB[29] WB[30]
+   WB[31] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6]
+   WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14]
+   WB_IN[15] WB_IN[16] WB_IN[17] WB_IN[18] WB_IN[19] WB_IN[20] WB_IN[21]
+   WB_IN[22] WB_IN[23] WB_IN[24] WB_IN[25] WB_IN[26] WB_IN[27] WB_IN[28]
+   WB_IN[29] WB_IN[30] WB_IN[31] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10]
+   WT[11] WT[12] WT[13] WT[14] WT[15] WT[16] WT[17] WT[18] WT[19] WT[20] WT[21]
+   WT[22] WT[23] WT[24] WT[25] WT[26] WT[27] WT[28] WT[29] WT[30] WT[31]
+   WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7]
+   WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14]
+   WT_IN[15] WT_IN[16] WT_IN[17] WT_IN[18] WT_IN[19] WT_IN[20] WT_IN[21]
+   WT_IN[22] WT_IN[23] WT_IN[24] WT_IN[25] WT_IN[26] WT_IN[27] WT_IN[28]
+   WT_IN[29] WT_IN[30] WT_IN[31] SNPS_SP_HD_16Kx8_sacwa_row
X_sac_row_2 ARYSD[2] ARYSD[3] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+   ARYSD_BC2[1] BYP_VLOAD[1] CENDP DEF_MODE LOG0 FAST1B[0] FAST1_MODE
+   FAST2_MODE FLOAT FLOATT LOG1 FLOAT_RET FLOAT_RET LBKADR0 LBKADR1 LCGTH[0]
+   LCGTH[1] LCGTH_PCHG[0] LDFTX LITESLP LLBKADRB[2] LLBKADRB[3] LLBKADRB[4]
+   LLBKADRT[0] LLBKADRT[1] LLBKADRT[2] LMATCH[1] LMATCHB LOG1 LOG1 LOG0 LOG1
+   LWEIB LWERD[0] LWEWR[0] LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+   LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] LBKADR0 LLBKADRB[3] LLBKADRB[4]
+   LLBKADRB[2] PM[0] PM[1] PM[2] PM[3] PRCKE_B[0] PRCKE_T[0] PRCLKB[0] PWDO[0]
+   PWDO[1] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QB[16] QB[17] QB[18] QB[19] QB[20] QB[21]
+   QB[22] QB[23] QB[24] QB[25] QB[26] QB[27] QB[28] QB[29] QB[30] QB[31] QB[32]
+   QB[33] QB[34] QB[35] QB[36] QB[37] QB[38] QB[39] QB[40] QB[41] QB[42] QB[43]
+   QB[44] QB[45] QB[46] QB[47] QB[48] QB[49] QB[50] QB[51] QB[52] QB[53] QB[54]
+   QB[55] QB[56] QB[57] QB[58] QB[59] QB[60] QB[61] QB[62] QB[63] QB[32] QB[33]
+   QB[34] QB[35] QB[36] QB[37] QB[38] QB[39] QB[40] QB[41] QB[42] QB[43] QB[44]
+   QB[45] QB[46] QB[47] QB[48] QB[49] QB[50] QB[51] QB[52] QB[53] QB[54] QB[55]
+   QB[56] QB[57] QB[58] QB[59] QB[60] QB[61] QB[62] QB[63] QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37]
+   QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48]
+   QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59]
+   QT[60] QT[61] QT[62] QT[63] RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3]
+   RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10] RB[11]
+   RB[12] RB[13] RB[14] RB[15] RB[16] RB[17] RB[18] RB[19] RB[20] RB[21] RB[22]
+   RB[23] RB[24] RB[25] RB[26] RB[27] RB[28] RB[29] RB[30] RB[31] RBLRD[1]
+   RBLWA[2] RBLWR[1] RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RT[0] RT[1] RT[2] RT[3]
+   RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14]
+   RT[15] RT[16] RT[17] RT[18] RT[19] RT[20] RT[21] RT[22] RT[23] RT[24] RT[25]
+   RT[26] RT[27] RT[28] RT[29] RT[30] RT[31] RWLB_SAC[1] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+   SEL[13] SEL[14] SEL[15] SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21]
+   SEL[22] SEL[23] SEL[24] SEL[25] SEL[26] SEL[27] SEL[28] SEL[29] SEL[30]
+   SEL[31] T1T TEST_RNMB VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VDDA VDDA VDDA VDDMINB VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VEDGE[0] VEDGE[1] VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4]
+   VSS_WA[5] VSS_WA[6] VSS_WA[7] VSS_WA[8] VSS_WA[9] VSS_WA[10] VSS_WA[11]
+   VSS_WA[12] VSS_WA[13] VSS_WA[14] VSS_WA[15] VSS_WA[16] VSS_WA[17] VSS_WA[18]
+   VSS_WA[19] VSS_WA[20] VSS_WA[21] VSS_WA[22] VSS_WA[23] VSS_WA[24] VSS_WA[25]
+   VSS_WA[26] VSS_WA[27] VSS_WA[28] VSS_WA[29] VSS_WA[30] VSS_WA[31] WABUF[0]
+   WABUF[1] WABUF[2] WAPRCLKBUFB_RET[0] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5]
+   WB[6] WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WB[16]
+   WB[17] WB[18] WB[19] WB[20] WB[21] WB[22] WB[23] WB[24] WB[25] WB[26] WB[27]
+   WB[28] WB[29] WB[30] WB[31] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4]
+   WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12]
+   WB_IN[13] WB_IN[14] WB_IN[15] WB_IN[16] WB_IN[17] WB_IN[18] WB_IN[19]
+   WB_IN[20] WB_IN[21] WB_IN[22] WB_IN[23] WB_IN[24] WB_IN[25] WB_IN[26]
+   WB_IN[27] WB_IN[28] WB_IN[29] WB_IN[30] WB_IN[31] WMT[0] WMT[1] WMT[2]
+   WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6]
+   WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WT[16] WT[17]
+   WT[18] WT[19] WT[20] WT[21] WT[22] WT[23] WT[24] WT[25] WT[26] WT[27] WT[28]
+   WT[29] WT[30] WT[31] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5]
+   WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13]
+   WT_IN[14] WT_IN[15] WT_IN[16] WT_IN[17] WT_IN[18] WT_IN[19] WT_IN[20]
+   WT_IN[21] WT_IN[22] WT_IN[23] WT_IN[24] WT_IN[25] WT_IN[26] WT_IN[27]
+   WT_IN[28] WT_IN[29] WT_IN[30] WT_IN[31] SNPS_SP_HD_16Kx8_sac_row_2
X_mux_row_2 ARYSD[2] ARYSD[3] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+   ARYSD_BC2[1] BB[128] BB[129] BB[130] BB[131] BB[132] BB[133] BB[134] BB[135]
+   BB[136] BB[137] BB[138] BB[139] BB[140] BB[141] BB[142] BB[143] BB[144]
+   BB[145] BB[146] BB[147] BB[148] BB[149] BB[150] BB[151] BB[152] BB[153]
+   BB[154] BB[155] BB[156] BB[157] BB[158] BB[159] BB[160] BB[161] BB[162]
+   BB[163] BB[164] BB[165] BB[166] BB[167] BB[168] BB[169] BB[170] BB[171]
+   BB[172] BB[173] BB[174] BB[175] BB[176] BB[177] BB[178] BB[179] BB[180]
+   BB[181] BB[182] BB[183] BB[184] BB[185] BB[186] BB[187] BB[188] BB[189]
+   BB[190] BB[191] BB[192] BB[193] BB[194] BB[195] BB[196] BB[197] BB[198]
+   BB[199] BB[200] BB[201] BB[202] BB[203] BB[204] BB[205] BB[206] BB[207]
+   BB[208] BB[209] BB[210] BB[211] BB[212] BB[213] BB[214] BB[215] BB[216]
+   BB[217] BB[218] BB[219] BB[220] BB[221] BB[222] BB[223] BB[224] BB[225]
+   BB[226] BB[227] BB[228] BB[229] BB[230] BB[231] BB[232] BB[233] BB[234]
+   BB[235] BB[236] BB[237] BB[238] BB[239] BB[240] BB[241] BB[242] BB[243]
+   BB[244] BB[245] BB[246] BB[247] BB[248] BB[249] BB[250] BB[251] BB[252]
+   BB[253] BB[254] BB[255] BOTEDGE[4] BOTEDGE[5] BOTEDGE[6] BOTEDGE[7] BT[128]
+   BT[129] BT[130] BT[131] BT[132] BT[133] BT[134] BT[135] BT[136] BT[137]
+   BT[138] BT[139] BT[140] BT[141] BT[142] BT[143] BT[144] BT[145] BT[146]
+   BT[147] BT[148] BT[149] BT[150] BT[151] BT[152] BT[153] BT[154] BT[155]
+   BT[156] BT[157] BT[158] BT[159] BT[160] BT[161] BT[162] BT[163] BT[164]
+   BT[165] BT[166] BT[167] BT[168] BT[169] BT[170] BT[171] BT[172] BT[173]
+   BT[174] BT[175] BT[176] BT[177] BT[178] BT[179] BT[180] BT[181] BT[182]
+   BT[183] BT[184] BT[185] BT[186] BT[187] BT[188] BT[189] BT[190] BT[191]
+   BT[192] BT[193] BT[194] BT[195] BT[196] BT[197] BT[198] BT[199] BT[200]
+   BT[201] BT[202] BT[203] BT[204] BT[205] BT[206] BT[207] BT[208] BT[209]
+   BT[210] BT[211] BT[212] BT[213] BT[214] BT[215] BT[216] BT[217] BT[218]
+   BT[219] BT[220] BT[221] BT[222] BT[223] BT[224] BT[225] BT[226] BT[227]
+   BT[228] BT[229] BT[230] BT[231] BT[232] BT[233] BT[234] BT[235] BT[236]
+   BT[237] BT[238] BT[239] BT[240] BT[241] BT[242] BT[243] BT[244] BT[245]
+   BT[246] BT[247] BT[248] BT[249] BT[250] BT[251] BT[252] BT[253] BT[254]
+   BT[255] BYP_VLOAD[1] CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT
+   FLOAT_RET LBKADR0 LBKADR1 LCGTH[0] LCGTH[1] LCGTH_PCHG[0] LDFTX LITESLP
+   LMATCH[2] LMATCHB LOG0 LOG1 LWEIB LWERD[0] LWEWR[0] LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] B[1]
+   PBB[9] PBB[10] PBB[11] PBB[12] PBB[13] PBB[14] PBB[15] C[1] PCB[9] PCB[10]
+   PCB[11] PCB[12] PCB[13] PCB[14] PCB[15] PWDO[0] PWDO[1] PM[0] PM[1] PM[2]
+   PM[3] PRCKE_T[0] QB[32] QB[33] QB[34] QB[35] QB[36] QB[37] QB[38] QB[39]
+   QB[40] QB[41] QB[42] QB[43] QB[44] QB[45] QB[46] QB[47] QB[48] QB[49] QB[50]
+   QB[51] QB[52] QB[53] QB[54] QB[55] QB[56] QB[57] QB[58] QB[59] QB[60] QB[61]
+   QB[62] QB[63] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38] QT[39] QT[40]
+   QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49] QT[50] QT[51]
+   QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60] QT[61] QT[62]
+   QT[63] RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RASSISTBH[2] RASSISTBH[3]
+   RASSISTBL[2] RASSISTBL[3] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7]
+   RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RB[16] RB[17] RB[18]
+   RB[19] RB[20] RB[21] RB[22] RB[23] RB[24] RB[25] RB[26] RB[27] RB[28] RB[29]
+   RB[30] RB[31] RBLRD[1] RBLWA[2] RBLWR[1] RM3CNT RMT[0] RMT[1] RMT[2] RMT[3]
+   RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11]
+   RT[12] RT[13] RT[14] RT[15] RT[16] RT[17] RT[18] RT[19] RT[20] RT[21] RT[22]
+   RT[23] RT[24] RT[25] RT[26] RT[27] RT[28] RT[29] RT[30] RT[31] RWLB_SAC[1]
+   SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9]
+   SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] SEL[16] SEL[17] SEL[18]
+   SEL[19] SEL[20] SEL[21] SEL[22] SEL[23] SEL[24] SEL[25] SEL[26] SEL[27]
+   SEL[28] SEL[29] SEL[30] SEL[31] T1T TEST_RNMB VBA VBA VBA VBA VBA VBA VBA
+   VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA
+   VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDAIL1[1]
+   VDDAIR1[1] VDDMINB VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDWL[2]
+   VDDWL[3] VEDGE[0] VEDGE[1] VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSSC_WL_L[1] VSSC_WL_R[1] WABUF[0] WABUF[1] WABUF[2]
+   WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11]
+   WB[12] WB[13] WB[14] WB[15] WB[16] WB[17] WB[18] WB[19] WB[20] WB[21] WB[22]
+   WB[23] WB[24] WB[25] WB[26] WB[27] WB[28] WB[29] WB[30] WB[31] WB_IN[0]
+   WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8]
+   WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15]
+   WB_IN[16] WB_IN[17] WB_IN[18] WB_IN[19] WB_IN[20] WB_IN[21] WB_IN[22]
+   WB_IN[23] WB_IN[24] WB_IN[25] WB_IN[26] WB_IN[27] WB_IN[28] WB_IN[29]
+   WB_IN[30] WB_IN[31] WCLKB[4] WCLKB[5] WCLKB[6] WCLKB[7] WMT[0] WMT[1] WMT[2]
+   WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6]
+   WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WT[16] WT[17]
+   WT[18] WT[19] WT[20] WT[21] WT[22] WT[23] WT[24] WT[25] WT[26] WT[27] WT[28]
+   WT[29] WT[30] WT[31] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5]
+   WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13]
+   WT_IN[14] WT_IN[15] WT_IN[16] WT_IN[17] WT_IN[18] WT_IN[19] WT_IN[20]
+   WT_IN[21] WT_IN[22] WT_IN[23] WT_IN[24] WT_IN[25] WT_IN[26] WT_IN[27]
+   WT_IN[28] WT_IN[29] WT_IN[30] WT_IN[31] SNPS_SP_HD_16Kx8_mux_row_2
X_ary_row_mx_2_S1 ARYSD[2] ARYSD[3] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+   ARYSD_BC2[1] B[1] BB[128] BB[129] BB[130] BB[131] BB[132] BB[133] BB[134]
+   BB[135] BB[136] BB[137] BB[138] BB[139] BB[140] BB[141] BB[142] BB[143]
+   BB[144] BB[145] BB[146] BB[147] BB[148] BB[149] BB[150] BB[151] BB[152]
+   BB[153] BB[154] BB[155] BB[156] BB[157] BB[158] BB[159] BB[160] BB[161]
+   BB[162] BB[163] BB[164] BB[165] BB[166] BB[167] BB[168] BB[169] BB[170]
+   BB[171] BB[172] BB[173] BB[174] BB[175] BB[176] BB[177] BB[178] BB[179]
+   BB[180] BB[181] BB[182] BB[183] BB[184] BB[185] BB[186] BB[187] BB[188]
+   BB[189] BB[190] BB[191] BB[192] BB[193] BB[194] BB[195] BB[196] BB[197]
+   BB[198] BB[199] BB[200] BB[201] BB[202] BB[203] BB[204] BB[205] BB[206]
+   BB[207] BB[208] BB[209] BB[210] BB[211] BB[212] BB[213] BB[214] BB[215]
+   BB[216] BB[217] BB[218] BB[219] BB[220] BB[221] BB[222] BB[223] BB[224]
+   BB[225] BB[226] BB[227] BB[228] BB[229] BB[230] BB[231] BB[232] BB[233]
+   BB[234] BB[235] BB[236] BB[237] BB[238] BB[239] BB[240] BB[241] BB[242]
+   BB[243] BB[244] BB[245] BB[246] BB[247] BB[248] BB[249] BB[250] BB[251]
+   BB[252] BB[253] BB[254] BB[255] BT[128] BT[129] BT[130] BT[131] BT[132]
+   BT[133] BT[134] BT[135] BT[136] BT[137] BT[138] BT[139] BT[140] BT[141]
+   BT[142] BT[143] BT[144] BT[145] BT[146] BT[147] BT[148] BT[149] BT[150]
+   BT[151] BT[152] BT[153] BT[154] BT[155] BT[156] BT[157] BT[158] BT[159]
+   BT[160] BT[161] BT[162] BT[163] BT[164] BT[165] BT[166] BT[167] BT[168]
+   BT[169] BT[170] BT[171] BT[172] BT[173] BT[174] BT[175] BT[176] BT[177]
+   BT[178] BT[179] BT[180] BT[181] BT[182] BT[183] BT[184] BT[185] BT[186]
+   BT[187] BT[188] BT[189] BT[190] BT[191] BT[192] BT[193] BT[194] BT[195]
+   BT[196] BT[197] BT[198] BT[199] BT[200] BT[201] BT[202] BT[203] BT[204]
+   BT[205] BT[206] BT[207] BT[208] BT[209] BT[210] BT[211] BT[212] BT[213]
+   BT[214] BT[215] BT[216] BT[217] BT[218] BT[219] BT[220] BT[221] BT[222]
+   BT[223] BT[224] BT[225] BT[226] BT[227] BT[228] BT[229] BT[230] BT[231]
+   BT[232] BT[233] BT[234] BT[235] BT[236] BT[237] BT[238] BT[239] BT[240]
+   BT[241] BT[242] BT[243] BT[244] BT[245] BT[246] BT[247] BT[248] BT[249]
+   BT[250] BT[251] BT[252] BT[253] BT[254] BT[255] BYP_VLOAD[1] C[1] CENDP
+   DEF_MODE EDGEB[4] EDGEB[5] EDGEB[6] EDGEB[7] EDGET[4] EDGET[5] EDGET[6]
+   EDGET[7] FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR0 LBKADR1
+   LCGTH[0] LCGTH[1] LDFTX LITESLP LMATCH[2] LMATCHB LOG0 LOG1 LWEIB LXADR[0]
+   LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+   LYADR[1] B[1] PBB[9] PBB[10] PBB[11] PBB[12] PBB[13] PBB[14] PBB[15] C[1]
+   PCB[9] PCB[10] PCB[11] PCB[12] PCB[13] PCB[14] PCB[15] PWDO[0] PWDO[1]
+   QB[32] QB[33] QB[34] QB[35] QB[36] QB[37] QB[38] QB[39] QB[40] QB[41] QB[42]
+   QB[43] QB[44] QB[45] QB[46] QB[47] QB[48] QB[49] QB[50] QB[51] QB[52] QB[53]
+   QB[54] QB[55] QB[56] QB[57] QB[58] QB[59] QB[60] QB[61] QB[62] QB[63] QT[32]
+   QT[33] QT[34] QT[35] QT[36] QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43]
+   QT[44] QT[45] QT[46] QT[47] QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54]
+   QT[55] QT[56] QT[57] QT[58] QT[59] QT[60] QT[61] QT[62] QT[63] RASSIST[0]
+   RASSIST[1] RASSIST[2] RASSIST[3] RASSISTBH[2] RASSISTBH[3] RASSISTBL[2]
+   RASSISTBL[3] RBLRD[1] RBLWA[2] RBLWR[1] RBLWR_LOAD[1] RM3CNT RMT[0] RMT[1]
+   RMT[2] RMT[3] RWLB_SAC[1] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+   SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] SEL[16]
+   SEL[17] SEL[18] SEL[19] SEL[20] SEL[21] SEL[22] SEL[23] SEL[24] SEL[25]
+   SEL[26] SEL[27] SEL[28] SEL[29] SEL[30] SEL[31] T1T TEST_RNMB VBA VBN VBP
+   VDDA VDDAIL1[1] VDDAIR1[1] VDDMINB VDDP VDDPI VDDWL[2] VDDWL[3] VEDGE[0]
+   VEDGE[1] VSS VSSC_WL_L[1] VSSC_WL_R[1] WABUF[0] WABUF[1] WABUF[2] WB_IN[0]
+   WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8]
+   WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15]
+   WB_IN[16] WB_IN[17] WB_IN[18] WB_IN[19] WB_IN[20] WB_IN[21] WB_IN[22]
+   WB_IN[23] WB_IN[24] WB_IN[25] WB_IN[26] WB_IN[27] WB_IN[28] WB_IN[29]
+   WB_IN[30] WB_IN[31] WCLKB[4] WCLKB[5] WCLKB[6] WCLKB[7] WLH[256] WLH[257]
+   WLH[258] WLH[259] WLH[260] WLH[261] WLH[262] WLH[263] WLH[264] WLH[265]
+   WLH[266] WLH[267] WLH[268] WLH[269] WLH[270] WLH[271] WLH[272] WLH[273]
+   WLH[274] WLH[275] WLH[276] WLH[277] WLH[278] WLH[279] WLH[280] WLH[281]
+   WLH[282] WLH[283] WLH[284] WLH[285] WLH[286] WLH[287] WLH[288] WLH[289]
+   WLH[290] WLH[291] WLH[292] WLH[293] WLH[294] WLH[295] WLH[296] WLH[297]
+   WLH[298] WLH[299] WLH[300] WLH[301] WLH[302] WLH[303] WLH[304] WLH[305]
+   WLH[306] WLH[307] WLH[308] WLH[309] WLH[310] WLH[311] WLH[312] WLH[313]
+   WLH[314] WLH[315] WLH[316] WLH[317] WLH[318] WLH[319] WLH[320] WLH[321]
+   WLH[322] WLH[323] WLH[324] WLH[325] WLH[326] WLH[327] WLH[328] WLH[329]
+   WLH[330] WLH[331] WLH[332] WLH[333] WLH[334] WLH[335] WLH[336] WLH[337]
+   WLH[338] WLH[339] WLH[340] WLH[341] WLH[342] WLH[343] WLH[344] WLH[345]
+   WLH[346] WLH[347] WLH[348] WLH[349] WLH[350] WLH[351] WLH[352] WLH[353]
+   WLH[354] WLH[355] WLH[356] WLH[357] WLH[358] WLH[359] WLH[360] WLH[361]
+   WLH[362] WLH[363] WLH[364] WLH[365] WLH[366] WLH[367] WLH[368] WLH[369]
+   WLH[370] WLH[371] WLH[372] WLH[373] WLH[374] WLH[375] WLH[376] WLH[377]
+   WLH[378] WLH[379] WLH[380] WLH[381] WLH[382] WLH[383] WLH[384] WLH[385]
+   WLH[386] WLH[387] WLH[388] WLH[389] WLH[390] WLH[391] WLH[392] WLH[393]
+   WLH[394] WLH[395] WLH[396] WLH[397] WLH[398] WLH[399] WLH[400] WLH[401]
+   WLH[402] WLH[403] WLH[404] WLH[405] WLH[406] WLH[407] WLH[408] WLH[409]
+   WLH[410] WLH[411] WLH[412] WLH[413] WLH[414] WLH[415] WLH[416] WLH[417]
+   WLH[418] WLH[419] WLH[420] WLH[421] WLH[422] WLH[423] WLH[424] WLH[425]
+   WLH[426] WLH[427] WLH[428] WLH[429] WLH[430] WLH[431] WLH[432] WLH[433]
+   WLH[434] WLH[435] WLH[436] WLH[437] WLH[438] WLH[439] WLH[440] WLH[441]
+   WLH[442] WLH[443] WLH[444] WLH[445] WLH[446] WLH[447] WLH[448] WLH[449]
+   WLH[450] WLH[451] WLH[452] WLH[453] WLH[454] WLH[455] WLH[456] WLH[457]
+   WLH[458] WLH[459] WLH[460] WLH[461] WLH[462] WLH[463] WLH[464] WLH[465]
+   WLH[466] WLH[467] WLH[468] WLH[469] WLH[470] WLH[471] WLH[472] WLH[473]
+   WLH[474] WLH[475] WLH[476] WLH[477] WLH[478] WLH[479] WLH[480] WLH[481]
+   WLH[482] WLH[483] WLH[484] WLH[485] WLH[486] WLH[487] WLH[488] WLH[489]
+   WLH[490] WLH[491] WLH[492] WLH[493] WLH[494] WLH[495] WLH[496] WLH[497]
+   WLH[498] WLH[499] WLH[500] WLH[501] WLH[502] WLH[503] WLH[504] WLH[505]
+   WLH[506] WLH[507] WLH[508] WLH[509] WLH[510] WLH[511] WLL[256] WLL[257]
+   WLL[258] WLL[259] WLL[260] WLL[261] WLL[262] WLL[263] WLL[264] WLL[265]
+   WLL[266] WLL[267] WLL[268] WLL[269] WLL[270] WLL[271] WLL[272] WLL[273]
+   WLL[274] WLL[275] WLL[276] WLL[277] WLL[278] WLL[279] WLL[280] WLL[281]
+   WLL[282] WLL[283] WLL[284] WLL[285] WLL[286] WLL[287] WLL[288] WLL[289]
+   WLL[290] WLL[291] WLL[292] WLL[293] WLL[294] WLL[295] WLL[296] WLL[297]
+   WLL[298] WLL[299] WLL[300] WLL[301] WLL[302] WLL[303] WLL[304] WLL[305]
+   WLL[306] WLL[307] WLL[308] WLL[309] WLL[310] WLL[311] WLL[312] WLL[313]
+   WLL[314] WLL[315] WLL[316] WLL[317] WLL[318] WLL[319] WLL[320] WLL[321]
+   WLL[322] WLL[323] WLL[324] WLL[325] WLL[326] WLL[327] WLL[328] WLL[329]
+   WLL[330] WLL[331] WLL[332] WLL[333] WLL[334] WLL[335] WLL[336] WLL[337]
+   WLL[338] WLL[339] WLL[340] WLL[341] WLL[342] WLL[343] WLL[344] WLL[345]
+   WLL[346] WLL[347] WLL[348] WLL[349] WLL[350] WLL[351] WLL[352] WLL[353]
+   WLL[354] WLL[355] WLL[356] WLL[357] WLL[358] WLL[359] WLL[360] WLL[361]
+   WLL[362] WLL[363] WLL[364] WLL[365] WLL[366] WLL[367] WLL[368] WLL[369]
+   WLL[370] WLL[371] WLL[372] WLL[373] WLL[374] WLL[375] WLL[376] WLL[377]
+   WLL[378] WLL[379] WLL[380] WLL[381] WLL[382] WLL[383] WLL[384] WLL[385]
+   WLL[386] WLL[387] WLL[388] WLL[389] WLL[390] WLL[391] WLL[392] WLL[393]
+   WLL[394] WLL[395] WLL[396] WLL[397] WLL[398] WLL[399] WLL[400] WLL[401]
+   WLL[402] WLL[403] WLL[404] WLL[405] WLL[406] WLL[407] WLL[408] WLL[409]
+   WLL[410] WLL[411] WLL[412] WLL[413] WLL[414] WLL[415] WLL[416] WLL[417]
+   WLL[418] WLL[419] WLL[420] WLL[421] WLL[422] WLL[423] WLL[424] WLL[425]
+   WLL[426] WLL[427] WLL[428] WLL[429] WLL[430] WLL[431] WLL[432] WLL[433]
+   WLL[434] WLL[435] WLL[436] WLL[437] WLL[438] WLL[439] WLL[440] WLL[441]
+   WLL[442] WLL[443] WLL[444] WLL[445] WLL[446] WLL[447] WLL[448] WLL[449]
+   WLL[450] WLL[451] WLL[452] WLL[453] WLL[454] WLL[455] WLL[456] WLL[457]
+   WLL[458] WLL[459] WLL[460] WLL[461] WLL[462] WLL[463] WLL[464] WLL[465]
+   WLL[466] WLL[467] WLL[468] WLL[469] WLL[470] WLL[471] WLL[472] WLL[473]
+   WLL[474] WLL[475] WLL[476] WLL[477] WLL[478] WLL[479] WLL[480] WLL[481]
+   WLL[482] WLL[483] WLL[484] WLL[485] WLL[486] WLL[487] WLL[488] WLL[489]
+   WLL[490] WLL[491] WLL[492] WLL[493] WLL[494] WLL[495] WLL[496] WLL[497]
+   WLL[498] WLL[499] WLL[500] WLL[501] WLL[502] WLL[503] WLL[504] WLL[505]
+   WLL[506] WLL[507] WLL[508] WLL[509] WLL[510] WLL[511] WMT[0] WMT[1] WMT[2]
+   WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3]
+   WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11]
+   WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15] WT_IN[16] WT_IN[17] WT_IN[18]
+   WT_IN[19] WT_IN[20] WT_IN[21] WT_IN[22] WT_IN[23] WT_IN[24] WT_IN[25]
+   WT_IN[26] WT_IN[27] WT_IN[28] WT_IN[29] WT_IN[30] WT_IN[31]
+   SNPS_SP_HD_16Kx8_ary_row_mx_2
X_ref_row_2 ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1] ARYSD[2]
+   ARYSD[3] ARYSD[4] ARYSD[5] BB[128] BB[129] BB[130] BB[131] BB[132] BB[133]
+   BB[134] BB[135] BB[136] BB[137] BB[138] BB[139] BB[140] BB[141] BB[142]
+   BB[143] BB[144] BB[145] BB[146] BB[147] BB[148] BB[149] BB[150] BB[151]
+   BB[152] BB[153] BB[154] BB[155] BB[156] BB[157] BB[158] BB[159] BB[160]
+   BB[161] BB[162] BB[163] BB[164] BB[165] BB[166] BB[167] BB[168] BB[169]
+   BB[170] BB[171] BB[172] BB[173] BB[174] BB[175] BB[176] BB[177] BB[178]
+   BB[179] BB[180] BB[181] BB[182] BB[183] BB[184] BB[185] BB[186] BB[187]
+   BB[188] BB[189] BB[190] BB[191] BB[192] BB[193] BB[194] BB[195] BB[196]
+   BB[197] BB[198] BB[199] BB[200] BB[201] BB[202] BB[203] BB[204] BB[205]
+   BB[206] BB[207] BB[208] BB[209] BB[210] BB[211] BB[212] BB[213] BB[214]
+   BB[215] BB[216] BB[217] BB[218] BB[219] BB[220] BB[221] BB[222] BB[223]
+   BB[224] BB[225] BB[226] BB[227] BB[228] BB[229] BB[230] BB[231] BB[232]
+   BB[233] BB[234] BB[235] BB[236] BB[237] BB[238] BB[239] BB[240] BB[241]
+   BB[242] BB[243] BB[244] BB[245] BB[246] BB[247] BB[248] BB[249] BB[250]
+   BB[251] BB[252] BB[253] BB[254] BB[255] CENDP DEF_MODE FAST1_MODE FAST2_MODE
+   FLOAT FLOATT FLOAT_RET LOG1 LBKADR0 LBKADR1 LCGTH[0] LCGTH[1] LDFTX LITESLP
+   LLBKADRB[5] LLBKADRB[6] LMATCHB LOG1 LOG0 LOG0 LOG1 LOG1 LWEIB LXADR[0]
+   LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+   LYADR[1] PWDO[0] PWDO[1] LLBKADRB[5] LLBKADRB[6] QB[32] QB[33] QB[34] QB[35]
+   QB[36] QB[37] QB[38] QB[39] QB[40] QB[41] QB[42] QB[43] QB[44] QB[45] QB[46]
+   QB[47] QB[48] QB[49] QB[50] QB[51] QB[52] QB[53] QB[54] QB[55] QB[56] QB[57]
+   QB[58] QB[59] QB[60] QB[61] QB[62] QB[63] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] RASSIST[0] RASSIST[1] RASSIST[2]
+   RASSIST[3] RASSISTBH[2] RASSISTBH[3] RASSISTBL[2] RASSISTBL[3] RBLRD[1]
+   RBLWA[2] RBLWR[1] RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC[1]
+   RWL_DLY_0[0] RWL_DLY_2[0] RWL_DLY_4[0] RWL_DLY_0[0] RWL_DLY_0[0]
+   RWL_RWLD_AND[0] RWL_RWLD_AND_WR[0] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5]
+   SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15]
+   SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21] SEL[22] SEL[23] SEL[24]
+   SEL[25] SEL[26] SEL[27] SEL[28] SEL[29] SEL[30] SEL[31] T1T TEST_RNMB
+   TOPEDGE[4] TOPEDGE[5] TOPEDGE[6] TOPEDGE[7] VBA VBA VBA VBA VBA VBA VBA VBA
+   VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA
+   VBA VBA VBA VBA VBA VBA VBA VBA VBA VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VDDA VDDA VDDA VDDAIL1[1] VDDAIR1[1] VDDMINB
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDWL[2] VDDWL[3] VEDGE[0] VEDGE[1] VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSSC_WL_L[1] VSSC_WL_R[1] WABUF[0] WABUF[1] WABUF[2] WB_IN[0] WB_IN[1]
+   WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9]
+   WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WB_IN[16]
+   WB_IN[17] WB_IN[18] WB_IN[19] WB_IN[20] WB_IN[21] WB_IN[22] WB_IN[23]
+   WB_IN[24] WB_IN[25] WB_IN[26] WB_IN[27] WB_IN[28] WB_IN[29] WB_IN[30]
+   WB_IN[31] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT_IN[0]
+   WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8]
+   WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15]
+   WT_IN[16] WT_IN[17] WT_IN[18] WT_IN[19] WT_IN[20] WT_IN[21] WT_IN[22]
+   WT_IN[23] WT_IN[24] WT_IN[25] WT_IN[26] WT_IN[27] WT_IN[28] WT_IN[29]
+   WT_IN[30] WT_IN[31] SNPS_SP_HD_16Kx8_ref_row_2
X_ref_row_mx_4 ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1] ARYSD[4]
+   ARYSD[5] ARYSD[6] ARYSD[7] BB[256] BB[257] BB[258] BB[259] BB[260] BB[261]
+   BB[262] BB[263] BB[264] BB[265] BB[266] BB[267] BB[268] BB[269] BB[270]
+   BB[271] BB[272] BB[273] BB[274] BB[275] BB[276] BB[277] BB[278] BB[279]
+   BB[280] BB[281] BB[282] BB[283] BB[284] BB[285] BB[286] BB[287] BB[288]
+   BB[289] BB[290] BB[291] BB[292] BB[293] BB[294] BB[295] BB[296] BB[297]
+   BB[298] BB[299] BB[300] BB[301] BB[302] BB[303] BB[304] BB[305] BB[306]
+   BB[307] BB[308] BB[309] BB[310] BB[311] BB[312] BB[313] BB[314] BB[315]
+   BB[316] BB[317] BB[318] BB[319] BB[320] BB[321] BB[322] BB[323] BB[324]
+   BB[325] BB[326] BB[327] BB[328] BB[329] BB[330] BB[331] BB[332] BB[333]
+   BB[334] BB[335] BB[336] BB[337] BB[338] BB[339] BB[340] BB[341] BB[342]
+   BB[343] BB[344] BB[345] BB[346] BB[347] BB[348] BB[349] BB[350] BB[351]
+   BB[352] BB[353] BB[354] BB[355] BB[356] BB[357] BB[358] BB[359] BB[360]
+   BB[361] BB[362] BB[363] BB[364] BB[365] BB[366] BB[367] BB[368] BB[369]
+   BB[370] BB[371] BB[372] BB[373] BB[374] BB[375] BB[376] BB[377] BB[378]
+   BB[379] BB[380] BB[381] BB[382] BB[383] CENDP DEF_MODE FAST1_MODE FAST2_MODE
+   FLOAT FLOATT FLOAT_RET LBKADR0 LBKADR1 LCGTH[2] LCGTH[3] LDFTX LITESLP
+   LLBKADRB[7] LLBKADRB[8] LMATCHB LMATCHB_I[2] LOG0 LOG0 LOG1 LOG1 LWEIB
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] PWDO[0] PWDO[1] PLBKADR[7] PLBKADR[8] QB[32] QB[33] QB[34]
+   QB[35] QB[36] QB[37] QB[38] QB[39] QB[40] QB[41] QB[42] QB[43] QB[44] QB[45]
+   QB[46] QB[47] QB[48] QB[49] QB[50] QB[51] QB[52] QB[53] QB[54] QB[55] QB[56]
+   QB[57] QB[58] QB[59] QB[60] QB[61] QB[62] QB[63] QT[32] QT[33] QT[34] QT[35]
+   QT[36] QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46]
+   QT[47] QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57]
+   QT[58] QT[59] QT[60] QT[61] QT[62] QT[63] RASSIST[0] RASSIST[1] RASSIST[2]
+   RASSIST[3] RASSISTB[4] RASSISTB[5] RASSISTB[6] RASSISTB[7] RBLRD[2] RBLWA[3]
+   RBLWR[2] RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC[1] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+   SEL[13] SEL[14] SEL[15] SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21]
+   SEL[22] SEL[23] SEL[24] SEL[25] SEL[26] SEL[27] SEL[28] SEL[29] SEL[30]
+   SEL[31] T1T TEST_RNMB TOPEDGE[4] TOPEDGE[5] TOPEDGE[6] TOPEDGE[7] VBA VBA
+   VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA
+   VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VDDA VDDA VDDA
+   VDDAIL1[2] VDDAIR1[2] VDDMINB VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDWL[4]
+   VDDWL[5] VEDGE[0] VEDGE[1] VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS WABUF[0] WABUF[1] WABUF[2] WB_IN[0] WB_IN[1]
+   WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9]
+   WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WB_IN[16]
+   WB_IN[17] WB_IN[18] WB_IN[19] WB_IN[20] WB_IN[21] WB_IN[22] WB_IN[23]
+   WB_IN[24] WB_IN[25] WB_IN[26] WB_IN[27] WB_IN[28] WB_IN[29] WB_IN[30]
+   WB_IN[31] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT_IN[0]
+   WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8]
+   WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15]
+   WT_IN[16] WT_IN[17] WT_IN[18] WT_IN[19] WT_IN[20] WT_IN[21] WT_IN[22]
+   WT_IN[23] WT_IN[24] WT_IN[25] WT_IN[26] WT_IN[27] WT_IN[28] WT_IN[29]
+   WT_IN[30] WT_IN[31] SNPS_SP_HD_16Kx8_ref_row_mx_4
X_ary_row_mx_2_F1 ARYSD[6] ARYSD[7] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+   ARYSD_BC2[1] B[2] BB[256] BB[257] BB[258] BB[259] BB[260] BB[261] BB[262]
+   BB[263] BB[264] BB[265] BB[266] BB[267] BB[268] BB[269] BB[270] BB[271]
+   BB[272] BB[273] BB[274] BB[275] BB[276] BB[277] BB[278] BB[279] BB[280]
+   BB[281] BB[282] BB[283] BB[284] BB[285] BB[286] BB[287] BB[288] BB[289]
+   BB[290] BB[291] BB[292] BB[293] BB[294] BB[295] BB[296] BB[297] BB[298]
+   BB[299] BB[300] BB[301] BB[302] BB[303] BB[304] BB[305] BB[306] BB[307]
+   BB[308] BB[309] BB[310] BB[311] BB[312] BB[313] BB[314] BB[315] BB[316]
+   BB[317] BB[318] BB[319] BB[320] BB[321] BB[322] BB[323] BB[324] BB[325]
+   BB[326] BB[327] BB[328] BB[329] BB[330] BB[331] BB[332] BB[333] BB[334]
+   BB[335] BB[336] BB[337] BB[338] BB[339] BB[340] BB[341] BB[342] BB[343]
+   BB[344] BB[345] BB[346] BB[347] BB[348] BB[349] BB[350] BB[351] BB[352]
+   BB[353] BB[354] BB[355] BB[356] BB[357] BB[358] BB[359] BB[360] BB[361]
+   BB[362] BB[363] BB[364] BB[365] BB[366] BB[367] BB[368] BB[369] BB[370]
+   BB[371] BB[372] BB[373] BB[374] BB[375] BB[376] BB[377] BB[378] BB[379]
+   BB[380] BB[381] BB[382] BB[383] BT[256] BT[257] BT[258] BT[259] BT[260]
+   BT[261] BT[262] BT[263] BT[264] BT[265] BT[266] BT[267] BT[268] BT[269]
+   BT[270] BT[271] BT[272] BT[273] BT[274] BT[275] BT[276] BT[277] BT[278]
+   BT[279] BT[280] BT[281] BT[282] BT[283] BT[284] BT[285] BT[286] BT[287]
+   BT[288] BT[289] BT[290] BT[291] BT[292] BT[293] BT[294] BT[295] BT[296]
+   BT[297] BT[298] BT[299] BT[300] BT[301] BT[302] BT[303] BT[304] BT[305]
+   BT[306] BT[307] BT[308] BT[309] BT[310] BT[311] BT[312] BT[313] BT[314]
+   BT[315] BT[316] BT[317] BT[318] BT[319] BT[320] BT[321] BT[322] BT[323]
+   BT[324] BT[325] BT[326] BT[327] BT[328] BT[329] BT[330] BT[331] BT[332]
+   BT[333] BT[334] BT[335] BT[336] BT[337] BT[338] BT[339] BT[340] BT[341]
+   BT[342] BT[343] BT[344] BT[345] BT[346] BT[347] BT[348] BT[349] BT[350]
+   BT[351] BT[352] BT[353] BT[354] BT[355] BT[356] BT[357] BT[358] BT[359]
+   BT[360] BT[361] BT[362] BT[363] BT[364] BT[365] BT[366] BT[367] BT[368]
+   BT[369] BT[370] BT[371] BT[372] BT[373] BT[374] BT[375] BT[376] BT[377]
+   BT[378] BT[379] BT[380] BT[381] BT[382] BT[383] BYP_VLOAD[2] C[2] CENDP
+   DEF_MODE EDGEB[8] EDGEB[9] EDGEB[10] EDGEB[11] EDGET[8] EDGET[9] EDGET[10]
+   EDGET[11] FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR0 LBKADR1
+   LCGTH[2] LCGTH[3] LDFTX LITESLP LMATCH[3] LMATCHB LOG0 LOG1 LWEIB LXADR[0]
+   LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+   LYADR[1] B[2] PBB[17] PBB[18] PBB[19] PBB[20] PBB[21] PBB[22] PBB[23] C[2]
+   PCB[17] PCB[18] PCB[19] PCB[20] PCB[21] PCB[22] PCB[23] PWDO[0] PWDO[1]
+   QB[32] QB[33] QB[34] QB[35] QB[36] QB[37] QB[38] QB[39] QB[40] QB[41] QB[42]
+   QB[43] QB[44] QB[45] QB[46] QB[47] QB[48] QB[49] QB[50] QB[51] QB[52] QB[53]
+   QB[54] QB[55] QB[56] QB[57] QB[58] QB[59] QB[60] QB[61] QB[62] QB[63] QT[32]
+   QT[33] QT[34] QT[35] QT[36] QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43]
+   QT[44] QT[45] QT[46] QT[47] QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54]
+   QT[55] QT[56] QT[57] QT[58] QT[59] QT[60] QT[61] QT[62] QT[63] RASSIST[0]
+   RASSIST[1] RASSIST[2] RASSIST[3] RASSISTBH[4] RASSISTBH[5] RASSISTBL[4]
+   RASSISTBL[5] RBLRD[2] RBLWA[3] RBLWR[2] RBLWR_LOAD[2] RM3CNT RMT[0] RMT[1]
+   RMT[2] RMT[3] RWLB_SAC[1] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+   SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] SEL[16]
+   SEL[17] SEL[18] SEL[19] SEL[20] SEL[21] SEL[22] SEL[23] SEL[24] SEL[25]
+   SEL[26] SEL[27] SEL[28] SEL[29] SEL[30] SEL[31] T1T TEST_RNMB VBA VBN VBP
+   VDDA VDDAIL1[2] VDDAIR1[2] VDDMINB VDDP VDDPI VDDWL[4] VDDWL[5] VEDGE[0]
+   VEDGE[1] VSS VSSC_WL_L[2] VSSC_WL_R[2] WABUF[0] WABUF[1] WABUF[2] WB_IN[0]
+   WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8]
+   WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15]
+   WB_IN[16] WB_IN[17] WB_IN[18] WB_IN[19] WB_IN[20] WB_IN[21] WB_IN[22]
+   WB_IN[23] WB_IN[24] WB_IN[25] WB_IN[26] WB_IN[27] WB_IN[28] WB_IN[29]
+   WB_IN[30] WB_IN[31] WCLKB[8] WCLKB[9] WCLKB[10] WCLKB[11] WLH[512] WLH[513]
+   WLH[514] WLH[515] WLH[516] WLH[517] WLH[518] WLH[519] WLH[520] WLH[521]
+   WLH[522] WLH[523] WLH[524] WLH[525] WLH[526] WLH[527] WLH[528] WLH[529]
+   WLH[530] WLH[531] WLH[532] WLH[533] WLH[534] WLH[535] WLH[536] WLH[537]
+   WLH[538] WLH[539] WLH[540] WLH[541] WLH[542] WLH[543] WLH[544] WLH[545]
+   WLH[546] WLH[547] WLH[548] WLH[549] WLH[550] WLH[551] WLH[552] WLH[553]
+   WLH[554] WLH[555] WLH[556] WLH[557] WLH[558] WLH[559] WLH[560] WLH[561]
+   WLH[562] WLH[563] WLH[564] WLH[565] WLH[566] WLH[567] WLH[568] WLH[569]
+   WLH[570] WLH[571] WLH[572] WLH[573] WLH[574] WLH[575] WLH[576] WLH[577]
+   WLH[578] WLH[579] WLH[580] WLH[581] WLH[582] WLH[583] WLH[584] WLH[585]
+   WLH[586] WLH[587] WLH[588] WLH[589] WLH[590] WLH[591] WLH[592] WLH[593]
+   WLH[594] WLH[595] WLH[596] WLH[597] WLH[598] WLH[599] WLH[600] WLH[601]
+   WLH[602] WLH[603] WLH[604] WLH[605] WLH[606] WLH[607] WLH[608] WLH[609]
+   WLH[610] WLH[611] WLH[612] WLH[613] WLH[614] WLH[615] WLH[616] WLH[617]
+   WLH[618] WLH[619] WLH[620] WLH[621] WLH[622] WLH[623] WLH[624] WLH[625]
+   WLH[626] WLH[627] WLH[628] WLH[629] WLH[630] WLH[631] WLH[632] WLH[633]
+   WLH[634] WLH[635] WLH[636] WLH[637] WLH[638] WLH[639] WLH[640] WLH[641]
+   WLH[642] WLH[643] WLH[644] WLH[645] WLH[646] WLH[647] WLH[648] WLH[649]
+   WLH[650] WLH[651] WLH[652] WLH[653] WLH[654] WLH[655] WLH[656] WLH[657]
+   WLH[658] WLH[659] WLH[660] WLH[661] WLH[662] WLH[663] WLH[664] WLH[665]
+   WLH[666] WLH[667] WLH[668] WLH[669] WLH[670] WLH[671] WLH[672] WLH[673]
+   WLH[674] WLH[675] WLH[676] WLH[677] WLH[678] WLH[679] WLH[680] WLH[681]
+   WLH[682] WLH[683] WLH[684] WLH[685] WLH[686] WLH[687] WLH[688] WLH[689]
+   WLH[690] WLH[691] WLH[692] WLH[693] WLH[694] WLH[695] WLH[696] WLH[697]
+   WLH[698] WLH[699] WLH[700] WLH[701] WLH[702] WLH[703] WLH[704] WLH[705]
+   WLH[706] WLH[707] WLH[708] WLH[709] WLH[710] WLH[711] WLH[712] WLH[713]
+   WLH[714] WLH[715] WLH[716] WLH[717] WLH[718] WLH[719] WLH[720] WLH[721]
+   WLH[722] WLH[723] WLH[724] WLH[725] WLH[726] WLH[727] WLH[728] WLH[729]
+   WLH[730] WLH[731] WLH[732] WLH[733] WLH[734] WLH[735] WLH[736] WLH[737]
+   WLH[738] WLH[739] WLH[740] WLH[741] WLH[742] WLH[743] WLH[744] WLH[745]
+   WLH[746] WLH[747] WLH[748] WLH[749] WLH[750] WLH[751] WLH[752] WLH[753]
+   WLH[754] WLH[755] WLH[756] WLH[757] WLH[758] WLH[759] WLH[760] WLH[761]
+   WLH[762] WLH[763] WLH[764] WLH[765] WLH[766] WLH[767] WLL[512] WLL[513]
+   WLL[514] WLL[515] WLL[516] WLL[517] WLL[518] WLL[519] WLL[520] WLL[521]
+   WLL[522] WLL[523] WLL[524] WLL[525] WLL[526] WLL[527] WLL[528] WLL[529]
+   WLL[530] WLL[531] WLL[532] WLL[533] WLL[534] WLL[535] WLL[536] WLL[537]
+   WLL[538] WLL[539] WLL[540] WLL[541] WLL[542] WLL[543] WLL[544] WLL[545]
+   WLL[546] WLL[547] WLL[548] WLL[549] WLL[550] WLL[551] WLL[552] WLL[553]
+   WLL[554] WLL[555] WLL[556] WLL[557] WLL[558] WLL[559] WLL[560] WLL[561]
+   WLL[562] WLL[563] WLL[564] WLL[565] WLL[566] WLL[567] WLL[568] WLL[569]
+   WLL[570] WLL[571] WLL[572] WLL[573] WLL[574] WLL[575] WLL[576] WLL[577]
+   WLL[578] WLL[579] WLL[580] WLL[581] WLL[582] WLL[583] WLL[584] WLL[585]
+   WLL[586] WLL[587] WLL[588] WLL[589] WLL[590] WLL[591] WLL[592] WLL[593]
+   WLL[594] WLL[595] WLL[596] WLL[597] WLL[598] WLL[599] WLL[600] WLL[601]
+   WLL[602] WLL[603] WLL[604] WLL[605] WLL[606] WLL[607] WLL[608] WLL[609]
+   WLL[610] WLL[611] WLL[612] WLL[613] WLL[614] WLL[615] WLL[616] WLL[617]
+   WLL[618] WLL[619] WLL[620] WLL[621] WLL[622] WLL[623] WLL[624] WLL[625]
+   WLL[626] WLL[627] WLL[628] WLL[629] WLL[630] WLL[631] WLL[632] WLL[633]
+   WLL[634] WLL[635] WLL[636] WLL[637] WLL[638] WLL[639] WLL[640] WLL[641]
+   WLL[642] WLL[643] WLL[644] WLL[645] WLL[646] WLL[647] WLL[648] WLL[649]
+   WLL[650] WLL[651] WLL[652] WLL[653] WLL[654] WLL[655] WLL[656] WLL[657]
+   WLL[658] WLL[659] WLL[660] WLL[661] WLL[662] WLL[663] WLL[664] WLL[665]
+   WLL[666] WLL[667] WLL[668] WLL[669] WLL[670] WLL[671] WLL[672] WLL[673]
+   WLL[674] WLL[675] WLL[676] WLL[677] WLL[678] WLL[679] WLL[680] WLL[681]
+   WLL[682] WLL[683] WLL[684] WLL[685] WLL[686] WLL[687] WLL[688] WLL[689]
+   WLL[690] WLL[691] WLL[692] WLL[693] WLL[694] WLL[695] WLL[696] WLL[697]
+   WLL[698] WLL[699] WLL[700] WLL[701] WLL[702] WLL[703] WLL[704] WLL[705]
+   WLL[706] WLL[707] WLL[708] WLL[709] WLL[710] WLL[711] WLL[712] WLL[713]
+   WLL[714] WLL[715] WLL[716] WLL[717] WLL[718] WLL[719] WLL[720] WLL[721]
+   WLL[722] WLL[723] WLL[724] WLL[725] WLL[726] WLL[727] WLL[728] WLL[729]
+   WLL[730] WLL[731] WLL[732] WLL[733] WLL[734] WLL[735] WLL[736] WLL[737]
+   WLL[738] WLL[739] WLL[740] WLL[741] WLL[742] WLL[743] WLL[744] WLL[745]
+   WLL[746] WLL[747] WLL[748] WLL[749] WLL[750] WLL[751] WLL[752] WLL[753]
+   WLL[754] WLL[755] WLL[756] WLL[757] WLL[758] WLL[759] WLL[760] WLL[761]
+   WLL[762] WLL[763] WLL[764] WLL[765] WLL[766] WLL[767] WMT[0] WMT[1] WMT[2]
+   WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3]
+   WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11]
+   WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15] WT_IN[16] WT_IN[17] WT_IN[18]
+   WT_IN[19] WT_IN[20] WT_IN[21] WT_IN[22] WT_IN[23] WT_IN[24] WT_IN[25]
+   WT_IN[26] WT_IN[27] WT_IN[28] WT_IN[29] WT_IN[30] WT_IN[31]
+   SNPS_SP_HD_16Kx8_ary_row_mx_2
X_mux_row_b_mx_F0 ARYSD[6] ARYSD[7] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+   ARYSD_BC2[1] BB[256] BB[257] BB[258] BB[259] BB[260] BB[261] BB[262] BB[263]
+   BB[264] BB[265] BB[266] BB[267] BB[268] BB[269] BB[270] BB[271] BB[272]
+   BB[273] BB[274] BB[275] BB[276] BB[277] BB[278] BB[279] BB[280] BB[281]
+   BB[282] BB[283] BB[284] BB[285] BB[286] BB[287] BB[288] BB[289] BB[290]
+   BB[291] BB[292] BB[293] BB[294] BB[295] BB[296] BB[297] BB[298] BB[299]
+   BB[300] BB[301] BB[302] BB[303] BB[304] BB[305] BB[306] BB[307] BB[308]
+   BB[309] BB[310] BB[311] BB[312] BB[313] BB[314] BB[315] BB[316] BB[317]
+   BB[318] BB[319] BB[320] BB[321] BB[322] BB[323] BB[324] BB[325] BB[326]
+   BB[327] BB[328] BB[329] BB[330] BB[331] BB[332] BB[333] BB[334] BB[335]
+   BB[336] BB[337] BB[338] BB[339] BB[340] BB[341] BB[342] BB[343] BB[344]
+   BB[345] BB[346] BB[347] BB[348] BB[349] BB[350] BB[351] BB[352] BB[353]
+   BB[354] BB[355] BB[356] BB[357] BB[358] BB[359] BB[360] BB[361] BB[362]
+   BB[363] BB[364] BB[365] BB[366] BB[367] BB[368] BB[369] BB[370] BB[371]
+   BB[372] BB[373] BB[374] BB[375] BB[376] BB[377] BB[378] BB[379] BB[380]
+   BB[381] BB[382] BB[383] BOTEDGE[8] BOTEDGE[9] BOTEDGE[10] BOTEDGE[11]
+   BT[256] BT[257] BT[258] BT[259] BT[260] BT[261] BT[262] BT[263] BT[264]
+   BT[265] BT[266] BT[267] BT[268] BT[269] BT[270] BT[271] BT[272] BT[273]
+   BT[274] BT[275] BT[276] BT[277] BT[278] BT[279] BT[280] BT[281] BT[282]
+   BT[283] BT[284] BT[285] BT[286] BT[287] BT[288] BT[289] BT[290] BT[291]
+   BT[292] BT[293] BT[294] BT[295] BT[296] BT[297] BT[298] BT[299] BT[300]
+   BT[301] BT[302] BT[303] BT[304] BT[305] BT[306] BT[307] BT[308] BT[309]
+   BT[310] BT[311] BT[312] BT[313] BT[314] BT[315] BT[316] BT[317] BT[318]
+   BT[319] BT[320] BT[321] BT[322] BT[323] BT[324] BT[325] BT[326] BT[327]
+   BT[328] BT[329] BT[330] BT[331] BT[332] BT[333] BT[334] BT[335] BT[336]
+   BT[337] BT[338] BT[339] BT[340] BT[341] BT[342] BT[343] BT[344] BT[345]
+   BT[346] BT[347] BT[348] BT[349] BT[350] BT[351] BT[352] BT[353] BT[354]
+   BT[355] BT[356] BT[357] BT[358] BT[359] BT[360] BT[361] BT[362] BT[363]
+   BT[364] BT[365] BT[366] BT[367] BT[368] BT[369] BT[370] BT[371] BT[372]
+   BT[373] BT[374] BT[375] BT[376] BT[377] BT[378] BT[379] BT[380] BT[381]
+   BT[382] BT[383] BYP_VLOAD[2] CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT
+   FLOATT FLOAT_RET LBKADR0 LBKADR1 LCGTH[2] LCGTH[3] LCGTH_PCHG[1] LDFTX
+   LITESLP LMATCH[3] LMATCHB LOG0 LOG1 LWEIB LWERD[1] LWEWR[1] LXADR[0]
+   LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+   LYADR[1] B[2] PBB[17] PBB[18] PBB[19] PBB[20] PBB[21] PBB[22] PBB[23] C[2]
+   PCB[17] PCB[18] PCB[19] PCB[20] PCB[21] PCB[22] PCB[23] PM[4] PM[5] PM[6]
+   PM[7] PRCKE_B[1] PWDO[0] PWDO[1] QB[32] QB[33] QB[34] QB[35] QB[36] QB[37]
+   QB[38] QB[39] QB[40] QB[41] QB[42] QB[43] QB[44] QB[45] QB[46] QB[47] QB[48]
+   QB[49] QB[50] QB[51] QB[52] QB[53] QB[54] QB[55] QB[56] QB[57] QB[58] QB[59]
+   QB[60] QB[61] QB[62] QB[63] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38]
+   QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49]
+   QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60]
+   QT[61] QT[62] QT[63] RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3]
+   RASSISTBH[4] RASSISTBH[5] RASSISTBL[4] RASSISTBL[5] RB[32] RB[33] RB[34]
+   RB[35] RB[36] RB[37] RB[38] RB[39] RB[40] RB[41] RB[42] RB[43] RB[44] RB[45]
+   RB[46] RB[47] RB[48] RB[49] RB[50] RB[51] RB[52] RB[53] RB[54] RB[55] RB[56]
+   RB[57] RB[58] RB[59] RB[60] RB[61] RB[62] RB[63] RBLRD[2] RBLWA[4] RBLWR[2]
+   RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RT[32] RT[33] RT[34] RT[35] RT[36] RT[37]
+   RT[38] RT[39] RT[40] RT[41] RT[42] RT[43] RT[44] RT[45] RT[46] RT[47] RT[48]
+   RT[49] RT[50] RT[51] RT[52] RT[53] RT[54] RT[55] RT[56] RT[57] RT[58] RT[59]
+   RT[60] RT[61] RT[62] RT[63] RWLB_SAC[1] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14]
+   SEL[15] SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21] SEL[22] SEL[23]
+   SEL[24] SEL[25] SEL[26] SEL[27] SEL[28] SEL[29] SEL[30] SEL[31] T1T
+   TEST_RNMB VBA VBN VBP VDDA VDDAIL1[2] VDDAIR1[2] VDDMINB VDDP VDDPI VDDWL[4]
+   VDDWL[5] VEDGE[0] VEDGE[1] VSS VSSC_WL_L[2] VSSC_WL_R[2] WABUF[0] WABUF[1]
+   WABUF[2] WB[32] WB[33] WB[34] WB[35] WB[36] WB[37] WB[38] WB[39] WB[40]
+   WB[41] WB[42] WB[43] WB[44] WB[45] WB[46] WB[47] WB[48] WB[49] WB[50] WB[51]
+   WB[52] WB[53] WB[54] WB[55] WB[56] WB[57] WB[58] WB[59] WB[60] WB[61] WB[62]
+   WB[63] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6]
+   WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14]
+   WB_IN[15] WB_IN[16] WB_IN[17] WB_IN[18] WB_IN[19] WB_IN[20] WB_IN[21]
+   WB_IN[22] WB_IN[23] WB_IN[24] WB_IN[25] WB_IN[26] WB_IN[27] WB_IN[28]
+   WB_IN[29] WB_IN[30] WB_IN[31] WCLKB[8] WCLKB[9] WCLKB[10] WCLKB[11] WMT[0]
+   WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT[32] WT[33] WT[34] WT[35]
+   WT[36] WT[37] WT[38] WT[39] WT[40] WT[41] WT[42] WT[43] WT[44] WT[45] WT[46]
+   WT[47] WT[48] WT[49] WT[50] WT[51] WT[52] WT[53] WT[54] WT[55] WT[56] WT[57]
+   WT[58] WT[59] WT[60] WT[61] WT[62] WT[63] WT_IN[0] WT_IN[1] WT_IN[2]
+   WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10]
+   WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15] WT_IN[16] WT_IN[17]
+   WT_IN[18] WT_IN[19] WT_IN[20] WT_IN[21] WT_IN[22] WT_IN[23] WT_IN[24]
+   WT_IN[25] WT_IN[26] WT_IN[27] WT_IN[28] WT_IN[29] WT_IN[30] WT_IN[31]
+   SNPS_SP_HD_16Kx8_mux_row_b_mx
X_sacwa_row_F0 ARYSD[6] ARYSD[7] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+   ARYSD_BC2[1] CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET
+   LBKADR0 LBKADR1 LBKADR2[2] LCGTH[2] LCGTH[3] LCGTH_PCHG[1] LDFTX LITESLP
+   LMATCHB LOG0 LOG0 LOG0 LOG1 LOG1 LOG1 LWEIB LWERD[1] LWEWR[1] LXADR[0]
+   LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+   LYADR[1] PM[4] PM[5] PM[6] PM[7] PRCKE_B[1] PWDO[0] PWDO[1] QB[32] QB[33]
+   QB[34] QB[35] QB[36] QB[37] QB[38] QB[39] QB[40] QB[41] QB[42] QB[43] QB[44]
+   QB[45] QB[46] QB[47] QB[48] QB[49] QB[50] QB[51] QB[52] QB[53] QB[54] QB[55]
+   QB[56] QB[57] QB[58] QB[59] QB[60] QB[61] QB[62] QB[63] QT[32] QT[33] QT[34]
+   QT[35] QT[36] QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45]
+   QT[46] QT[47] QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56]
+   QT[57] QT[58] QT[59] QT[60] QT[61] QT[62] QT[63] RASSIST[0] RASSIST[1]
+   RASSIST[2] RASSIST[3] RB[32] RB[33] RB[34] RB[35] RB[36] RB[37] RB[38]
+   RB[39] RB[40] RB[41] RB[42] RB[43] RB[44] RB[45] RB[46] RB[47] RB[48] RB[49]
+   RB[50] RB[51] RB[52] RB[53] RB[54] RB[55] RB[56] RB[57] RB[58] RB[59] RB[60]
+   RB[61] RB[62] RB[63] RBLWA[5] RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RT[32]
+   RT[33] RT[34] RT[35] RT[36] RT[37] RT[38] RT[39] RT[40] RT[41] RT[42] RT[43]
+   RT[44] RT[45] RT[46] RT[47] RT[48] RT[49] RT[50] RT[51] RT[52] RT[53] RT[54]
+   RT[55] RT[56] RT[57] RT[58] RT[59] RT[60] RT[61] RT[62] RT[63] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] SEL[16] SEL[17] SEL[18] SEL[19] SEL[20]
+   SEL[21] SEL[22] SEL[23] SEL[24] SEL[25] SEL[26] SEL[27] SEL[28] SEL[29]
+   SEL[30] SEL[31] T1T TEST_RNMB VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VDDA VDDA VDDA VDDMINB VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VEDGE[0] VEDGE[1] VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS_WA[32] VSS_WA[33] VSS_WA[34] VSS_WA[35] VSS_WA[36]
+   VSS_WA[37] VSS_WA[38] VSS_WA[39] VSS_WA[40] VSS_WA[41] VSS_WA[42] VSS_WA[43]
+   VSS_WA[44] VSS_WA[45] VSS_WA[46] VSS_WA[47] VSS_WA[48] VSS_WA[49] VSS_WA[50]
+   VSS_WA[51] VSS_WA[52] VSS_WA[53] VSS_WA[54] VSS_WA[55] VSS_WA[56] VSS_WA[57]
+   VSS_WA[58] VSS_WA[59] VSS_WA[60] VSS_WA[61] VSS_WA[62] VSS_WA[63] WABUF[0]
+   WABUF[1] WABUF[2] WAPRCLKBUFB_RET[1] WB[32] WB[33] WB[34] WB[35] WB[36]
+   WB[37] WB[38] WB[39] WB[40] WB[41] WB[42] WB[43] WB[44] WB[45] WB[46] WB[47]
+   WB[48] WB[49] WB[50] WB[51] WB[52] WB[53] WB[54] WB[55] WB[56] WB[57] WB[58]
+   WB[59] WB[60] WB[61] WB[62] WB[63] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3]
+   WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11]
+   WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WB_IN[16] WB_IN[17] WB_IN[18]
+   WB_IN[19] WB_IN[20] WB_IN[21] WB_IN[22] WB_IN[23] WB_IN[24] WB_IN[25]
+   WB_IN[26] WB_IN[27] WB_IN[28] WB_IN[29] WB_IN[30] WB_IN[31] WMT[0] WMT[1]
+   WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT[32] WT[33] WT[34] WT[35] WT[36]
+   WT[37] WT[38] WT[39] WT[40] WT[41] WT[42] WT[43] WT[44] WT[45] WT[46] WT[47]
+   WT[48] WT[49] WT[50] WT[51] WT[52] WT[53] WT[54] WT[55] WT[56] WT[57] WT[58]
+   WT[59] WT[60] WT[61] WT[62] WT[63] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3]
+   WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11]
+   WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15] WT_IN[16] WT_IN[17] WT_IN[18]
+   WT_IN[19] WT_IN[20] WT_IN[21] WT_IN[22] WT_IN[23] WT_IN[24] WT_IN[25]
+   WT_IN[26] WT_IN[27] WT_IN[28] WT_IN[29] WT_IN[30] WT_IN[31]
+   SNPS_SP_HD_16Kx8_sacwa_row
X_sac_row_4 ARYSD[6] ARYSD[7] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+   ARYSD_BC2[1] BYP_VLOAD[3] CENDP DEF_MODE LOG0 FAST1B[1] FAST1_MODE
+   FAST2_MODE FLOAT FLOATT LOG1 FLOAT_RET FLOAT_RET LBKADR0 LBKADR1 LCGTH[2]
+   LCGTH[3] LCGTH_PCHG[1] LDFTX LITESLP LLBKADRB[9] LLBKADRB[10] LLBKADRB[11]
+   LLBKADRT[3] LLBKADRT[4] LLBKADRT[5] LMATCH[4] LMATCHB LOG1 LOG1 LOG0 LOG1
+   LWEIB LWERD[1] LWEWR[1] LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+   LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] LBKADR0 LBKADR1 LLBKADRB[11]
+   LLBKADRB[9] PM[4] PM[5] PM[6] PM[7] PRCKE_B[1] PRCKE_T[1] FLOAT_RET PWDO[0]
+   PWDO[1] QB[32] QB[33] QB[34] QB[35] QB[36] QB[37] QB[38] QB[39] QB[40]
+   QB[41] QB[42] QB[43] QB[44] QB[45] QB[46] QB[47] QB[48] QB[49] QB[50] QB[51]
+   QB[52] QB[53] QB[54] QB[55] QB[56] QB[57] QB[58] QB[59] QB[60] QB[61] QB[62]
+   QB[63] QB[64] QB[65] QB[66] QB[67] QB[68] QB[69] QB[70] QB[71] QB[72] QB[73]
+   QB[74] QB[75] QB[76] QB[77] QB[78] QB[79] QB[80] QB[81] QB[82] QB[83] QB[84]
+   QB[85] QB[86] QB[87] QB[88] QB[89] QB[90] QB[91] QB[92] QB[93] QB[94] QB[95]
+   LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1
+   LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1
+   LOG1 LOG1 QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38] QT[39] QT[40]
+   QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49] QT[50] QT[51]
+   QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60] QT[61] QT[62]
+   QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70] QT[71] QT[72] QT[73]
+   QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80] QT[81] QT[82] QT[83] QT[84]
+   QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91] QT[92] QT[93] QT[94] QT[95]
+   LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1
+   LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1
+   LOG1 LOG1 RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RB[32] RB[33] RB[34]
+   RB[35] RB[36] RB[37] RB[38] RB[39] RB[40] RB[41] RB[42] RB[43] RB[44] RB[45]
+   RB[46] RB[47] RB[48] RB[49] RB[50] RB[51] RB[52] RB[53] RB[54] RB[55] RB[56]
+   RB[57] RB[58] RB[59] RB[60] RB[61] RB[62] RB[63] RBLRD[3] RBLWA[5] RBLWR[3]
+   RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RT[32] RT[33] RT[34] RT[35] RT[36] RT[37]
+   RT[38] RT[39] RT[40] RT[41] RT[42] RT[43] RT[44] RT[45] RT[46] RT[47] RT[48]
+   RT[49] RT[50] RT[51] RT[52] RT[53] RT[54] RT[55] RT[56] RT[57] RT[58] RT[59]
+   RT[60] RT[61] RT[62] RT[63] RWLB_SAC[2] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14]
+   SEL[15] SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21] SEL[22] SEL[23]
+   SEL[24] SEL[25] SEL[26] SEL[27] SEL[28] SEL[29] SEL[30] SEL[31] T1T
+   TEST_RNMB VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VDDA VDDA VDDA VDDMINB VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VEDGE[0]
+   VEDGE[1] VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS_WA[32] VSS_WA[33] VSS_WA[34] VSS_WA[35] VSS_WA[36] VSS_WA[37]
+   VSS_WA[38] VSS_WA[39] VSS_WA[40] VSS_WA[41] VSS_WA[42] VSS_WA[43] VSS_WA[44]
+   VSS_WA[45] VSS_WA[46] VSS_WA[47] VSS_WA[48] VSS_WA[49] VSS_WA[50] VSS_WA[51]
+   VSS_WA[52] VSS_WA[53] VSS_WA[54] VSS_WA[55] VSS_WA[56] VSS_WA[57] VSS_WA[58]
+   VSS_WA[59] VSS_WA[60] VSS_WA[61] VSS_WA[62] VSS_WA[63] WABUF[0] WABUF[1]
+   WABUF[2] WAPRCLKBUFB_RET[1] WB[32] WB[33] WB[34] WB[35] WB[36] WB[37] WB[38]
+   WB[39] WB[40] WB[41] WB[42] WB[43] WB[44] WB[45] WB[46] WB[47] WB[48] WB[49]
+   WB[50] WB[51] WB[52] WB[53] WB[54] WB[55] WB[56] WB[57] WB[58] WB[59] WB[60]
+   WB[61] WB[62] WB[63] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5]
+   WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13]
+   WB_IN[14] WB_IN[15] WB_IN[16] WB_IN[17] WB_IN[18] WB_IN[19] WB_IN[20]
+   WB_IN[21] WB_IN[22] WB_IN[23] WB_IN[24] WB_IN[25] WB_IN[26] WB_IN[27]
+   WB_IN[28] WB_IN[29] WB_IN[30] WB_IN[31] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0]
+   WPBUF[1] WPBUF[2] WT[32] WT[33] WT[34] WT[35] WT[36] WT[37] WT[38] WT[39]
+   WT[40] WT[41] WT[42] WT[43] WT[44] WT[45] WT[46] WT[47] WT[48] WT[49] WT[50]
+   WT[51] WT[52] WT[53] WT[54] WT[55] WT[56] WT[57] WT[58] WT[59] WT[60] WT[61]
+   WT[62] WT[63] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6]
+   WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14]
+   WT_IN[15] WT_IN[16] WT_IN[17] WT_IN[18] WT_IN[19] WT_IN[20] WT_IN[21]
+   WT_IN[22] WT_IN[23] WT_IN[24] WT_IN[25] WT_IN[26] WT_IN[27] WT_IN[28]
+   WT_IN[29] WT_IN[30] WT_IN[31] SNPS_SP_HD_16Kx8_sac_row_4
X_mux_row_4 ARYSD[6] ARYSD[7] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+   ARYSD_BC2[1] BB[384] BB[385] BB[386] BB[387] BB[388] BB[389] BB[390] BB[391]
+   BB[392] BB[393] BB[394] BB[395] BB[396] BB[397] BB[398] BB[399] BB[400]
+   BB[401] BB[402] BB[403] BB[404] BB[405] BB[406] BB[407] BB[408] BB[409]
+   BB[410] BB[411] BB[412] BB[413] BB[414] BB[415] BB[416] BB[417] BB[418]
+   BB[419] BB[420] BB[421] BB[422] BB[423] BB[424] BB[425] BB[426] BB[427]
+   BB[428] BB[429] BB[430] BB[431] BB[432] BB[433] BB[434] BB[435] BB[436]
+   BB[437] BB[438] BB[439] BB[440] BB[441] BB[442] BB[443] BB[444] BB[445]
+   BB[446] BB[447] BB[448] BB[449] BB[450] BB[451] BB[452] BB[453] BB[454]
+   BB[455] BB[456] BB[457] BB[458] BB[459] BB[460] BB[461] BB[462] BB[463]
+   BB[464] BB[465] BB[466] BB[467] BB[468] BB[469] BB[470] BB[471] BB[472]
+   BB[473] BB[474] BB[475] BB[476] BB[477] BB[478] BB[479] BB[480] BB[481]
+   BB[482] BB[483] BB[484] BB[485] BB[486] BB[487] BB[488] BB[489] BB[490]
+   BB[491] BB[492] BB[493] BB[494] BB[495] BB[496] BB[497] BB[498] BB[499]
+   BB[500] BB[501] BB[502] BB[503] BB[504] BB[505] BB[506] BB[507] BB[508]
+   BB[509] BB[510] BB[511] BOTEDGE[12] BOTEDGE[13] BOTEDGE[14] BOTEDGE[15]
+   BT[384] BT[385] BT[386] BT[387] BT[388] BT[389] BT[390] BT[391] BT[392]
+   BT[393] BT[394] BT[395] BT[396] BT[397] BT[398] BT[399] BT[400] BT[401]
+   BT[402] BT[403] BT[404] BT[405] BT[406] BT[407] BT[408] BT[409] BT[410]
+   BT[411] BT[412] BT[413] BT[414] BT[415] BT[416] BT[417] BT[418] BT[419]
+   BT[420] BT[421] BT[422] BT[423] BT[424] BT[425] BT[426] BT[427] BT[428]
+   BT[429] BT[430] BT[431] BT[432] BT[433] BT[434] BT[435] BT[436] BT[437]
+   BT[438] BT[439] BT[440] BT[441] BT[442] BT[443] BT[444] BT[445] BT[446]
+   BT[447] BT[448] BT[449] BT[450] BT[451] BT[452] BT[453] BT[454] BT[455]
+   BT[456] BT[457] BT[458] BT[459] BT[460] BT[461] BT[462] BT[463] BT[464]
+   BT[465] BT[466] BT[467] BT[468] BT[469] BT[470] BT[471] BT[472] BT[473]
+   BT[474] BT[475] BT[476] BT[477] BT[478] BT[479] BT[480] BT[481] BT[482]
+   BT[483] BT[484] BT[485] BT[486] BT[487] BT[488] BT[489] BT[490] BT[491]
+   BT[492] BT[493] BT[494] BT[495] BT[496] BT[497] BT[498] BT[499] BT[500]
+   BT[501] BT[502] BT[503] BT[504] BT[505] BT[506] BT[507] BT[508] BT[509]
+   BT[510] BT[511] BYP_VLOAD[3] CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT
+   FLOATT FLOAT_RET LBKADR0 LBKADR1 LCGTH[2] LCGTH[3] LCGTH_PCHG[1] LDFTX
+   LITESLP LMATCH[5] LMATCHB LOG0 LOG1 LWEIB LWERD[1] LWEWR[1] LXADR[0]
+   LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+   LYADR[1] B[3] PBB[25] PBB[26] PBB[27] PBB[28] PBB[29] PBB[30] PBB[31] C[3]
+   PCB[25] PCB[26] PCB[27] PCB[28] PCB[29] PCB[30] PCB[31] PWDO[0] PWDO[1]
+   PM[4] PM[5] PM[6] PM[7] PRCKE_T[1] QB[64] QB[65] QB[66] QB[67] QB[68] QB[69]
+   QB[70] QB[71] QB[72] QB[73] QB[74] QB[75] QB[76] QB[77] QB[78] QB[79] QB[80]
+   QB[81] QB[82] QB[83] QB[84] QB[85] QB[86] QB[87] QB[88] QB[89] QB[90] QB[91]
+   QB[92] QB[93] QB[94] QB[95] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70]
+   QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80] QT[81]
+   QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91] QT[92]
+   QT[93] QT[94] QT[95] RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3]
+   RASSISTBH[6] RASSISTBH[7] RASSISTBL[6] RASSISTBL[7] RB[32] RB[33] RB[34]
+   RB[35] RB[36] RB[37] RB[38] RB[39] RB[40] RB[41] RB[42] RB[43] RB[44] RB[45]
+   RB[46] RB[47] RB[48] RB[49] RB[50] RB[51] RB[52] RB[53] RB[54] RB[55] RB[56]
+   RB[57] RB[58] RB[59] RB[60] RB[61] RB[62] RB[63] RBLRD[3] RBLWA[5] RBLWR[3]
+   RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RT[32] RT[33] RT[34] RT[35] RT[36] RT[37]
+   RT[38] RT[39] RT[40] RT[41] RT[42] RT[43] RT[44] RT[45] RT[46] RT[47] RT[48]
+   RT[49] RT[50] RT[51] RT[52] RT[53] RT[54] RT[55] RT[56] RT[57] RT[58] RT[59]
+   RT[60] RT[61] RT[62] RT[63] RWLB_SAC[2] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14]
+   SEL[15] SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21] SEL[22] SEL[23]
+   SEL[24] SEL[25] SEL[26] SEL[27] SEL[28] SEL[29] SEL[30] SEL[31] T1T
+   TEST_RNMB VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA
+   VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA
+   VBA VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDAIL1[3] VDDAIR1[3] VDDMINB VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDWL[6] VDDWL[7] VEDGE[0] VEDGE[1] VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSSC_WL_L[3]
+   VSSC_WL_R[3] WABUF[0] WABUF[1] WABUF[2] WB[32] WB[33] WB[34] WB[35] WB[36]
+   WB[37] WB[38] WB[39] WB[40] WB[41] WB[42] WB[43] WB[44] WB[45] WB[46] WB[47]
+   WB[48] WB[49] WB[50] WB[51] WB[52] WB[53] WB[54] WB[55] WB[56] WB[57] WB[58]
+   WB[59] WB[60] WB[61] WB[62] WB[63] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3]
+   WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11]
+   WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WB_IN[16] WB_IN[17] WB_IN[18]
+   WB_IN[19] WB_IN[20] WB_IN[21] WB_IN[22] WB_IN[23] WB_IN[24] WB_IN[25]
+   WB_IN[26] WB_IN[27] WB_IN[28] WB_IN[29] WB_IN[30] WB_IN[31] WCLKB[12]
+   WCLKB[13] WCLKB[14] WCLKB[15] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] WT[32] WT[33] WT[34] WT[35] WT[36] WT[37] WT[38] WT[39] WT[40]
+   WT[41] WT[42] WT[43] WT[44] WT[45] WT[46] WT[47] WT[48] WT[49] WT[50] WT[51]
+   WT[52] WT[53] WT[54] WT[55] WT[56] WT[57] WT[58] WT[59] WT[60] WT[61] WT[62]
+   WT[63] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6]
+   WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14]
+   WT_IN[15] WT_IN[16] WT_IN[17] WT_IN[18] WT_IN[19] WT_IN[20] WT_IN[21]
+   WT_IN[22] WT_IN[23] WT_IN[24] WT_IN[25] WT_IN[26] WT_IN[27] WT_IN[28]
+   WT_IN[29] WT_IN[30] WT_IN[31] SNPS_SP_HD_16Kx8_mux_row_4
X_ary_row_mx_2_F0 ARYSD[6] ARYSD[7] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+   ARYSD_BC2[1] B[3] BB[384] BB[385] BB[386] BB[387] BB[388] BB[389] BB[390]
+   BB[391] BB[392] BB[393] BB[394] BB[395] BB[396] BB[397] BB[398] BB[399]
+   BB[400] BB[401] BB[402] BB[403] BB[404] BB[405] BB[406] BB[407] BB[408]
+   BB[409] BB[410] BB[411] BB[412] BB[413] BB[414] BB[415] BB[416] BB[417]
+   BB[418] BB[419] BB[420] BB[421] BB[422] BB[423] BB[424] BB[425] BB[426]
+   BB[427] BB[428] BB[429] BB[430] BB[431] BB[432] BB[433] BB[434] BB[435]
+   BB[436] BB[437] BB[438] BB[439] BB[440] BB[441] BB[442] BB[443] BB[444]
+   BB[445] BB[446] BB[447] BB[448] BB[449] BB[450] BB[451] BB[452] BB[453]
+   BB[454] BB[455] BB[456] BB[457] BB[458] BB[459] BB[460] BB[461] BB[462]
+   BB[463] BB[464] BB[465] BB[466] BB[467] BB[468] BB[469] BB[470] BB[471]
+   BB[472] BB[473] BB[474] BB[475] BB[476] BB[477] BB[478] BB[479] BB[480]
+   BB[481] BB[482] BB[483] BB[484] BB[485] BB[486] BB[487] BB[488] BB[489]
+   BB[490] BB[491] BB[492] BB[493] BB[494] BB[495] BB[496] BB[497] BB[498]
+   BB[499] BB[500] BB[501] BB[502] BB[503] BB[504] BB[505] BB[506] BB[507]
+   BB[508] BB[509] BB[510] BB[511] BT[384] BT[385] BT[386] BT[387] BT[388]
+   BT[389] BT[390] BT[391] BT[392] BT[393] BT[394] BT[395] BT[396] BT[397]
+   BT[398] BT[399] BT[400] BT[401] BT[402] BT[403] BT[404] BT[405] BT[406]
+   BT[407] BT[408] BT[409] BT[410] BT[411] BT[412] BT[413] BT[414] BT[415]
+   BT[416] BT[417] BT[418] BT[419] BT[420] BT[421] BT[422] BT[423] BT[424]
+   BT[425] BT[426] BT[427] BT[428] BT[429] BT[430] BT[431] BT[432] BT[433]
+   BT[434] BT[435] BT[436] BT[437] BT[438] BT[439] BT[440] BT[441] BT[442]
+   BT[443] BT[444] BT[445] BT[446] BT[447] BT[448] BT[449] BT[450] BT[451]
+   BT[452] BT[453] BT[454] BT[455] BT[456] BT[457] BT[458] BT[459] BT[460]
+   BT[461] BT[462] BT[463] BT[464] BT[465] BT[466] BT[467] BT[468] BT[469]
+   BT[470] BT[471] BT[472] BT[473] BT[474] BT[475] BT[476] BT[477] BT[478]
+   BT[479] BT[480] BT[481] BT[482] BT[483] BT[484] BT[485] BT[486] BT[487]
+   BT[488] BT[489] BT[490] BT[491] BT[492] BT[493] BT[494] BT[495] BT[496]
+   BT[497] BT[498] BT[499] BT[500] BT[501] BT[502] BT[503] BT[504] BT[505]
+   BT[506] BT[507] BT[508] BT[509] BT[510] BT[511] BYP_VLOAD[3] C[3] CENDP
+   DEF_MODE EDGEB[12] EDGEB[13] EDGEB[14] EDGEB[15] EDGET[12] EDGET[13]
+   EDGET[14] EDGET[15] FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LBKADR0
+   LBKADR1 LCGTH[2] LCGTH[3] LDFTX LITESLP LMATCH[5] LMATCHB LOG0 LOG1 LWEIB
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] B[3] PBB[25] PBB[26] PBB[27] PBB[28] PBB[29] PBB[30]
+   PBB[31] C[3] PCB[25] PCB[26] PCB[27] PCB[28] PCB[29] PCB[30] PCB[31] PWDO[0]
+   PWDO[1] QB[64] QB[65] QB[66] QB[67] QB[68] QB[69] QB[70] QB[71] QB[72]
+   QB[73] QB[74] QB[75] QB[76] QB[77] QB[78] QB[79] QB[80] QB[81] QB[82] QB[83]
+   QB[84] QB[85] QB[86] QB[87] QB[88] QB[89] QB[90] QB[91] QB[92] QB[93] QB[94]
+   QB[95] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70] QT[71] QT[72] QT[73]
+   QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80] QT[81] QT[82] QT[83] QT[84]
+   QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91] QT[92] QT[93] QT[94] QT[95]
+   RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RASSISTBH[6] RASSISTBH[7]
+   RASSISTBL[6] RASSISTBL[7] RBLRD[3] RBLWA[5] RBLWR[3] RBLWR_LOAD[3] RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC[2] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14]
+   SEL[15] SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21] SEL[22] SEL[23]
+   SEL[24] SEL[25] SEL[26] SEL[27] SEL[28] SEL[29] SEL[30] SEL[31] T1T
+   TEST_RNMB VBA VBN VBP VDDA VDDAIL1[3] VDDAIR1[3] VDDMINB VDDP VDDPI VDDWL[6]
+   VDDWL[7] VEDGE[0] VEDGE[1] VSS VSSC_WL_L[3] VSSC_WL_R[3] WABUF[0] WABUF[1]
+   WABUF[2] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6]
+   WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14]
+   WB_IN[15] WB_IN[16] WB_IN[17] WB_IN[18] WB_IN[19] WB_IN[20] WB_IN[21]
+   WB_IN[22] WB_IN[23] WB_IN[24] WB_IN[25] WB_IN[26] WB_IN[27] WB_IN[28]
+   WB_IN[29] WB_IN[30] WB_IN[31] WCLKB[12] WCLKB[13] WCLKB[14] WCLKB[15]
+   WLH[768] WLH[769] WLH[770] WLH[771] WLH[772] WLH[773] WLH[774] WLH[775]
+   WLH[776] WLH[777] WLH[778] WLH[779] WLH[780] WLH[781] WLH[782] WLH[783]
+   WLH[784] WLH[785] WLH[786] WLH[787] WLH[788] WLH[789] WLH[790] WLH[791]
+   WLH[792] WLH[793] WLH[794] WLH[795] WLH[796] WLH[797] WLH[798] WLH[799]
+   WLH[800] WLH[801] WLH[802] WLH[803] WLH[804] WLH[805] WLH[806] WLH[807]
+   WLH[808] WLH[809] WLH[810] WLH[811] WLH[812] WLH[813] WLH[814] WLH[815]
+   WLH[816] WLH[817] WLH[818] WLH[819] WLH[820] WLH[821] WLH[822] WLH[823]
+   WLH[824] WLH[825] WLH[826] WLH[827] WLH[828] WLH[829] WLH[830] WLH[831]
+   WLH[832] WLH[833] WLH[834] WLH[835] WLH[836] WLH[837] WLH[838] WLH[839]
+   WLH[840] WLH[841] WLH[842] WLH[843] WLH[844] WLH[845] WLH[846] WLH[847]
+   WLH[848] WLH[849] WLH[850] WLH[851] WLH[852] WLH[853] WLH[854] WLH[855]
+   WLH[856] WLH[857] WLH[858] WLH[859] WLH[860] WLH[861] WLH[862] WLH[863]
+   WLH[864] WLH[865] WLH[866] WLH[867] WLH[868] WLH[869] WLH[870] WLH[871]
+   WLH[872] WLH[873] WLH[874] WLH[875] WLH[876] WLH[877] WLH[878] WLH[879]
+   WLH[880] WLH[881] WLH[882] WLH[883] WLH[884] WLH[885] WLH[886] WLH[887]
+   WLH[888] WLH[889] WLH[890] WLH[891] WLH[892] WLH[893] WLH[894] WLH[895]
+   WLH[896] WLH[897] WLH[898] WLH[899] WLH[900] WLH[901] WLH[902] WLH[903]
+   WLH[904] WLH[905] WLH[906] WLH[907] WLH[908] WLH[909] WLH[910] WLH[911]
+   WLH[912] WLH[913] WLH[914] WLH[915] WLH[916] WLH[917] WLH[918] WLH[919]
+   WLH[920] WLH[921] WLH[922] WLH[923] WLH[924] WLH[925] WLH[926] WLH[927]
+   WLH[928] WLH[929] WLH[930] WLH[931] WLH[932] WLH[933] WLH[934] WLH[935]
+   WLH[936] WLH[937] WLH[938] WLH[939] WLH[940] WLH[941] WLH[942] WLH[943]
+   WLH[944] WLH[945] WLH[946] WLH[947] WLH[948] WLH[949] WLH[950] WLH[951]
+   WLH[952] WLH[953] WLH[954] WLH[955] WLH[956] WLH[957] WLH[958] WLH[959]
+   WLH[960] WLH[961] WLH[962] WLH[963] WLH[964] WLH[965] WLH[966] WLH[967]
+   WLH[968] WLH[969] WLH[970] WLH[971] WLH[972] WLH[973] WLH[974] WLH[975]
+   WLH[976] WLH[977] WLH[978] WLH[979] WLH[980] WLH[981] WLH[982] WLH[983]
+   WLH[984] WLH[985] WLH[986] WLH[987] WLH[988] WLH[989] WLH[990] WLH[991]
+   WLH[992] WLH[993] WLH[994] WLH[995] WLH[996] WLH[997] WLH[998] WLH[999]
+   WLH[1000] WLH[1001] WLH[1002] WLH[1003] WLH[1004] WLH[1005] WLH[1006]
+   WLH[1007] WLH[1008] WLH[1009] WLH[1010] WLH[1011] WLH[1012] WLH[1013]
+   WLH[1014] WLH[1015] WLH[1016] WLH[1017] WLH[1018] WLH[1019] WLH[1020]
+   WLH[1021] WLH[1022] WLH[1023] WLL[768] WLL[769] WLL[770] WLL[771] WLL[772]
+   WLL[773] WLL[774] WLL[775] WLL[776] WLL[777] WLL[778] WLL[779] WLL[780]
+   WLL[781] WLL[782] WLL[783] WLL[784] WLL[785] WLL[786] WLL[787] WLL[788]
+   WLL[789] WLL[790] WLL[791] WLL[792] WLL[793] WLL[794] WLL[795] WLL[796]
+   WLL[797] WLL[798] WLL[799] WLL[800] WLL[801] WLL[802] WLL[803] WLL[804]
+   WLL[805] WLL[806] WLL[807] WLL[808] WLL[809] WLL[810] WLL[811] WLL[812]
+   WLL[813] WLL[814] WLL[815] WLL[816] WLL[817] WLL[818] WLL[819] WLL[820]
+   WLL[821] WLL[822] WLL[823] WLL[824] WLL[825] WLL[826] WLL[827] WLL[828]
+   WLL[829] WLL[830] WLL[831] WLL[832] WLL[833] WLL[834] WLL[835] WLL[836]
+   WLL[837] WLL[838] WLL[839] WLL[840] WLL[841] WLL[842] WLL[843] WLL[844]
+   WLL[845] WLL[846] WLL[847] WLL[848] WLL[849] WLL[850] WLL[851] WLL[852]
+   WLL[853] WLL[854] WLL[855] WLL[856] WLL[857] WLL[858] WLL[859] WLL[860]
+   WLL[861] WLL[862] WLL[863] WLL[864] WLL[865] WLL[866] WLL[867] WLL[868]
+   WLL[869] WLL[870] WLL[871] WLL[872] WLL[873] WLL[874] WLL[875] WLL[876]
+   WLL[877] WLL[878] WLL[879] WLL[880] WLL[881] WLL[882] WLL[883] WLL[884]
+   WLL[885] WLL[886] WLL[887] WLL[888] WLL[889] WLL[890] WLL[891] WLL[892]
+   WLL[893] WLL[894] WLL[895] WLL[896] WLL[897] WLL[898] WLL[899] WLL[900]
+   WLL[901] WLL[902] WLL[903] WLL[904] WLL[905] WLL[906] WLL[907] WLL[908]
+   WLL[909] WLL[910] WLL[911] WLL[912] WLL[913] WLL[914] WLL[915] WLL[916]
+   WLL[917] WLL[918] WLL[919] WLL[920] WLL[921] WLL[922] WLL[923] WLL[924]
+   WLL[925] WLL[926] WLL[927] WLL[928] WLL[929] WLL[930] WLL[931] WLL[932]
+   WLL[933] WLL[934] WLL[935] WLL[936] WLL[937] WLL[938] WLL[939] WLL[940]
+   WLL[941] WLL[942] WLL[943] WLL[944] WLL[945] WLL[946] WLL[947] WLL[948]
+   WLL[949] WLL[950] WLL[951] WLL[952] WLL[953] WLL[954] WLL[955] WLL[956]
+   WLL[957] WLL[958] WLL[959] WLL[960] WLL[961] WLL[962] WLL[963] WLL[964]
+   WLL[965] WLL[966] WLL[967] WLL[968] WLL[969] WLL[970] WLL[971] WLL[972]
+   WLL[973] WLL[974] WLL[975] WLL[976] WLL[977] WLL[978] WLL[979] WLL[980]
+   WLL[981] WLL[982] WLL[983] WLL[984] WLL[985] WLL[986] WLL[987] WLL[988]
+   WLL[989] WLL[990] WLL[991] WLL[992] WLL[993] WLL[994] WLL[995] WLL[996]
+   WLL[997] WLL[998] WLL[999] WLL[1000] WLL[1001] WLL[1002] WLL[1003] WLL[1004]
+   WLL[1005] WLL[1006] WLL[1007] WLL[1008] WLL[1009] WLL[1010] WLL[1011]
+   WLL[1012] WLL[1013] WLL[1014] WLL[1015] WLL[1016] WLL[1017] WLL[1018]
+   WLL[1019] WLL[1020] WLL[1021] WLL[1022] WLL[1023] WMT[0] WMT[1] WMT[2]
+   WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3]
+   WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11]
+   WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15] WT_IN[16] WT_IN[17] WT_IN[18]
+   WT_IN[19] WT_IN[20] WT_IN[21] WT_IN[22] WT_IN[23] WT_IN[24] WT_IN[25]
+   WT_IN[26] WT_IN[27] WT_IN[28] WT_IN[29] WT_IN[30] WT_IN[31]
+   SNPS_SP_HD_16Kx8_ary_row_mx_2
X_ref_row_4 ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1] ARYSD[6]
+   ARYSD[7] ARYSD[8] ARYSD[9] BB[384] BB[385] BB[386] BB[387] BB[388] BB[389]
+   BB[390] BB[391] BB[392] BB[393] BB[394] BB[395] BB[396] BB[397] BB[398]
+   BB[399] BB[400] BB[401] BB[402] BB[403] BB[404] BB[405] BB[406] BB[407]
+   BB[408] BB[409] BB[410] BB[411] BB[412] BB[413] BB[414] BB[415] BB[416]
+   BB[417] BB[418] BB[419] BB[420] BB[421] BB[422] BB[423] BB[424] BB[425]
+   BB[426] BB[427] BB[428] BB[429] BB[430] BB[431] BB[432] BB[433] BB[434]
+   BB[435] BB[436] BB[437] BB[438] BB[439] BB[440] BB[441] BB[442] BB[443]
+   BB[444] BB[445] BB[446] BB[447] BB[448] BB[449] BB[450] BB[451] BB[452]
+   BB[453] BB[454] BB[455] BB[456] BB[457] BB[458] BB[459] BB[460] BB[461]
+   BB[462] BB[463] BB[464] BB[465] BB[466] BB[467] BB[468] BB[469] BB[470]
+   BB[471] BB[472] BB[473] BB[474] BB[475] BB[476] BB[477] BB[478] BB[479]
+   BB[480] BB[481] BB[482] BB[483] BB[484] BB[485] BB[486] BB[487] BB[488]
+   BB[489] BB[490] BB[491] BB[492] BB[493] BB[494] BB[495] BB[496] BB[497]
+   BB[498] BB[499] BB[500] BB[501] BB[502] BB[503] BB[504] BB[505] BB[506]
+   BB[507] BB[508] BB[509] BB[510] BB[511] CENDP DEF_MODE FAST1_MODE FAST2_MODE
+   FLOAT FLOATT FLOAT_RET FLOAT_RET_PROG[1] LBKADR0 LBKADR1 LCGTH[2] LCGTH[3]
+   LDFTX LITESLP LLBKADRB[12] LLBKADRB[13] LMATCHB LOG1 LOG0 LOG0 LOG1 LOG1
+   LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6]
+   LXADR[7] LYADR[0] LYADR[1] PWDO[0] PWDO[1] LBKADR1 LLBKADRB[13] QB[64]
+   QB[65] QB[66] QB[67] QB[68] QB[69] QB[70] QB[71] QB[72] QB[73] QB[74] QB[75]
+   QB[76] QB[77] QB[78] QB[79] QB[80] QB[81] QB[82] QB[83] QB[84] QB[85] QB[86]
+   QB[87] QB[88] QB[89] QB[90] QB[91] QB[92] QB[93] QB[94] QB[95] QT[64] QT[65]
+   QT[66] QT[67] QT[68] QT[69] QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76]
+   QT[77] QT[78] QT[79] QT[80] QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87]
+   QT[88] QT[89] QT[90] QT[91] QT[92] QT[93] QT[94] QT[95] RASSIST[0]
+   RASSIST[1] RASSIST[2] RASSIST[3] RASSISTBH[6] RASSISTBH[7] RASSISTBL[6]
+   RASSISTBL[7] RBLRD[3] RBLWA[5] RBLWR[3] RM3CNT RMT[0] RMT[1] RMT[2] RMT[3]
+   RWLB_SAC[2] RWL_DLY_0[1] RWL_DLY_2[1] RWL_DLY_4[1] RWL_DLY_0[1] RWL_DLY_0[1]
+   RWL_RWLD_AND[1] RWL_RWLD_AND_WR[1] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5]
+   SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15]
+   SEL[16] SEL[17] SEL[18] SEL[19] SEL[20] SEL[21] SEL[22] SEL[23] SEL[24]
+   SEL[25] SEL[26] SEL[27] SEL[28] SEL[29] SEL[30] SEL[31] T1T TEST_RNMB
+   TOPEDGE[8] TOPEDGE[9] TOPEDGE[10] TOPEDGE[11] VBA VBA VBA VBA VBA VBA VBA
+   VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA
+   VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VDDA VDDA VDDA VDDAIL1[3] VDDAIR1[3] VDDMINB
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDWL[6] VDDWL[7] VEDGE[0] VEDGE[1] VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSSC_WL_L[3] VSSC_WL_R[3] WABUF[0] WABUF[1] WABUF[2] WB_IN[0] WB_IN[1]
+   WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9]
+   WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WB_IN[16]
+   WB_IN[17] WB_IN[18] WB_IN[19] WB_IN[20] WB_IN[21] WB_IN[22] WB_IN[23]
+   WB_IN[24] WB_IN[25] WB_IN[26] WB_IN[27] WB_IN[28] WB_IN[29] WB_IN[30]
+   WB_IN[31] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT_IN[0]
+   WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8]
+   WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15]
+   WT_IN[16] WT_IN[17] WT_IN[18] WT_IN[19] WT_IN[20] WT_IN[21] WT_IN[22]
+   WT_IN[23] WT_IN[24] WT_IN[25] WT_IN[26] WT_IN[27] WT_IN[28] WT_IN[29]
+   WT_IN[30] WT_IN[31] SNPS_SP_HD_16Kx8_ref_row_4
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8_TOP_LAY ADR[0] ADR[1] ADR[2] ADR[3] ADR[4] ADR[5]
+       ADR[6] ADR[7] ADR[9] ADR[10] ADR[11] ADR[12] ADR[13] ADR[14] BC0 BC1 BC2
+       CLK D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] LS ME Q[0] Q[1] Q[2] Q[3]
+       Q[4] Q[5] Q[6] Q[7] RM[0] RM[1] RM[2] RM[3] RME TEST1 TEST_RNM VDD[0]
+       VNW_N VPW_P VSS WA[0] WA[1] WE WPULSE[0] WPULSE[1] WPULSE[2]
X_top ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1] BC0
+   BC1 BC2 LOG0 CLK D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] DEF_MODE DS
+   FAST1_MODE FAST2_MODE LOG0 FLOAT FLOATT FLOAT_RET LOG1 LBKADR0 LBKADR1 LOG0
+   LITESLP LOG1 LOG0 LOG1 LS LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+   LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] ME LOG1 LOG1 Q[0] Q[1] Q[2]
+   Q[3] Q[4] Q[5] Q[6] Q[7] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7]
+   QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QB[16] QB[17] QB[18]
+   QB[19] QB[20] QB[21] QB[22] QB[23] QB[24] QB[25] QB[26] QB[27] QB[28] QB[29]
+   QB[30] QB[31] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9]
+   QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17] QT[18] QT[19] QT[20]
+   QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28] QT[29] QT[30] QT[31]
+   LOG0 LOG0 RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RM[0] RM[1] RM[2]
+   RM[3] RM3CNT RME RMT[0] RMT[1] RMT[2] RMT[3] ROP RWLB_SAC RWL_RWLD_AND
+   RWL_RWLD_AND_WR LOG0 SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7]
+   SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] SEL[16]
+   SEL[17] SEL[18] SEL[19] SEL[20] SEL[21] SEL[22] SEL[23] SEL[24] SEL[25]
+   SEL[26] SEL[27] SEL[28] SEL[29] SEL[30] SEL[31] SO_D[0] SO_D[1] SO_Q[0]
+   SO_Q[1] T1T TEST1 TEST_RNM TEST_RNMB TOPEDGE[0] TOPEDGE[1] TOPEDGE[2]
+   TOPEDGE[3] VSS VNW_N VPW_P VDD[0] VDDMINB VDD[0] VDD[0] VEDGE[0] VEDGE[1]
+   VSS WA[0] WA[1] WABUF[0] WABUF[1] WABUF[2] WB_IN[0] WB_IN[1] WB_IN[2]
+   WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10]
+   WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WB_IN[16] WB_IN[17]
+   WB_IN[18] WB_IN[19] WB_IN[20] WB_IN[21] WB_IN[22] WB_IN[23] WB_IN[24]
+   WB_IN[25] WB_IN[26] WB_IN[27] WB_IN[28] WB_IN[29] WB_IN[30] WB_IN[31] WE
+   LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 WLH[0] WLH[1] WLH[2] WLH[3] WLH[4]
+   WLH[5] WLH[6] WLH[7] WLH[8] WLH[9] WLH[10] WLH[11] WLH[12] WLH[13] WLH[14]
+   WLH[15] WLH[16] WLH[17] WLH[18] WLH[19] WLH[20] WLH[21] WLH[22] WLH[23]
+   WLH[24] WLH[25] WLH[26] WLH[27] WLH[28] WLH[29] WLH[30] WLH[31] WLH[32]
+   WLH[33] WLH[34] WLH[35] WLH[36] WLH[37] WLH[38] WLH[39] WLH[40] WLH[41]
+   WLH[42] WLH[43] WLH[44] WLH[45] WLH[46] WLH[47] WLH[48] WLH[49] WLH[50]
+   WLH[51] WLH[52] WLH[53] WLH[54] WLH[55] WLH[56] WLH[57] WLH[58] WLH[59]
+   WLH[60] WLH[61] WLH[62] WLH[63] WLH[64] WLH[65] WLH[66] WLH[67] WLH[68]
+   WLH[69] WLH[70] WLH[71] WLH[72] WLH[73] WLH[74] WLH[75] WLH[76] WLH[77]
+   WLH[78] WLH[79] WLH[80] WLH[81] WLH[82] WLH[83] WLH[84] WLH[85] WLH[86]
+   WLH[87] WLH[88] WLH[89] WLH[90] WLH[91] WLH[92] WLH[93] WLH[94] WLH[95]
+   WLH[96] WLH[97] WLH[98] WLH[99] WLH[100] WLH[101] WLH[102] WLH[103] WLH[104]
+   WLH[105] WLH[106] WLH[107] WLH[108] WLH[109] WLH[110] WLH[111] WLH[112]
+   WLH[113] WLH[114] WLH[115] WLH[116] WLH[117] WLH[118] WLH[119] WLH[120]
+   WLH[121] WLH[122] WLH[123] WLH[124] WLH[125] WLH[126] WLH[127] WLH[128]
+   WLH[129] WLH[130] WLH[131] WLH[132] WLH[133] WLH[134] WLH[135] WLH[136]
+   WLH[137] WLH[138] WLH[139] WLH[140] WLH[141] WLH[142] WLH[143] WLH[144]
+   WLH[145] WLH[146] WLH[147] WLH[148] WLH[149] WLH[150] WLH[151] WLH[152]
+   WLH[153] WLH[154] WLH[155] WLH[156] WLH[157] WLH[158] WLH[159] WLH[160]
+   WLH[161] WLH[162] WLH[163] WLH[164] WLH[165] WLH[166] WLH[167] WLH[168]
+   WLH[169] WLH[170] WLH[171] WLH[172] WLH[173] WLH[174] WLH[175] WLH[176]
+   WLH[177] WLH[178] WLH[179] WLH[180] WLH[181] WLH[182] WLH[183] WLH[184]
+   WLH[185] WLH[186] WLH[187] WLH[188] WLH[189] WLH[190] WLH[191] WLH[192]
+   WLH[193] WLH[194] WLH[195] WLH[196] WLH[197] WLH[198] WLH[199] WLH[200]
+   WLH[201] WLH[202] WLH[203] WLH[204] WLH[205] WLH[206] WLH[207] WLH[208]
+   WLH[209] WLH[210] WLH[211] WLH[212] WLH[213] WLH[214] WLH[215] WLH[216]
+   WLH[217] WLH[218] WLH[219] WLH[220] WLH[221] WLH[222] WLH[223] WLH[224]
+   WLH[225] WLH[226] WLH[227] WLH[228] WLH[229] WLH[230] WLH[231] WLH[232]
+   WLH[233] WLH[234] WLH[235] WLH[236] WLH[237] WLH[238] WLH[239] WLH[240]
+   WLH[241] WLH[242] WLH[243] WLH[244] WLH[245] WLH[246] WLH[247] WLH[248]
+   WLH[249] WLH[250] WLH[251] WLH[252] WLH[253] WLH[254] WLH[255] WLH[256]
+   WLH[257] WLH[258] WLH[259] WLH[260] WLH[261] WLH[262] WLH[263] WLH[264]
+   WLH[265] WLH[266] WLH[267] WLH[268] WLH[269] WLH[270] WLH[271] WLH[272]
+   WLH[273] WLH[274] WLH[275] WLH[276] WLH[277] WLH[278] WLH[279] WLH[280]
+   WLH[281] WLH[282] WLH[283] WLH[284] WLH[285] WLH[286] WLH[287] WLH[288]
+   WLH[289] WLH[290] WLH[291] WLH[292] WLH[293] WLH[294] WLH[295] WLH[296]
+   WLH[297] WLH[298] WLH[299] WLH[300] WLH[301] WLH[302] WLH[303] WLH[304]
+   WLH[305] WLH[306] WLH[307] WLH[308] WLH[309] WLH[310] WLH[311] WLH[312]
+   WLH[313] WLH[314] WLH[315] WLH[316] WLH[317] WLH[318] WLH[319] WLH[320]
+   WLH[321] WLH[322] WLH[323] WLH[324] WLH[325] WLH[326] WLH[327] WLH[328]
+   WLH[329] WLH[330] WLH[331] WLH[332] WLH[333] WLH[334] WLH[335] WLH[336]
+   WLH[337] WLH[338] WLH[339] WLH[340] WLH[341] WLH[342] WLH[343] WLH[344]
+   WLH[345] WLH[346] WLH[347] WLH[348] WLH[349] WLH[350] WLH[351] WLH[352]
+   WLH[353] WLH[354] WLH[355] WLH[356] WLH[357] WLH[358] WLH[359] WLH[360]
+   WLH[361] WLH[362] WLH[363] WLH[364] WLH[365] WLH[366] WLH[367] WLH[368]
+   WLH[369] WLH[370] WLH[371] WLH[372] WLH[373] WLH[374] WLH[375] WLH[376]
+   WLH[377] WLH[378] WLH[379] WLH[380] WLH[381] WLH[382] WLH[383] WLH[384]
+   WLH[385] WLH[386] WLH[387] WLH[388] WLH[389] WLH[390] WLH[391] WLH[392]
+   WLH[393] WLH[394] WLH[395] WLH[396] WLH[397] WLH[398] WLH[399] WLH[400]
+   WLH[401] WLH[402] WLH[403] WLH[404] WLH[405] WLH[406] WLH[407] WLH[408]
+   WLH[409] WLH[410] WLH[411] WLH[412] WLH[413] WLH[414] WLH[415] WLH[416]
+   WLH[417] WLH[418] WLH[419] WLH[420] WLH[421] WLH[422] WLH[423] WLH[424]
+   WLH[425] WLH[426] WLH[427] WLH[428] WLH[429] WLH[430] WLH[431] WLH[432]
+   WLH[433] WLH[434] WLH[435] WLH[436] WLH[437] WLH[438] WLH[439] WLH[440]
+   WLH[441] WLH[442] WLH[443] WLH[444] WLH[445] WLH[446] WLH[447] WLH[448]
+   WLH[449] WLH[450] WLH[451] WLH[452] WLH[453] WLH[454] WLH[455] WLH[456]
+   WLH[457] WLH[458] WLH[459] WLH[460] WLH[461] WLH[462] WLH[463] WLH[464]
+   WLH[465] WLH[466] WLH[467] WLH[468] WLH[469] WLH[470] WLH[471] WLH[472]
+   WLH[473] WLH[474] WLH[475] WLH[476] WLH[477] WLH[478] WLH[479] WLH[480]
+   WLH[481] WLH[482] WLH[483] WLH[484] WLH[485] WLH[486] WLH[487] WLH[488]
+   WLH[489] WLH[490] WLH[491] WLH[492] WLH[493] WLH[494] WLH[495] WLH[496]
+   WLH[497] WLH[498] WLH[499] WLH[500] WLH[501] WLH[502] WLH[503] WLH[504]
+   WLH[505] WLH[506] WLH[507] WLH[508] WLH[509] WLH[510] WLH[511] WLH[512]
+   WLH[513] WLH[514] WLH[515] WLH[516] WLH[517] WLH[518] WLH[519] WLH[520]
+   WLH[521] WLH[522] WLH[523] WLH[524] WLH[525] WLH[526] WLH[527] WLH[528]
+   WLH[529] WLH[530] WLH[531] WLH[532] WLH[533] WLH[534] WLH[535] WLH[536]
+   WLH[537] WLH[538] WLH[539] WLH[540] WLH[541] WLH[542] WLH[543] WLH[544]
+   WLH[545] WLH[546] WLH[547] WLH[548] WLH[549] WLH[550] WLH[551] WLH[552]
+   WLH[553] WLH[554] WLH[555] WLH[556] WLH[557] WLH[558] WLH[559] WLH[560]
+   WLH[561] WLH[562] WLH[563] WLH[564] WLH[565] WLH[566] WLH[567] WLH[568]
+   WLH[569] WLH[570] WLH[571] WLH[572] WLH[573] WLH[574] WLH[575] WLH[576]
+   WLH[577] WLH[578] WLH[579] WLH[580] WLH[581] WLH[582] WLH[583] WLH[584]
+   WLH[585] WLH[586] WLH[587] WLH[588] WLH[589] WLH[590] WLH[591] WLH[592]
+   WLH[593] WLH[594] WLH[595] WLH[596] WLH[597] WLH[598] WLH[599] WLH[600]
+   WLH[601] WLH[602] WLH[603] WLH[604] WLH[605] WLH[606] WLH[607] WLH[608]
+   WLH[609] WLH[610] WLH[611] WLH[612] WLH[613] WLH[614] WLH[615] WLH[616]
+   WLH[617] WLH[618] WLH[619] WLH[620] WLH[621] WLH[622] WLH[623] WLH[624]
+   WLH[625] WLH[626] WLH[627] WLH[628] WLH[629] WLH[630] WLH[631] WLH[632]
+   WLH[633] WLH[634] WLH[635] WLH[636] WLH[637] WLH[638] WLH[639] WLH[640]
+   WLH[641] WLH[642] WLH[643] WLH[644] WLH[645] WLH[646] WLH[647] WLH[648]
+   WLH[649] WLH[650] WLH[651] WLH[652] WLH[653] WLH[654] WLH[655] WLH[656]
+   WLH[657] WLH[658] WLH[659] WLH[660] WLH[661] WLH[662] WLH[663] WLH[664]
+   WLH[665] WLH[666] WLH[667] WLH[668] WLH[669] WLH[670] WLH[671] WLH[672]
+   WLH[673] WLH[674] WLH[675] WLH[676] WLH[677] WLH[678] WLH[679] WLH[680]
+   WLH[681] WLH[682] WLH[683] WLH[684] WLH[685] WLH[686] WLH[687] WLH[688]
+   WLH[689] WLH[690] WLH[691] WLH[692] WLH[693] WLH[694] WLH[695] WLH[696]
+   WLH[697] WLH[698] WLH[699] WLH[700] WLH[701] WLH[702] WLH[703] WLH[704]
+   WLH[705] WLH[706] WLH[707] WLH[708] WLH[709] WLH[710] WLH[711] WLH[712]
+   WLH[713] WLH[714] WLH[715] WLH[716] WLH[717] WLH[718] WLH[719] WLH[720]
+   WLH[721] WLH[722] WLH[723] WLH[724] WLH[725] WLH[726] WLH[727] WLH[728]
+   WLH[729] WLH[730] WLH[731] WLH[732] WLH[733] WLH[734] WLH[735] WLH[736]
+   WLH[737] WLH[738] WLH[739] WLH[740] WLH[741] WLH[742] WLH[743] WLH[744]
+   WLH[745] WLH[746] WLH[747] WLH[748] WLH[749] WLH[750] WLH[751] WLH[752]
+   WLH[753] WLH[754] WLH[755] WLH[756] WLH[757] WLH[758] WLH[759] WLH[760]
+   WLH[761] WLH[762] WLH[763] WLH[764] WLH[765] WLH[766] WLH[767] WLH[768]
+   WLH[769] WLH[770] WLH[771] WLH[772] WLH[773] WLH[774] WLH[775] WLH[776]
+   WLH[777] WLH[778] WLH[779] WLH[780] WLH[781] WLH[782] WLH[783] WLH[784]
+   WLH[785] WLH[786] WLH[787] WLH[788] WLH[789] WLH[790] WLH[791] WLH[792]
+   WLH[793] WLH[794] WLH[795] WLH[796] WLH[797] WLH[798] WLH[799] WLH[800]
+   WLH[801] WLH[802] WLH[803] WLH[804] WLH[805] WLH[806] WLH[807] WLH[808]
+   WLH[809] WLH[810] WLH[811] WLH[812] WLH[813] WLH[814] WLH[815] WLH[816]
+   WLH[817] WLH[818] WLH[819] WLH[820] WLH[821] WLH[822] WLH[823] WLH[824]
+   WLH[825] WLH[826] WLH[827] WLH[828] WLH[829] WLH[830] WLH[831] WLH[832]
+   WLH[833] WLH[834] WLH[835] WLH[836] WLH[837] WLH[838] WLH[839] WLH[840]
+   WLH[841] WLH[842] WLH[843] WLH[844] WLH[845] WLH[846] WLH[847] WLH[848]
+   WLH[849] WLH[850] WLH[851] WLH[852] WLH[853] WLH[854] WLH[855] WLH[856]
+   WLH[857] WLH[858] WLH[859] WLH[860] WLH[861] WLH[862] WLH[863] WLH[864]
+   WLH[865] WLH[866] WLH[867] WLH[868] WLH[869] WLH[870] WLH[871] WLH[872]
+   WLH[873] WLH[874] WLH[875] WLH[876] WLH[877] WLH[878] WLH[879] WLH[880]
+   WLH[881] WLH[882] WLH[883] WLH[884] WLH[885] WLH[886] WLH[887] WLH[888]
+   WLH[889] WLH[890] WLH[891] WLH[892] WLH[893] WLH[894] WLH[895] WLH[896]
+   WLH[897] WLH[898] WLH[899] WLH[900] WLH[901] WLH[902] WLH[903] WLH[904]
+   WLH[905] WLH[906] WLH[907] WLH[908] WLH[909] WLH[910] WLH[911] WLH[912]
+   WLH[913] WLH[914] WLH[915] WLH[916] WLH[917] WLH[918] WLH[919] WLH[920]
+   WLH[921] WLH[922] WLH[923] WLH[924] WLH[925] WLH[926] WLH[927] WLH[928]
+   WLH[929] WLH[930] WLH[931] WLH[932] WLH[933] WLH[934] WLH[935] WLH[936]
+   WLH[937] WLH[938] WLH[939] WLH[940] WLH[941] WLH[942] WLH[943] WLH[944]
+   WLH[945] WLH[946] WLH[947] WLH[948] WLH[949] WLH[950] WLH[951] WLH[952]
+   WLH[953] WLH[954] WLH[955] WLH[956] WLH[957] WLH[958] WLH[959] WLH[960]
+   WLH[961] WLH[962] WLH[963] WLH[964] WLH[965] WLH[966] WLH[967] WLH[968]
+   WLH[969] WLH[970] WLH[971] WLH[972] WLH[973] WLH[974] WLH[975] WLH[976]
+   WLH[977] WLH[978] WLH[979] WLH[980] WLH[981] WLH[982] WLH[983] WLH[984]
+   WLH[985] WLH[986] WLH[987] WLH[988] WLH[989] WLH[990] WLH[991] WLH[992]
+   WLH[993] WLH[994] WLH[995] WLH[996] WLH[997] WLH[998] WLH[999] WLH[1000]
+   WLH[1001] WLH[1002] WLH[1003] WLH[1004] WLH[1005] WLH[1006] WLH[1007]
+   WLH[1008] WLH[1009] WLH[1010] WLH[1011] WLH[1012] WLH[1013] WLH[1014]
+   WLH[1015] WLH[1016] WLH[1017] WLH[1018] WLH[1019] WLH[1020] WLH[1021]
+   WLH[1022] WLH[1023] WLL[0] WLL[1] WLL[2] WLL[3] WLL[4] WLL[5] WLL[6] WLL[7]
+   WLL[8] WLL[9] WLL[10] WLL[11] WLL[12] WLL[13] WLL[14] WLL[15] WLL[16]
+   WLL[17] WLL[18] WLL[19] WLL[20] WLL[21] WLL[22] WLL[23] WLL[24] WLL[25]
+   WLL[26] WLL[27] WLL[28] WLL[29] WLL[30] WLL[31] WLL[32] WLL[33] WLL[34]
+   WLL[35] WLL[36] WLL[37] WLL[38] WLL[39] WLL[40] WLL[41] WLL[42] WLL[43]
+   WLL[44] WLL[45] WLL[46] WLL[47] WLL[48] WLL[49] WLL[50] WLL[51] WLL[52]
+   WLL[53] WLL[54] WLL[55] WLL[56] WLL[57] WLL[58] WLL[59] WLL[60] WLL[61]
+   WLL[62] WLL[63] WLL[64] WLL[65] WLL[66] WLL[67] WLL[68] WLL[69] WLL[70]
+   WLL[71] WLL[72] WLL[73] WLL[74] WLL[75] WLL[76] WLL[77] WLL[78] WLL[79]
+   WLL[80] WLL[81] WLL[82] WLL[83] WLL[84] WLL[85] WLL[86] WLL[87] WLL[88]
+   WLL[89] WLL[90] WLL[91] WLL[92] WLL[93] WLL[94] WLL[95] WLL[96] WLL[97]
+   WLL[98] WLL[99] WLL[100] WLL[101] WLL[102] WLL[103] WLL[104] WLL[105]
+   WLL[106] WLL[107] WLL[108] WLL[109] WLL[110] WLL[111] WLL[112] WLL[113]
+   WLL[114] WLL[115] WLL[116] WLL[117] WLL[118] WLL[119] WLL[120] WLL[121]
+   WLL[122] WLL[123] WLL[124] WLL[125] WLL[126] WLL[127] WLL[128] WLL[129]
+   WLL[130] WLL[131] WLL[132] WLL[133] WLL[134] WLL[135] WLL[136] WLL[137]
+   WLL[138] WLL[139] WLL[140] WLL[141] WLL[142] WLL[143] WLL[144] WLL[145]
+   WLL[146] WLL[147] WLL[148] WLL[149] WLL[150] WLL[151] WLL[152] WLL[153]
+   WLL[154] WLL[155] WLL[156] WLL[157] WLL[158] WLL[159] WLL[160] WLL[161]
+   WLL[162] WLL[163] WLL[164] WLL[165] WLL[166] WLL[167] WLL[168] WLL[169]
+   WLL[170] WLL[171] WLL[172] WLL[173] WLL[174] WLL[175] WLL[176] WLL[177]
+   WLL[178] WLL[179] WLL[180] WLL[181] WLL[182] WLL[183] WLL[184] WLL[185]
+   WLL[186] WLL[187] WLL[188] WLL[189] WLL[190] WLL[191] WLL[192] WLL[193]
+   WLL[194] WLL[195] WLL[196] WLL[197] WLL[198] WLL[199] WLL[200] WLL[201]
+   WLL[202] WLL[203] WLL[204] WLL[205] WLL[206] WLL[207] WLL[208] WLL[209]
+   WLL[210] WLL[211] WLL[212] WLL[213] WLL[214] WLL[215] WLL[216] WLL[217]
+   WLL[218] WLL[219] WLL[220] WLL[221] WLL[222] WLL[223] WLL[224] WLL[225]
+   WLL[226] WLL[227] WLL[228] WLL[229] WLL[230] WLL[231] WLL[232] WLL[233]
+   WLL[234] WLL[235] WLL[236] WLL[237] WLL[238] WLL[239] WLL[240] WLL[241]
+   WLL[242] WLL[243] WLL[244] WLL[245] WLL[246] WLL[247] WLL[248] WLL[249]
+   WLL[250] WLL[251] WLL[252] WLL[253] WLL[254] WLL[255] WLL[256] WLL[257]
+   WLL[258] WLL[259] WLL[260] WLL[261] WLL[262] WLL[263] WLL[264] WLL[265]
+   WLL[266] WLL[267] WLL[268] WLL[269] WLL[270] WLL[271] WLL[272] WLL[273]
+   WLL[274] WLL[275] WLL[276] WLL[277] WLL[278] WLL[279] WLL[280] WLL[281]
+   WLL[282] WLL[283] WLL[284] WLL[285] WLL[286] WLL[287] WLL[288] WLL[289]
+   WLL[290] WLL[291] WLL[292] WLL[293] WLL[294] WLL[295] WLL[296] WLL[297]
+   WLL[298] WLL[299] WLL[300] WLL[301] WLL[302] WLL[303] WLL[304] WLL[305]
+   WLL[306] WLL[307] WLL[308] WLL[309] WLL[310] WLL[311] WLL[312] WLL[313]
+   WLL[314] WLL[315] WLL[316] WLL[317] WLL[318] WLL[319] WLL[320] WLL[321]
+   WLL[322] WLL[323] WLL[324] WLL[325] WLL[326] WLL[327] WLL[328] WLL[329]
+   WLL[330] WLL[331] WLL[332] WLL[333] WLL[334] WLL[335] WLL[336] WLL[337]
+   WLL[338] WLL[339] WLL[340] WLL[341] WLL[342] WLL[343] WLL[344] WLL[345]
+   WLL[346] WLL[347] WLL[348] WLL[349] WLL[350] WLL[351] WLL[352] WLL[353]
+   WLL[354] WLL[355] WLL[356] WLL[357] WLL[358] WLL[359] WLL[360] WLL[361]
+   WLL[362] WLL[363] WLL[364] WLL[365] WLL[366] WLL[367] WLL[368] WLL[369]
+   WLL[370] WLL[371] WLL[372] WLL[373] WLL[374] WLL[375] WLL[376] WLL[377]
+   WLL[378] WLL[379] WLL[380] WLL[381] WLL[382] WLL[383] WLL[384] WLL[385]
+   WLL[386] WLL[387] WLL[388] WLL[389] WLL[390] WLL[391] WLL[392] WLL[393]
+   WLL[394] WLL[395] WLL[396] WLL[397] WLL[398] WLL[399] WLL[400] WLL[401]
+   WLL[402] WLL[403] WLL[404] WLL[405] WLL[406] WLL[407] WLL[408] WLL[409]
+   WLL[410] WLL[411] WLL[412] WLL[413] WLL[414] WLL[415] WLL[416] WLL[417]
+   WLL[418] WLL[419] WLL[420] WLL[421] WLL[422] WLL[423] WLL[424] WLL[425]
+   WLL[426] WLL[427] WLL[428] WLL[429] WLL[430] WLL[431] WLL[432] WLL[433]
+   WLL[434] WLL[435] WLL[436] WLL[437] WLL[438] WLL[439] WLL[440] WLL[441]
+   WLL[442] WLL[443] WLL[444] WLL[445] WLL[446] WLL[447] WLL[448] WLL[449]
+   WLL[450] WLL[451] WLL[452] WLL[453] WLL[454] WLL[455] WLL[456] WLL[457]
+   WLL[458] WLL[459] WLL[460] WLL[461] WLL[462] WLL[463] WLL[464] WLL[465]
+   WLL[466] WLL[467] WLL[468] WLL[469] WLL[470] WLL[471] WLL[472] WLL[473]
+   WLL[474] WLL[475] WLL[476] WLL[477] WLL[478] WLL[479] WLL[480] WLL[481]
+   WLL[482] WLL[483] WLL[484] WLL[485] WLL[486] WLL[487] WLL[488] WLL[489]
+   WLL[490] WLL[491] WLL[492] WLL[493] WLL[494] WLL[495] WLL[496] WLL[497]
+   WLL[498] WLL[499] WLL[500] WLL[501] WLL[502] WLL[503] WLL[504] WLL[505]
+   WLL[506] WLL[507] WLL[508] WLL[509] WLL[510] WLL[511] WLL[512] WLL[513]
+   WLL[514] WLL[515] WLL[516] WLL[517] WLL[518] WLL[519] WLL[520] WLL[521]
+   WLL[522] WLL[523] WLL[524] WLL[525] WLL[526] WLL[527] WLL[528] WLL[529]
+   WLL[530] WLL[531] WLL[532] WLL[533] WLL[534] WLL[535] WLL[536] WLL[537]
+   WLL[538] WLL[539] WLL[540] WLL[541] WLL[542] WLL[543] WLL[544] WLL[545]
+   WLL[546] WLL[547] WLL[548] WLL[549] WLL[550] WLL[551] WLL[552] WLL[553]
+   WLL[554] WLL[555] WLL[556] WLL[557] WLL[558] WLL[559] WLL[560] WLL[561]
+   WLL[562] WLL[563] WLL[564] WLL[565] WLL[566] WLL[567] WLL[568] WLL[569]
+   WLL[570] WLL[571] WLL[572] WLL[573] WLL[574] WLL[575] WLL[576] WLL[577]
+   WLL[578] WLL[579] WLL[580] WLL[581] WLL[582] WLL[583] WLL[584] WLL[585]
+   WLL[586] WLL[587] WLL[588] WLL[589] WLL[590] WLL[591] WLL[592] WLL[593]
+   WLL[594] WLL[595] WLL[596] WLL[597] WLL[598] WLL[599] WLL[600] WLL[601]
+   WLL[602] WLL[603] WLL[604] WLL[605] WLL[606] WLL[607] WLL[608] WLL[609]
+   WLL[610] WLL[611] WLL[612] WLL[613] WLL[614] WLL[615] WLL[616] WLL[617]
+   WLL[618] WLL[619] WLL[620] WLL[621] WLL[622] WLL[623] WLL[624] WLL[625]
+   WLL[626] WLL[627] WLL[628] WLL[629] WLL[630] WLL[631] WLL[632] WLL[633]
+   WLL[634] WLL[635] WLL[636] WLL[637] WLL[638] WLL[639] WLL[640] WLL[641]
+   WLL[642] WLL[643] WLL[644] WLL[645] WLL[646] WLL[647] WLL[648] WLL[649]
+   WLL[650] WLL[651] WLL[652] WLL[653] WLL[654] WLL[655] WLL[656] WLL[657]
+   WLL[658] WLL[659] WLL[660] WLL[661] WLL[662] WLL[663] WLL[664] WLL[665]
+   WLL[666] WLL[667] WLL[668] WLL[669] WLL[670] WLL[671] WLL[672] WLL[673]
+   WLL[674] WLL[675] WLL[676] WLL[677] WLL[678] WLL[679] WLL[680] WLL[681]
+   WLL[682] WLL[683] WLL[684] WLL[685] WLL[686] WLL[687] WLL[688] WLL[689]
+   WLL[690] WLL[691] WLL[692] WLL[693] WLL[694] WLL[695] WLL[696] WLL[697]
+   WLL[698] WLL[699] WLL[700] WLL[701] WLL[702] WLL[703] WLL[704] WLL[705]
+   WLL[706] WLL[707] WLL[708] WLL[709] WLL[710] WLL[711] WLL[712] WLL[713]
+   WLL[714] WLL[715] WLL[716] WLL[717] WLL[718] WLL[719] WLL[720] WLL[721]
+   WLL[722] WLL[723] WLL[724] WLL[725] WLL[726] WLL[727] WLL[728] WLL[729]
+   WLL[730] WLL[731] WLL[732] WLL[733] WLL[734] WLL[735] WLL[736] WLL[737]
+   WLL[738] WLL[739] WLL[740] WLL[741] WLL[742] WLL[743] WLL[744] WLL[745]
+   WLL[746] WLL[747] WLL[748] WLL[749] WLL[750] WLL[751] WLL[752] WLL[753]
+   WLL[754] WLL[755] WLL[756] WLL[757] WLL[758] WLL[759] WLL[760] WLL[761]
+   WLL[762] WLL[763] WLL[764] WLL[765] WLL[766] WLL[767] WLL[768] WLL[769]
+   WLL[770] WLL[771] WLL[772] WLL[773] WLL[774] WLL[775] WLL[776] WLL[777]
+   WLL[778] WLL[779] WLL[780] WLL[781] WLL[782] WLL[783] WLL[784] WLL[785]
+   WLL[786] WLL[787] WLL[788] WLL[789] WLL[790] WLL[791] WLL[792] WLL[793]
+   WLL[794] WLL[795] WLL[796] WLL[797] WLL[798] WLL[799] WLL[800] WLL[801]
+   WLL[802] WLL[803] WLL[804] WLL[805] WLL[806] WLL[807] WLL[808] WLL[809]
+   WLL[810] WLL[811] WLL[812] WLL[813] WLL[814] WLL[815] WLL[816] WLL[817]
+   WLL[818] WLL[819] WLL[820] WLL[821] WLL[822] WLL[823] WLL[824] WLL[825]
+   WLL[826] WLL[827] WLL[828] WLL[829] WLL[830] WLL[831] WLL[832] WLL[833]
+   WLL[834] WLL[835] WLL[836] WLL[837] WLL[838] WLL[839] WLL[840] WLL[841]
+   WLL[842] WLL[843] WLL[844] WLL[845] WLL[846] WLL[847] WLL[848] WLL[849]
+   WLL[850] WLL[851] WLL[852] WLL[853] WLL[854] WLL[855] WLL[856] WLL[857]
+   WLL[858] WLL[859] WLL[860] WLL[861] WLL[862] WLL[863] WLL[864] WLL[865]
+   WLL[866] WLL[867] WLL[868] WLL[869] WLL[870] WLL[871] WLL[872] WLL[873]
+   WLL[874] WLL[875] WLL[876] WLL[877] WLL[878] WLL[879] WLL[880] WLL[881]
+   WLL[882] WLL[883] WLL[884] WLL[885] WLL[886] WLL[887] WLL[888] WLL[889]
+   WLL[890] WLL[891] WLL[892] WLL[893] WLL[894] WLL[895] WLL[896] WLL[897]
+   WLL[898] WLL[899] WLL[900] WLL[901] WLL[902] WLL[903] WLL[904] WLL[905]
+   WLL[906] WLL[907] WLL[908] WLL[909] WLL[910] WLL[911] WLL[912] WLL[913]
+   WLL[914] WLL[915] WLL[916] WLL[917] WLL[918] WLL[919] WLL[920] WLL[921]
+   WLL[922] WLL[923] WLL[924] WLL[925] WLL[926] WLL[927] WLL[928] WLL[929]
+   WLL[930] WLL[931] WLL[932] WLL[933] WLL[934] WLL[935] WLL[936] WLL[937]
+   WLL[938] WLL[939] WLL[940] WLL[941] WLL[942] WLL[943] WLL[944] WLL[945]
+   WLL[946] WLL[947] WLL[948] WLL[949] WLL[950] WLL[951] WLL[952] WLL[953]
+   WLL[954] WLL[955] WLL[956] WLL[957] WLL[958] WLL[959] WLL[960] WLL[961]
+   WLL[962] WLL[963] WLL[964] WLL[965] WLL[966] WLL[967] WLL[968] WLL[969]
+   WLL[970] WLL[971] WLL[972] WLL[973] WLL[974] WLL[975] WLL[976] WLL[977]
+   WLL[978] WLL[979] WLL[980] WLL[981] WLL[982] WLL[983] WLL[984] WLL[985]
+   WLL[986] WLL[987] WLL[988] WLL[989] WLL[990] WLL[991] WLL[992] WLL[993]
+   WLL[994] WLL[995] WLL[996] WLL[997] WLL[998] WLL[999] WLL[1000] WLL[1001]
+   WLL[1002] WLL[1003] WLL[1004] WLL[1005] WLL[1006] WLL[1007] WLL[1008]
+   WLL[1009] WLL[1010] WLL[1011] WLL[1012] WLL[1013] WLL[1014] WLL[1015]
+   WLL[1016] WLL[1017] WLL[1018] WLL[1019] WLL[1020] WLL[1021] WLL[1022]
+   WLL[1023] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WPULSE[0]
+   WPULSE[1] WPULSE[2] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5]
+   WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13]
+   WT_IN[14] WT_IN[15] WT_IN[16] WT_IN[17] WT_IN[18] WT_IN[19] WT_IN[20]
+   WT_IN[21] WT_IN[22] WT_IN[23] WT_IN[24] WT_IN[25] WT_IN[26] WT_IN[27]
+   WT_IN[28] WT_IN[29] WT_IN[30] WT_IN[31] ADR[4] ADR[5] ADR[9] ADR[10] ADR[11]
+   ADR[12] ADR[13] ADR[14] ADR[6] ADR[7] LOG0 ADR[0] ADR[1] ADR[2] ADR[3]
+   SNPS_SP_HD_16Kx8_top
.ENDS
.SUBCKT SNPS_SP_HD_16Kx8 ADR[0] ADR[1] ADR[2] ADR[3] ADR[4] ADR[5] ADR[6] ADR[7]
+       ADR[8] ADR[9] ADR[10] ADR[11] ADR[12] ADR[13] BC0 BC1 BC2 CLK D[0] D[1]
+       D[2] D[3] D[4] D[5] D[6] D[7] LS ME Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6]
+       Q[7] RM[0] RM[1] RM[2] RM[3] RME TEST1 TEST_RNM VDD VNW_N VPW_P VSS
+       WA[0] WA[1] WE WPULSE[0] WPULSE[1] WPULSE[2]
X_TOP_LAY ADR[0] ADR[1] ADR[2] ADR[3] ADR[4] ADR[5] ADR[6] ADR[7] ADR[8] ADR[9]
+   ADR[10] ADR[11] ADR[12] ADR[13] BC0 BC1 BC2 CLK D[0] D[1] D[2] D[3] D[4]
+   D[5] D[6] D[7] LS ME Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] RM[0] RM[1]
+   RM[2] RM[3] RME TEST1 TEST_RNM VDD VNW_N VPW_P VSS WA[0] WA[1] WE WPULSE[0]
+   WPULSE[1] WPULSE[2] SNPS_SP_HD_16Kx8_TOP_LAY
 Xvpw_p_h VPW_P vassert_hi vmax=0
 Xvpw_p_l VPW_P vassert_lo vmin=-1.5
 Xvnw_n_l VNW_N vassert_lo vmin=0
 Xvnw_n_h VNW_N vassert_hi vmax=1.2
 Xvss_h VSS vassert_hi vmax=0
 Xvss_l VSS vassert_lo vmin=0
 Xvdd_h VDD vassert_hi vmax=0.9
 Xvdd_l VDD vassert_lo vmin=0.45
.ENDS
