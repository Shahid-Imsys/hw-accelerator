*---------------------------------------------------------------------*
*               Copyright(c) Synopsys, Inc.                           *
*     All Rights reserved - Unpublished -rights reserved under        *
*     the Copyright laws of the United States of America.             *
*                                                                     *
*  U.S. Patents: 7,093,156 B1 and 7,406,620 B2 (and more pending).    *
*                                                                     *
*  This file includes the Confidential information of Synopsys, Inc.  *
*  and GLOBALFOUNDRIES.                                               *
*  The receiver of this Confidential Information shall not disclose   *
*  it to any third party and shall protect its confidentiality by     *
*  using the same degree of care, but not less than a reasonable      *
*  degree of care, as the receiver uses to protect receiver's own     *
*  Confidential Information.                                          *
*  Licensee acknowledges and agrees that all output generated for     *
*  Licensee by Synopsys, Inc. as described in the pertinent Program   *
*  Schedule(s), or generated by Licensee through use of any Compiler  *
*  licensed hereunder contains information that complies with the     *
*  Virtual Component Identification Physical Tagging Standard (VCID)  *
*  as maintained by the Virtual Socket Interface Alliance (VSIA).     *
*  Such information may be expressed in GDSII Layer 63 or other such  *
*  layer designated by the VSIA, hardware definition languages, or    *
*  other formats.  Licensee is not authorized to alter or change any  *
*  such information.                                                  *
*---------------------------------------------------------------------*
*                                                                     *
*  Built for linux64 and running on linux64.                          *
*                                                                     *
*  Software           : Rev: U-2022.12                                *
*  Library Format     : Rev: 1.05.00                                  *
*  Compiler Name      : gf22nsd42p11s1drl128sa04p1                    *
*  Platform           : Linux3.10.0-957.5.1.el7.x86_64                *
*                     : #1 SMP Wed Dec 19 10:46:58 EST 2018x86_64     *
*  Date of Generation : Fri Dec 09 14:35:03 CET 2022                  *
*                                                                     *
*---------------------------------------------------------------------*
.option SCALE=1

.subckt mm17a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=120n wn2=120n wp1=240n wp2=240n
MNA1 X A1 VSS VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 X A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MPA2 net10 A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2
+ w=wp2 m=m_p2
MPA1 X A1 net10 VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
.ends

.subckt mm17a04_u_inv_bulk_n_vt2_p_vt2 VDD VSS VBP VBN X A CPP=104n P_LA_n=4n
+ P_LA_p=4n ULP=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
MNA X A VSS VBN slvtnfet cpp=cpp p_la=p_la_n ulp=ulp nf=nf_n l=ln w=wn m=m_n
MPA X A VDD VBP slvtpfet cpp=cpp p_la=p_la_p ulp=ulp nf=nf_p l=lp w=wp m=m_p
.ends

.subckt mm17a04_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=320n wn2=320n wp1=240n wp2=240n
MPA2 X A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
MPA1 X A1 VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MNA1 X A1 net22 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 net22 A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2
+ w=wn2 m=m_n2
.ends

.subckt mm17a04_u_hdrf2p_tclk VDDP VDDPI VNWP VSS VBP VBN T1T FLOAT LDFTY TCLKB
+ TEST1
XI18 VDDPI VSS VBP VBN T1T T1B LDFTY
+ mm17a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=320n
+ wp2=320n
MI41 net98 net101 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
MI43 net102 TCK net98 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
MI44 FLOAT T1T net102 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
MI38 VDDP TCK FLOAT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=2
XI17 VDDPI VSS VBP VBN T1B TEST1 mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI40 VDDPI VSS VBP VBN net101 FLOAT mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI45 VDDPI VSS VBP VBN TCK T1T TCLKB
+ mm17a04_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=180n
+ wp2=180n
.ends

.subckt mm17a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 VDD VSS VBP VBN X A S0
+ S1 CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=120n wn2=120n wp1=120n wp2=120n
MNA net020 A VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MNS0 X S0 net020 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MPA net16 A VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MPS1 X S1 net16 VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
.ends

.subckt mm17a04_u_inv_bulk_n_vt3_p_vt3 VDD VSS VBP VBN X A CPP=104n P_LA_n=4n
+ P_LA_p=4n ULP=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
MNA X A VSS VBN slvtnfet cpp=cpp p_la=p_la_n ulp=ulp nf=nf_n l=ln w=wn m=m_n
MPA X A VDD VBP slvtpfet cpp=cpp p_la=p_la_p ulp=ulp nf=nf_p l=lp w=wp m=m_p
.ends

.subckt mm17a04_u_hdrf2p_blatch_ctrl_lme VDDP VDDPI VSS VBP VBN OUT OUTB CB CT
+ IN
*XI13 VBP VBN OUTB VDDPI mm17a04_u_lat_set_op_pfv
XI0 VDDPI VSS VBP VBN OUTB IN CB CT
+ mm17a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n
+ wp1=240n wp2=240n
XI1 VDDPI VSS VBP VBN OUTB OUT CT CB
+ mm17a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n
+ wp1=240n wp2=240n
XI2 VDDPI VSS VBP VBN OUT OUTB mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
.ends

.subckt mm17a04_u_hdrf2p_rctrl VDDPI VNWP VSS VBP VBN LME LMEB MCLKB MCLKT CLK
+ ME
XI61 VNWP VDDPI VSS VBP VBN net243 LMEBB MCLKB MCLKT ME
+ mm17a04_u_hdrf2p_blatch_ctrl_lme
Xinv_lwe VDDPI VSS VBP VBN LMEB net243 mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
Xinv_mclk VDDPI VSS VBP VBN MCLKT MCLKB mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
Xinv_mclkb VDDPI VSS VBP VBN MCLKB CLK mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI28 VDDPI VSS VBP VBN LME LMEBB mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
.ends

.subckt mm17a04_u_hdrf2p_ry4sel VDDPI VNWP VSS VBP VBN YSEL[0] YSEL[1] YSEL[2]
+ YSEL[3] YSELIO[0] YSELIO[1] YSELIO[2] YSELIO[3] RFLOAT YCOL[0] YCOL[1]
+ YCOL[2] YCOL[3]
XI47 VDDPI VSS VBP VBN RWCLK RFLOAT mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=480n
+ wp=480n
MI59[0] VDDPI YSELB[0] YSELIO[0] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=400n m=2
MI59[1] VDDPI YSELB[1] YSELIO[1] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=400n m=2
MI59[2] VDDPI YSELB[2] YSELIO[2] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=400n m=2
MI59[3] VDDPI YSELB[3] YSELIO[3] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=400n m=2
M22[0] VDDPI RWCLK YSELB[0] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=400n m=1
M22[1] VDDPI RWCLK YSELB[1] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=400n m=1
M22[2] VDDPI RWCLK YSELB[2] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=400n m=1
M22[3] VDDPI RWCLK YSELB[3] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=400n m=1
MI56[0] VDDPI YCOL[0] YSELB[0] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=400n m=1
MI56[1] VDDPI YCOL[1] YSELB[1] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=400n m=1
MI56[2] VDDPI YCOL[2] YSELB[2] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=400n m=1
MI56[3] VDDPI YCOL[3] YSELB[3] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=400n m=1
MI62[0] VDDPI YSELB[0] YSEL[0] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=400n m=3
MI62[1] VDDPI YSELB[1] YSEL[1] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=400n m=3
MI62[2] VDDPI YSELB[2] YSEL[2] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=400n m=3
MI62[3] VDDPI YSELB[3] YSEL[3] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=400n m=3
MI61[0] YSEL[0] YSELB[0] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=480n m=3
MI61[1] YSEL[1] YSELB[1] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=480n m=3
MI61[2] YSEL[2] YSELB[2] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=480n m=3
MI61[3] YSEL[3] YSELB[3] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=480n m=3
MI60[0] YSELIO[0] YSELB[0] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=480n m=2
MI60[1] YSELIO[1] YSELB[1] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=480n m=2
MI60[2] YSELIO[2] YSELB[2] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=480n m=2
MI60[3] YSELIO[3] YSELB[3] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=480n m=2
MI57[0] YSELB[0] YCOL[0] NN1 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=480n m=1
MI57[1] YSELB[1] YCOL[1] NN1 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=480n m=1
MI57[2] YSELB[2] YCOL[2] NN1 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=480n m=1
MI57[3] YSELB[3] YCOL[3] NN1 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=480n m=1
MI64[0] YSELB[0] VSS VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=480n
+ m=1
MI64[1] YSELB[1] VSS VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=480n
+ m=1
MI64[2] YSELB[2] VSS VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=480n
+ m=1
MI64[3] YSELB[3] VSS VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=480n
+ m=1
M21 NN1 RWCLK VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=480n m=2
.ends

.subckt mm17a04_u_hdrf2p_clkgen VDDP VDDPI VSS VBP VBN CKGATE FLOATB FLOATT
+ FLOAT CLKB CLPSEBUF DLYPW LDFTY LMEB PW
*XI69 VBP VBN FLOAT mm17a04_u_init1
XI103 VDDPI VSS VBP VBN CKGATE CLKB PWB
+ mm17a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=480n wn2=480n wp1=400n
+ wp2=400n
XI98 VDDP VSS VBP VBN PWB net363 PW
+ mm17a04_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=120n
+ wp2=120n
XI104 VDDPI VSS VBP VBN net363 LMEB net362
+ mm17a04_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=240n
+ wp2=240n
M65 net259 FLOATB VDDP VBP slvtpfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=480n m=1
M50 FLOAT CKGATE net259 VBP slvtpfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=480n
+ m=1
MPFLT VDDPI FLOAT FLOATB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n
+ m=1
XI109 VDDPI VSS VBP VBN net362 LDFTY mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=240n
MLPCPLP FLOATB DLYPW VSS VBN slvtnfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=480n
+ m=1
MNgate FLOAT CKGATE VSS VBN slvtnfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=480n
+ m=4
MI114 FLOATB CLPSEBUF VSS VBN slvtnfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=480n
+ m=1
MNFLT FLOATB FLOAT VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=2
.ends

.subckt mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=320n wn2=320n wp1=240n wp2=240n
MPA2 X A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
MPA1 X A1 VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MNA1 X A1 net22 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 net22 A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2
+ w=wn2 m=m_n2
.ends

.subckt mm17a04_u_inv_bulk_n_vt2_p_vt3 VDD VSS VBP VBN X A CPP=104n P_LA_n=4n
+ P_LA_p=4n ULP=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
MNA X A VSS VBN slvtnfet cpp=cpp p_la=p_la_n ulp=ulp nf=nf_n l=ln w=wn m=m_n
MPA X A VDD VBP slvtpfet cpp=cpp p_la=p_la_p ulp=ulp nf=nf_p l=lp w=wp m=m_p
.ends

.subckt
+ mm17a04_u_nr4_bulk_n1_vt2_n2_vt2_n3_vt2_n4_vt2_p1_vt2_p2_vt2_p3_vt2_p4_vt2
+ VDD VSS VBP VBN X A1 A2 A3 A4 CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_n3=4n
+ P_LA_n4=4n P_LA_p1=4n P_LA_p2=4n P_LA_p3=4n P_LA_p4=4n ULP=0 ln1=20n ln2=20n
+ ln3=20n ln4=20n lp1=20n lp2=20n lp3=20n lp4=20n m_n1=1 m_n2=1 m_n3=1 m_n4=1
+ m_p1=1 m_p2=1 m_p3=1 m_p4=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_n4=1 nf_p1=1 nf_p2=1
+ nf_p3=1 nf_p4=1 wn1=120n wn2=120n wn3=120n wn4=120n wp1=120n wp2=120n
+ wp3=120n wp4=120n
MNA2 X A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MNA4 X A4 VSS VBN slvtnfet cpp=cpp p_la=p_la_n4 ulp=ulp nf=nf_n4 l=ln4 w=wn4
+ m=m_n4
MNA1 X A1 VSS VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA3 X A3 VSS VBN slvtnfet cpp=cpp p_la=p_la_n3 ulp=ulp nf=nf_n3 l=ln3 w=wn3
+ m=m_n3
MPA4 net10 A4 VDD VBP slvtpfet cpp=cpp p_la=p_la_p4 ulp=ulp nf=nf_p4 l=lp4
+ w=wp4 m=m_p4
MPA3 net029 A3 net10 VBP slvtpfet cpp=cpp p_la=p_la_p3 ulp=ulp nf=nf_p3 l=lp3
+ w=wp3 m=m_p3
MPA2 net032 A2 net029 VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2
+ w=wp2 m=m_p2
MPA1 X A1 net032 VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
.ends

.subckt mm17a04_u_pw_gen_rf2p VDDP VDDPI VSS VBP VBN PW CLKFLT CLPSEBUF DFTMASK
+ DLYPW DSORSD FLOAT_RET LS
M12 PW PWB1 CKGDN VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
MI72 PW CLPSEBUF VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
Mckdrv pwsvs CLKFLT VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
M11 PW CLMP VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
Mxback1ck CKGDN CLKDEL VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=1
MN3 pwsvs FLTBAR PW VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
Xnr2_ckdel1 VDDPI VSS VBP VBN CLKDELB CLKFLT CLMP
+ mm17a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=320n
+ wp2=320n
XFWD VDDPI VSS VBP VBN PWB1 PW net284
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=320n
+ wp2=320n
M0 net267 CLKFLT net268 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
M65 net268 FLTBAR net267 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
M8 VDDPI CLMP net267 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
*XI38 VBP VBN PW mm17a04_u_init1
XI73 VDDPI_PWGEN VSS VBP VBN net284 CLPSEBUF mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=160n wp=320n
XI79 VDDP VSS VBP VBN CLMP LSORDLTPWB mm17a04_u_inv_bulk_n_vt2_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
Xinv_ckdel2 VDDP VSS VBP VBN CLKDEL CLKDELB mm17a04_u_inv_bulk_n_vt2_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI40 VDDPI VSS VBP VBN FLTBAR FLOAT_RET mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=320n
Xnr2_clmp VDDPI VSS VBP VBN LSORDLTPWB DSORSD DFTMASK LS DLYPW
+ mm17a04_u_nr4_bulk_n1_vt2_n2_vt2_n3_vt2_n4_vt2_p1_vt2_p2_vt2_p3_vt2_p4_vt2
+ cpp=104n p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_n4=4n p_la_p1=4n p_la_p2=4n
+ p_la_p3=4n p_la_p4=4n ulp=0 ln1=20n ln2=20n ln3=20n ln4=20n lp1=20n lp2=20n
+ lp3=20n lp4=20n m_n1=1 m_n2=1 m_n3=1 m_n4=1 m_p1=1 m_p2=1 m_p3=1 m_p4=1
+ nf_n1=1 nf_n2=1 nf_n3=1 nf_n4=1 nf_p1=1 nf_p2=1 nf_p3=1 nf_p4=1 wn1=120n
+ wn2=120n wn3=120n wn4=120n wp1=400n wp2=400n wp3=400n wp4=400n
M9 net268 PWB1 PW VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
Mclkpull VDDPI_PWGEN CLKDEL PW VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=320n m=1
MI70 VDDPI CLPSEBUF VDDPI_PWGEN VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=320n m=1
.ends

.subckt mm17a04_u_nd3_bulk_n1_vt3_n2_vt3_n3_vt3_p1_vt3_p2_vt3_p3_vt3 VDD VSS
+ VBP VBN X A1 A2 A3 CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_n3=4n P_LA_p1=4n
+ P_LA_p2=4n P_LA_p3=4n ULP=0 ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n
+ m_n1=1 m_n2=1 m_n3=1 m_p1=1 m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1
+ nf_p2=1 nf_p3=1 wn1=120n wn2=120n wn3=120n wp1=120n wp2=120n wp3=120n
MNA1 X A1 net19 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 net19 A2 net018 VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2
+ w=wn2 m=m_n2
MNA3 net018 A3 VSS VBN slvtnfet cpp=cpp p_la=p_la_n3 ulp=ulp nf=nf_n3 l=ln3
+ w=wn3 m=m_n3
MPA1 X A1 VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MPA3 X A3 VDD VBP slvtpfet cpp=cpp p_la=p_la_p3 ulp=ulp nf=nf_p3 l=lp3 w=wp3
+ m=m_p3
MPA2 X A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
.ends

.subckt mm17a04_u_hdrf2p_ltchclk VDDP VDDPI VSS VBP VBN FLTL LCLKB LCLKT CLKFLT
+ DFTCKEN FLOAT LS ME_GATING
Xnd2_clkenab VDDPI VSS VBP VBN CLKB_LATCH CLKFLT DFTCKEN
+ mm17a04_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=180n
+ wp2=180n
XI18 VDDPI VSS VBP VBN net74 DFTCKEN ME_GATING
+ mm17a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=320n
+ wp2=320n
XLSB VDDPI VSS VBP VBN LSB net74 LS
+ mm17a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=320n
+ wp2=320n
Xinv_lclk VDDPI VSS VBP VBN FLT FLTL mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=320n
Xinv_lclkb VDDPI VSS VBP VBN LCLKB LCLKT mm17a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=5 m_p=5 nf_n=1 nf_p=1
+ wn=320n wp=320n
Xinv_lclkt VDDPI VSS VBP VBN LCLKT FLT mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=320n
+ wp=320n
Xnd3_lclk VDDPI VSS VBP VBN FLTL CLKB_LATCH FLOAT LSB
+ mm17a04_u_nd3_bulk_n1_vt3_n2_vt3_n3_vt3_p1_vt3_p2_vt3_p3_vt3 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=320n
+ wn2=320n wn3=320n wp1=320n wp2=320n wp3=320n
.ends

.subckt mm17a04_u_hdrf2p_cenclk VDDP VDDPI VSS VBP VBN CKGATE FLOAT FLOATT
+ LCLKB LCLKT CLKFLT CLKMUXB CLPSEBUF DFTCKEN DFTMASK DLYPW DSORSD FLOAT_RET
+ LDFTY LMEB LS ME_GATING
XFLTGEN VDDP VDDPI VSS VBP VBN CKGATE FLOATB FLOATT FLOAT CLKMUXB CLPSEBUF
+ DLYPW LDFTY LMEB PW mm17a04_u_hdrf2p_clkgen
XI113 VDDP VDDPI VSS VBP VBN PW CLKFLT CLPSEBUF DFTMASK DLYPW DSORSD FLOAT_RET
+ LS mm17a04_u_pw_gen_rf2p
XLTCHCLK VDDP VDDPI VSS VBP VBN FLTB LCLKB LCLKT CLKFLT DFTCKEN FLOAT LS
+ ME_GATING mm17a04_u_hdrf2p_ltchclk
.ends

.subckt mm17a04_u_hdrf2p_xbklatch VDDP VDDPI VSS VBP VBN OUT OUTB CB CT IN
*XI5 VBP VBN INB mm17a04_u_init0
XI2 VDDPI VSS VBP VBN OUT INB mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=240n wp=240n
XI9 VDDPI VSS VBP VBN OUTB OUT mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI0 VDDPI VSS VBP VBN INB IN CB CT
+ mm17a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n
+ wp1=240n wp2=240n
XI1 VDDPI VSS VBP VBN INB OUT CT CB
+ mm17a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n
+ wp1=240n wp2=240n
.ends

.subckt mm17a04_u_hdrf2p_xylatch VDDP VDDPI VSS VBP VBN OUT OUTB CB CT IN
*XI5 VBP VBN INB mm17a04_u_init0
XI2 VDDPI VSS VBP VBN OUT INB mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n wp=240n
XI9 VDDPI VSS VBP VBN OUTB OUT mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI0 VDDPI VSS VBP VBN INB IN CB CT
+ mm17a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n
+ wp1=240n wp2=240n
XI1 VDDPI VSS VBP VBN INB OUT CT CB
+ mm17a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n
+ wp1=240n wp2=240n
.ends

.subckt mm17a04_u_hdrf2p_adrltch_RD VDDP VDDPI VSS VBP VBN LXADR[0] LXADR[1]
+ LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LXADRB[0] LXADRB[1]
+ LXADRB[2] LXADRB[3] LXADRB[4] LXADRB[5] LXADRB[6] LXADRB[7] LYADR[0] LYADR[1]
+ LYADRB[0] LYADRB[1] LCLKB LCLKT XXADR[0] XXADR[1] XXADR[2] XXADR[3] XXADR[4]
+ XXADR[5] XXADR[6] XXADR[7] YYADR[0] YYADR[1]
XBKADR[2] VDDP VDDPI VSS VBP VBN LXADR[2] LXADRB[2] LCLKB LCLKT XXADR[2]
+ mm17a04_u_hdrf2p_xbklatch
XBKADR[3] VDDP VDDPI VSS VBP VBN LXADR[3] LXADRB[3] LCLKB LCLKT XXADR[3]
+ mm17a04_u_hdrf2p_xbklatch
XBKADR[4] VDDP VDDPI VSS VBP VBN LXADR[4] LXADRB[4] LCLKB LCLKT XXADR[4]
+ mm17a04_u_hdrf2p_xbklatch
XYADR[0] VDDP VDDPI VSS VBP VBN LYADR[0] LYADRB[0] LCLKB LCLKT YYADR[0]
+ mm17a04_u_hdrf2p_xylatch
XYADR[1] VDDP VDDPI VSS VBP VBN LYADR[1] LYADRB[1] LCLKB LCLKT YYADR[1]
+ mm17a04_u_hdrf2p_xylatch
XADR[5] VDDP VDDPI VSS VBP VBN LXADR[5] LXADRB[5] LCLKB LCLKT XXADR[5]
+ mm17a04_u_hdrf2p_xylatch
XADR[6] VDDP VDDPI VSS VBP VBN LXADR[6] LXADRB[6] LCLKB LCLKT XXADR[6]
+ mm17a04_u_hdrf2p_xylatch
XADR[7] VDDP VDDPI VSS VBP VBN LXADR[7] LXADRB[7] LCLKB LCLKT XXADR[7]
+ mm17a04_u_hdrf2p_xylatch
XADR[0] VDDP VDDPI VSS VBP VBN LXADR[0] LXADRB[0] LCLKB LCLKT XXADR[0]
+ mm17a04_u_hdrf2p_xylatch
XADR[1] VDDP VDDPI VSS VBP VBN LXADR[1] LXADRB[1] LCLKB LCLKT XXADR[1]
+ mm17a04_u_hdrf2p_xylatch
.ends

.subckt mm17a04_u_hdrf2p_clkdly VDDPI VNWP VSS VBP VBN CLKB CLKDEL CLK
Xinv_mclkb VDDPI VSS VBP VBN CLKB CLK mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=240n
+ wp=240n
Xinv_mclk VDDPI VSS VBP VBN CLKDEL CLKB mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
.ends

.subckt mm17a04_u_hdrf2p_rdgcen VDDP VDDPI VSS VBP VBN CKGATE_RD CLKB CLKDEL
+ FLOAT FLOATT LCLKB LCLKT LME LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+ LXADR[5] LXADR[6] LXADR[7] LXADRB[0] LXADRB[1] LXADRB[2] LXADRB[3] LXADRB[4]
+ LXADRB[5] LXADRB[6] LXADRB[7] LYADR[0] LYADR[1] LYADRB[0] LYADRB[1] MCLKB
+ MCLKT T1T YSEL[0] YSEL[1] YSEL[2] YSEL[3] YSELIO[0] YSELIO[1] YSELIO[2]
+ YSELIO[3] LOG1 CLK CLKFLT CLK_MUXB CLPSEBUF DFTCLKEN DFTMASK DLYPW DSORSD
+ FLOAT_RET LDFTY LME_GATING LS ME OPT_Y[0] OPT_Y[1] OPT_Y[2] OPT_Y[3] TEST1
+ XADR[0] XADR[1] XADR[2] XADR[3] XADR[4] XADR[5] XADR[6] XADR[7] YADR[0]
+ YADR[1]
XTCLK VDDP VDDPI VDDP VSS VBP VBN T1T FLOAT LDFTY MCLKB TEST1
+ mm17a04_u_hdrf2p_tclk
XCONTROL VDDPI VDDP VSS VBP VBN LME LMEB MCLKB MCLKT CLK ME
+ mm17a04_u_hdrf2p_rctrl
XYSEL VDDPI VDDP VSS VBP VBN YSEL[0] YSEL[1] YSEL[2] YSEL[3] YSELIO[0]
+ YSELIO[1] YSELIO[2] YSELIO[3] FLOAT OPT_Y[0] OPT_Y[1] OPT_Y[2] OPT_Y[3]
+ mm17a04_u_hdrf2p_ry4sel
XCLOCK VDDP VDDPI VSS VBP VBN CKGATE_RD FLOAT FLOATT LCLKB LCLKT CLKFLT
+ CLK_MUXB CLPSEBUF DFTCLKEN DFTMASK DLYPW DSORSD FLOAT_RET LDFTY LMEB LS
+ LME_GATING mm17a04_u_hdrf2p_cenclk
XADRLAT VDDP VDDPI VSS VBP VBN LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+ LXADR[5] LXADR[6] LXADR[7] LXADRB[0] LXADRB[1] LXADRB[2] LXADRB[3] LXADRB[4]
+ LXADRB[5] LXADRB[6] LXADRB[7] LYADR[0] LYADR[1] LYADRB[0] LYADRB[1] LCLKB
+ LCLKT XADR[0] XADR[1] XADR[2] XADR[3] XADR[4] XADR[5] XADR[6] XADR[7] YADR[0]
+ YADR[1] mm17a04_u_hdrf2p_adrltch_RD
XI143 VDDPI VDDP VSS VBP VBN CLKB CLKDEL CLK mm17a04_u_hdrf2p_clkdly
.ends

.subckt mm17a04_u_hdrf2p_cenclk_wr VDDP VDDPI VSS VBP VBN DCKBIO_L DCKBIO_R
+ FLOAT FLOATT LCLKB LCLKT LCLKT_DEL_2 LCLKT_DEL_4 CLKFLT CLKMUXB CLPSEBUF
+ DFTCLKEN DFTMASK DLYPW DSORSD FLOAT_RET LCLKT_PROG LDFTY LMEB LS ME_GATING
XI113 VDDP VDDPI VSS VBP VBN PW CLKFLT CLPSEBUF DFTMASK DLYPW DSORSD FLOAT_RET
+ LS mm17a04_u_pw_gen_rf2p
XI105 VDDPI VSS VBP VBN net575 LCLKT_DEL_2 mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI104 VDDPI VSS VBP VBN LCLKT_DEL_2 net571 mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI103 VDDPI VSS VBP VBN net571 LCLKT mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI106 VDDPI VSS VBP VBN LCLKT_DEL_4 net575 mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XFLTGEN VDDP VDDPI VSS VBP VBN CKGATE FLOATB FLOATT FLOAT CLKMUXB CLPSEBUF
+ DLYPW LDFTY LMEB PW mm17a04_u_hdrf2p_clkgen
XLTCHCLK VDDP VDDPI VSS VBP VBN FLTL LCLKB LCLKT CLKFLT DFTCLKEN FLOAT LS
+ ME_GATING mm17a04_u_hdrf2p_ltchclk
XDCLKNR3_R VDDPI VSS VBP VBN DCKBIO_R LCLKT_PROG FLTL
+ mm17a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=480n wn2=480n wp1=489n
+ wp2=489n
XDCLKNR3_L VDDPI VSS VBP VBN DCKBIO_L LCLKT_PROG FLTL
+ mm17a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=480n wn2=480n wp1=489n
+ wp2=489n
.ends

.subckt mm17a04_u_hdrf2p_adrltch VDDPI VNWP VSS VBP VBN LXADR[0] LXADR[1]
+ LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LXADRB[0] LXADRB[1]
+ LXADRB[2] LXADRB[3] LXADRB[4] LXADRB[5] LXADRB[6] LXADRB[7] LYADR[0] LYADR[1]
+ LYADRB[0] LYADRB[1] LCLKB LCLKT XADR[0] XADR[1] XADR[2] XADR[3] XADR[4]
+ XADR[5] XADR[6] XADR[7] YADR[0] YADR[1]
XYADR[0] VNWP VDDPI VSS VBP VBN LYADR[0] LYADRB[0] LCLKB LCLKT YADR[0]
+ mm17a04_u_hdrf2p_xylatch
XYADR[1] VNWP VDDPI VSS VBP VBN LYADR[1] LYADRB[1] LCLKB LCLKT YADR[1]
+ mm17a04_u_hdrf2p_xylatch
XRADR[0] VNWP VDDPI VSS VBP VBN LXADR[0] LXADRB[0] LCLKB LCLKT XADR[0]
+ mm17a04_u_hdrf2p_xylatch
XRADR[1] VNWP VDDPI VSS VBP VBN LXADR[1] LXADRB[1] LCLKB LCLKT XADR[1]
+ mm17a04_u_hdrf2p_xylatch
XRADR[2] VNWP VDDPI VSS VBP VBN LXADR[2] LXADRB[2] LCLKB LCLKT XADR[2]
+ mm17a04_u_hdrf2p_xylatch
XRADR[3] VNWP VDDPI VSS VBP VBN LXADR[3] LXADRB[3] LCLKB LCLKT XADR[3]
+ mm17a04_u_hdrf2p_xylatch
XRADR[4] VNWP VDDPI VSS VBP VBN LXADR[4] LXADRB[4] LCLKB LCLKT XADR[4]
+ mm17a04_u_hdrf2p_xylatch
XRADR[5] VNWP VDDPI VSS VBP VBN LXADR[5] LXADRB[5] LCLKB LCLKT XADR[5]
+ mm17a04_u_hdrf2p_xylatch
XRADR[6] VNWP VDDPI VSS VBP VBN LXADR[6] LXADRB[6] LCLKB LCLKT XADR[6]
+ mm17a04_u_hdrf2p_xylatch
XRADR[7] VNWP VDDPI VSS VBP VBN LXADR[7] LXADRB[7] LCLKB LCLKT XADR[7]
+ mm17a04_u_hdrf2p_xylatch
.ends

.subckt mm17a04_u_blatch_ctrl_lmelwe VDDP VDDPI VSS VBP VBN OUT OUTB CB CT IN
XI2 VDDPI VSS VBP VBN OUT OUTB mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
*XI13 VBP VBN OUTB VDDPI mm17a04_u_lat_set_op_pfv
XI0 VDDPI VSS VBP VBN OUTB IN CB CT
+ mm17a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n
+ wp1=320n wp2=320n
XI1 VDDPI VSS VBP VBN OUTB OUT CT CB
+ mm17a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
.ends

.subckt mm17a04_u_hdrf2p_wctrl VDDPI VNWP VSS VBP VBN LME LWE LWMEWB MCLKB
+ MCLKT CLK ME WE
XLATWE VNWP VDDPI VSS VBP VBN LWET LWEB MCLKB MCLKT WE
+ mm17a04_u_blatch_ctrl_lmelwe
XLATME VNWP VDDPI VSS VBP VBN LMET LMEBB MCLKB MCLKT ME
+ mm17a04_u_blatch_ctrl_lmelwe
XI59 VDDPI VSS VBP VBN LME LMEBB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI60 VDDPI VSS VBP VBN LWE LWEB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
Xinv_mclk VDDPI VSS VBP VBN MCLKT MCLKB mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=320n
Xinv_mclkb VDDPI VSS VBP VBN MCLKB CLK mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI58 VDDPI VSS VBP VBN LWMEWB LWET LMET
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=290n wn2=290n wp1=166n
+ wp2=166n
.ends

.subckt mm17a04_u_hdrf2p_wrgcen VDDP VDDPI VSS VBP VBN CLKB CLKDEL DCKBIO_L
+ DCKBIO_R FLOAT FLOATT LCLKB LCLKT LCLKT_DEL_2 LCLKT_DEL_4 LME LWE LXADR[0]
+ LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LXADRB[0]
+ LXADRB[1] LXADRB[2] LXADRB[3] LXADRB[4] LXADRB[5] LXADRB[6] LXADRB[7]
+ LYADR[0] LYADR[1] LYADRB[0] LYADRB[1] MCLKB MCLKT T1T CLK CLKFLT CLK_MUXB
+ CLPSEBUF DFTCLKEN DFTMASK DLYPW DSORSD FLOAT_RET LCLKT_prog LDFTY LME_GATING
+ LS ME TEST1 WE XADR[0] XADR[1] XADR[2] XADR[3] XADR[4] XADR[5] XADR[6]
+ XADR[7] YADR[0] YADR[1]
XTCLK VDDP VDDPI VDDP VSS VBP VBN T1T FLOAT LDFTY MCLKB TEST1
+ mm17a04_u_hdrf2p_tclk
XI131 VDDPI VDDP VSS VBP VBN CLKB CLKDEL CLK mm17a04_u_hdrf2p_clkdly
XCLOCK VDDP VDDPI VSS VBP VBN DCKBIO_L DCKBIO_R FLOAT FLOATT LCLKB LCLKT
+ LCLKT_DEL_2 LCLKT_DEL_4 CLKFLT CLK_MUXB CLPSEBUF DFTCLKEN DFTMASK DLYPW
+ DSORSD FLOAT_RET LCLKT_prog LDFTY LMEB LS LME_GATING
+ mm17a04_u_hdrf2p_cenclk_wr
XADRLAT VDDPI VDDP VSS VBP VBN LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+ LXADR[5] LXADR[6] LXADR[7] LXADRB[0] LXADRB[1] LXADRB[2] LXADRB[3] LXADRB[4]
+ LXADRB[5] LXADRB[6] LXADRB[7] LYADR[0] LYADR[1] LYADRB[0] LYADRB[1] LCLKB
+ LCLKT XADR[0] XADR[1] XADR[2] XADR[3] XADR[4] XADR[5] XADR[6] XADR[7] YADR[0]
+ YADR[1] mm17a04_u_hdrf2p_adrltch
XCONTROL VDDPI VDDP VSS VBP VBN LME LWE LMEB MCLKB MCLKT CLK ME WE
+ mm17a04_u_hdrf2p_wctrl
.ends

.subckt mm17a04_u_hdrf2p_bcctrl VDDP VDDPI VNWP VSS VBP VBN ARYSD ARYSD_BC1
+ ARYSD_BC2 RABUF[0] RABUF[1] STRSB WABUF[0] WABUF[1] WABUF[2] WPBUF[0]
+ WPBUF[1] WPBUF[2] BC1 BC2 LOG0 RA[0] RA[1] SD TEST_RNM WA[0] WA[1] WP[0]
+ WP[1] WP[2]
XI31 VDDPI VSS VBP VBN STRSB TEST_RNM mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI47 VDDPI VSS VBP VBN WABUF[0] WA[0] mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI49 VDDPI VSS VBP VBN WABUF[1] WA[1] mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI29[0] VDDPI VSS VBP VBN WPBUF[0] WP[0] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI29[1] VDDPI VSS VBP VBN WPBUF[1] WP[1] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI29[2] VDDPI VSS VBP VBN WPBUF[2] WP[2] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI18[0] VDDPI VSS VBP VBN RABUF[0] RA[0] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI18[1] VDDPI VSS VBP VBN RABUF[1] RA[1] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI176[2] VDDPI VSS VBP VBN WABUF[2] WA[0] WA[1]
+ mm17a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=240n
+ wp2=240n
.ends

.subckt mm17a04_u_rm4to1_pmos VDDP VBP VBN AT BT CT DT A B C D SELB[1]
MI5 A SELB[1] AT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
M2 D SELB[1] DT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
M1 C SELB[1] CT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
M0 B SELB[1] BT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
.ends

.subckt mm17a04_u_tg_bulk_n_vt2_p_vt2 VBP VBN A B S SB CPP=104n P_LA_n=4n
+ P_LA_p=4n ULP=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
MNS A S B VBN slvtnfet cpp=cpp p_la=p_la_n ulp=ulp nf=nf_n l=ln w=wn m=m_n
MPSB A SB B VBP slvtpfet cpp=cpp p_la=p_la_p ulp=ulp nf=nf_p l=lp w=wp m=m_p
.ends

.subckt mm17a04_u_rm4to1_slow VDDPI VNWP VSS VBP VBN AT BT CT DT A B C D SEL[0]
+ SEL[1]
XI1 VBP VBN B BT SEL[1] SEL[0] mm17a04_u_tg_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n wp=240n
XI0 VBP VBN A AT SEL[1] SEL[0] mm17a04_u_tg_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n wp=240n
XI2 VBP VBN C CT SEL[1] SEL[0] mm17a04_u_tg_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n wp=240n
XI3 VBP VBN D DT SEL[1] SEL[0] mm17a04_u_tg_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n wp=240n
.ends

.subckt mm17a04_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 VDD VSS
+ VBP VBN X A1 A2 A3 CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_n3=4n P_LA_p1=4n
+ P_LA_p2=4n P_LA_p3=4n ULP=0 ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n
+ m_n1=1 m_n2=1 m_n3=1 m_p1=1 m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1
+ nf_p2=1 nf_p3=1 wn1=120n wn2=120n wn3=120n wp1=120n wp2=120n wp3=120n
MNA1 X A1 net19 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 net19 A2 net018 VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2
+ w=wn2 m=m_n2
MNA3 net018 A3 VSS VBN slvtnfet cpp=cpp p_la=p_la_n3 ulp=ulp nf=nf_n3 l=ln3
+ w=wn3 m=m_n3
MPA1 X A1 VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MPA3 X A3 VDD VBP slvtpfet cpp=cpp p_la=p_la_p3 ulp=ulp nf=nf_p3 l=lp3 w=wp3
+ m=m_p3
MPA2 X A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
.ends

.subckt mm17a04_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 VDD VSS VBP VBN X A S0
+ S1 CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=120n wn2=120n wp1=120n wp2=120n
MNA net020 A VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MNS0 X S0 net020 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MPA net16 A VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MPS1 X S1 net16 VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
.ends

.subckt mm17a04_u_blatch_rm VDDPI VNWP VSS VBP VBN OUT OUTB CB CT IN
XI0 VDDPI VSS VBP VBN OUTB IN CB CT
+ mm17a04_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XI1 VDDPI VSS VBP VBN OUTB OUT CT CB
+ mm17a04_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
*XI39 VBP VBN OUTB mm17a04_u_init1
XI2 VDDPI VSS VBP VBN OUT OUTB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
.ends

.subckt mm17a04_u_rmmx VDDP VDDPI VSS VBP VBN QB A BCB BCT TA
XA VDDPI VSS VBP VBN QB A BCB BCT
+ mm17a04_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XTA VDDPI VSS VBP VBN QB TA BCT BCB
+ mm17a04_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
.ends

.subckt mm17a04_u_rm2to4 VDDP VDDPI VSS VBP VBN SEL_RM0 SEL_RM0123 SEL_RM0B
+ SEL_RM1 SEL_RM1B SEL_RM2 SEL_RM2B SEL_RM3 SEL_RM3B SEL_RM4 SEL_RM5 LCLKB
+ LCLKT RM[0] RM[1] RM[2] RME RMENI[0] RMENI[1] RMENI[2]
XI75 VDDPI VSS VBP VBN SEL_RM0123 LRM[2] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI80 VDDPI VSS VBP VBN SEL_RM3B SEL_RM3 mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI74 VDDPI VSS VBP VBN SEL_RM4 SEL_RM4B mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI4 VDDPI VSS VBP VBN SEL_RM0 SEL_RM0B mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI61 VDDPI VSS VBP VBN RMEB RME mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI68 VDDPI VSS VBP VBN SEL_RM1 SEL_RM1B mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI72 VDDPI VSS VBP VBN SEL_RM2 SEL_RM2B mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI78 VDDPI VSS VBP VBN SEL_RM1B LRM[0] LRMB[1] LRMB[2]
+ mm17a04_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=259n
+ wn2=259n wn3=259n wp1=120n wp2=120n wp3=120n
XI79 VDDPI VSS VBP VBN SEL_RM0B LRMB[0] LRMB[1] LRMB[2]
+ mm17a04_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=259n
+ wn2=259n wn3=259n wp1=120n wp2=120n wp3=120n
XI77 VDDPI VSS VBP VBN net229 LRM[0] LRM[1] LRMB[2]
+ mm17a04_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=259n
+ wn2=259n wn3=259n wp1=120n wp2=120n wp3=120n
XI71 VDDPI VSS VBP VBN SEL_RM2B LRMB[0] LRM[1] LRMB[2]
+ mm17a04_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=259n
+ wn2=259n wn3=259n wp1=120n wp2=120n wp3=120n
XI76 VDDPI VSS VBP VBN SEL_RM4B LRMB[0] LRMB[1] LRM[2]
+ mm17a04_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=259n
+ wn2=259n wn3=259n wp1=170n wp2=170n wp3=170n
MNA SEL_RM5 LRMB[1] net169 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=259n m=1
MI56 SEL_RM5 LRMB[2] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=259n
+ m=1
MI55 net169 LRMB[0] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=259n
+ m=1
XLRM1 VDDPI VDDP VSS VBP VBN LRMB[1] LRM[1] LCLKB LCLKT RM_RMI[1]
+ mm17a04_u_blatch_rm
XLRM0 VDDPI VDDP VSS VBP VBN LRMB[0] LRM[0] LCLKB LCLKT RM_RMI[0]
+ mm17a04_u_blatch_rm
XLRM2 VDDPI VDDP VSS VBP VBN LRMB[2] LRM[2] LCLKB LCLKT RM_RMI[2]
+ mm17a04_u_blatch_rm
XIRM_RMI0 VDDP VDDPI VSS VBP VBN RM_RMI[0] RM[0] RME RMEB RMENI[0]
+ mm17a04_u_rmmx
XIRM_RMI1 VDDP VDDPI VSS VBP VBN RM_RMI[1] RM[1] RME RMEB RMENI[1]
+ mm17a04_u_rmmx
XIRM_RMI2 VDDP VDDPI VSS VBP VBN RM_RMI[2] RM[2] RME RMEB RMENI[2]
+ mm17a04_u_rmmx
MI57 net163 LRMB[0] SEL_RM5 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=170n m=1
MI58 net163 LRMB[1] SEL_RM5 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=170n m=1
MPA VDDPI LRMB[2] net163 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=170n
+ m=1
XI69 VDDPI VSS VBP VBN SEL_RM3 net229 LRMB[2]
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
.ends

.subckt mm17a04_u_rm4to1 VDDP VDDPI VSS VBP VBN AT BT CT DT A B C D SEL[0]
+ SEL[1]
*XI8 VBP VBN net39 mm17a04_u_init1
*XI9 VBP VBN net40 mm17a04_u_init0
XI1 VBP VBN B BT SEL[1] SEL[0] mm17a04_u_tg_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
XI0 VBP VBN A AT SEL[1] SEL[0] mm17a04_u_tg_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
XI2 VBP VBN C CT SEL[1] SEL[0] mm17a04_u_tg_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
XI3 VBP VBN D DT SEL[1] SEL[0] mm17a04_u_tg_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
.ends

.subckt mm17a04_u_hdrf2p_rm3to6_rmmux VDDP VDDPI VSS VBP VBN DEF1 DEF1B DEF2
+ DEF2B DEF_MODE FAST1_MODE FAST2_MODE RT_BUF[0] RT_BUF[1] RT_BUF[2] RT_BUF[3]
+ LOG1RM_VDDPI DEF12B_PGM DEF12_PGM DLYPW LCLKB LCLKT PROCOM[1] PROCOM00[0]
+ PROCOM00[1] PROCOM01[0] PROCOM01[1] PROCOMB[1] RM[0] RM[1] RM[2] RMDEF1[0]
+ RMDEF1[1] RMDEF1[2] RMDEF1[3] RMDEF12_PROCOM00[0] RMDEF12_PROCOM00[1]
+ RMDEF12_PROCOM00[2] RMDEF12_PROCOM00[3] RMDEF12_PROCOM01[0]
+ RMDEF12_PROCOM01[1] RMDEF12_PROCOM01[2] RMDEF12_PROCOM01[3] RMDEF2[0]
+ RMDEF2[1] RMDEF2[2] RMDEF2[3] RME RMENI[0] RMENI[1] RMENI[2] RMSLOW[0]
+ RMSLOW[1] RMSLOW[2] RMSLOW[3]
XRT[0] LOG1RM_VDDPI VSS VBP VBN RT_BUF[0] RT[0] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=240n
XRT[1] LOG1RM_VDDPI VSS VBP VBN RT_BUF[1] RT[1] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=240n
XRT[2] LOG1RM_VDDPI VSS VBP VBN RT_BUF[2] RT[2] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=240n
XRT[3] LOG1RM_VDDPI VSS VBP VBN RT_BUF[3] RT[3] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=240n
XFAST2 VDDP VSS VBP VBN FAST2_MODE net375 mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=320n wp=320n
XDEF VDDPI VSS VBP VBN DEF_MODE net351 mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XDEFB VDDPI VSS VBP VBN net351 DEF_MODE_INT mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=320n wp=320n
XFAST1 VDDP VSS VBP VBN FAST1_MODE net373 mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=320n wp=320n
XI106 VDDP VBP VBN RT[0] RT[1] RT[2] RT[3] LOG1RM_VDDPI LOG1RM_VDDPI
+ LOG1RM_VDDPI LOG1RM_VDDPI VDDMINB mm17a04_u_rm4to1_pmos
XFAST1B VDDPI VSS VBP VBN net373 FAST1_MODE_INT DLYPW
+ mm17a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XFAST2B VDDPI VSS VBP VBN net375 FAST2_MODE_INT DLYPW
+ mm17a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI105 VDDPI VDDP VSS VBP VBN RT[0] RT[1] RT[2] RT[3] RMSLOW[0] RMSLOW[1]
+ RMSLOW[2] RMSLOW[3] SLOWB SLOW mm17a04_u_rm4to1_slow
XRM3TO6 VDDP VDDPI VSS VBP VBN VDDMIN DEF_MODE_INT VDDMINB SLOW SLOWB DEF2
+ DEF2B DEF1 DEF1B FAST1_MODE_INT FAST2_MODE_INT LCLKB LCLKT RM[0] RM[1] RM[2]
+ RME RMENI[0] RMENI[1] RMENI[2] mm17a04_u_rm2to4
XI146 VDDP VDDPI VSS VBP VBN RT[0] RT[1] RT[2] RT[3] RMDEF1[0] RMDEF1[1]
+ RMDEF1[2] RMDEF1[3] DEF1B DEF1 mm17a04_u_rm4to1
XI104 VDDP VDDPI VSS VBP VBN RT[0] RT[1] RT[2] RT[3] RMDEF2[0] RMDEF2[1]
+ RMDEF2[2] RMDEF2[3] DEF2B DEF2 mm17a04_u_rm4to1
.ends

.subckt mm17a04_u_hdrf2p_rmctrl VDDP VDDPI VSS VBP VBN DEF1B_RD DEF1B_WR
+ DEF1_RD DEF1_WR DEF2B_RD DEF2B_WR DEF2_RD DEF2_WR DEF_RD_MODE DEF_WR_MODE
+ FAST1_RD_MODE FAST1_WR_MODE FAST2_RD_MODE FAST2_WR_MODE RMTRD[0] RMTRD[1]
+ RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] TKEEPB LOG0
+ LOG1RMRD_VDDPI LOG1RMWR_VDDPI LOG1_RMRD LOG1_RMWR DEF12B_RD_PGM DEF12B_WR_PGM
+ DEF12_RD_PGM DEF12_WR_PGM DEF_RD_PGM DEF_WR_PGM DLYPW LCLKRDB LCLKRDT LCLKWRB
+ LCLKWRT PROCOM[0] PROCOM[1] RMDEF12_RD_PROCOM00[0] RMDEF12_RD_PROCOM00[1]
+ RMDEF12_RD_PROCOM00[2] RMDEF12_RD_PROCOM00[3] RMDEF12_RD_PROCOM01[0]
+ RMDEF12_RD_PROCOM01[1] RMDEF12_RD_PROCOM01[2] RMDEF12_RD_PROCOM01[3]
+ RMDEF12_WR_PROCOM00[0] RMDEF12_WR_PROCOM00[1] RMDEF12_WR_PROCOM00[2]
+ RMDEF12_WR_PROCOM00[3] RMDEF12_WR_PROCOM01[0] RMDEF12_WR_PROCOM01[1]
+ RMDEF12_WR_PROCOM01[2] RMDEF12_WR_PROCOM01[3] RMDEF1_RD[0] RMDEF1_RD[1]
+ RMDEF1_RD[2] RMDEF1_RD[3] RMDEF1_WR[0] RMDEF1_WR[1] RMDEF1_WR[2] RMDEF1_WR[3]
+ RMDEF2_RD[0] RMDEF2_RD[1] RMDEF2_RD[2] RMDEF2_RD[3] RMDEF2_WR[0] RMDEF2_WR[1]
+ RMDEF2_WR[2] RMDEF2_WR[3] RMENI_RD[0] RMENI_RD[1] RMENI_RD[2] RMENI_WR[0]
+ RMENI_WR[1] RMENI_WR[2] RMERD RMEWR RMRD[0] RMRD[1] RMRD[2] RMRD[3]
+ RMSLOW_RD[0] RMSLOW_RD[1] RMSLOW_RD[2] RMSLOW_RD[3] RMSLOW_WR[0] RMSLOW_WR[1]
+ RMSLOW_WR[2] RMSLOW_WR[3] RMWR[0] RMWR[1] RMWR[2] RMWR[3]
XI104 VDDPI VSS VBP VBN TKEEPB RMRD[3] mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI103 VDDPI VSS VBP VBN net496 RMWR[3] mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
MI151 VDDP LOG0 LOG1_RMRD VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
MI238 VDDP LOG0 LOG1_RMWR VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
XRM_WR VDDP VDDPI VSS VBP VBN DEF1_WR DEF1B_WR DEF2_WR DEF2B_WR DEF_WR_MODE
+ FAST1_WR_MODE FAST2_WR_MODE RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3]
+ LOG1RMWR_VDDPI DEF12B_WR_PGM DEF12_WR_PGM DLYPW LCLKWRB LCLKWRT PROCOMT_WR[1]
+ PROCOM00_WR[0] PROCOM00_WR[1] PROCOM01_WR[0] PROCOM01_WR[1] PROCOMB_WR[1]
+ RMWR[0] RMWR[1] RMWR[2] RMDEF1_WR[0] RMDEF1_WR[1] RMDEF1_WR[2] RMDEF1_WR[3]
+ RMDEF12_WR_PROCOM00[0] RMDEF12_WR_PROCOM00[1] RMDEF12_WR_PROCOM00[2]
+ RMDEF12_WR_PROCOM00[3] RMDEF12_WR_PROCOM01[0] RMDEF12_WR_PROCOM01[1]
+ RMDEF12_WR_PROCOM01[2] RMDEF12_WR_PROCOM01[3] RMDEF2_WR[0] RMDEF2_WR[1]
+ RMDEF2_WR[2] RMDEF2_WR[3] RMEWR RMENI_WR[0] RMENI_WR[1] RMENI_WR[2]
+ RMSLOW_WR[0] RMSLOW_WR[1] RMSLOW_WR[2] RMSLOW_WR[3]
+ mm17a04_u_hdrf2p_rm3to6_rmmux
XRM_RD VDDP VDDPI VSS VBP VBN DEF1_RD DEF1B_RD DEF2_RD DEF2B_RD DEF_RD_MODE
+ FAST1_RD_MODE FAST2_RD_MODE RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+ LOG1RMRD_VDDPI DEF12B_RD_PGM DEF12_RD_PGM DLYPW LCLKRDB LCLKRDT PROCOMT_RD[1]
+ PROCOM00_RD[0] PROCOM00_RD[1] PROCOM01_RD[0] PROCOM01_RD[1] PROCOMB_RD[1]
+ RMRD[0] RMRD[1] RMRD[2] RMDEF1_RD[0] RMDEF1_RD[1] RMDEF1_RD[2] RMDEF1_RD[3]
+ RMDEF12_RD_PROCOM00[0] RMDEF12_RD_PROCOM00[1] RMDEF12_RD_PROCOM00[2]
+ RMDEF12_RD_PROCOM00[3] RMDEF12_RD_PROCOM01[0] RMDEF12_RD_PROCOM01[1]
+ RMDEF12_RD_PROCOM01[2] RMDEF12_RD_PROCOM01[3] RMDEF2_RD[0] RMDEF2_RD[1]
+ RMDEF2_RD[2] RMDEF2_RD[3] RMERD RMENI_RD[0] RMENI_RD[1] RMENI_RD[2]
+ RMSLOW_RD[0] RMSLOW_RD[1] RMSLOW_RD[2] RMSLOW_RD[3]
+ mm17a04_u_hdrf2p_rm3to6_rmmux
.ends

.subckt mm17a04_u_log01_gen VDDP VNWP VSS VBP VBN LOG0
*XI11 VBP VBN always1 mm17a04_u_init1
XI10 VDDP VSS VBP VBN alway0 always1 mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
Xinv_1 VDDP VSS VBP VBN always1 ST0 mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
M0 LOG0 always1 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=2
M1 ST0 always1 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
M2 ST0 alway0 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
.ends

.subckt mm17a04_u_logrep_rf2p VDDP VNWP VSS VBP VBN LOG0 LOG1
MPLOG VDDP LOG0 LOG1 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=5
M0 LOG0 LOG1 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=5
.ends

.subckt mm17a04_u_blatch_ctrl_lsltch VDDPI VNWP VSS VBP VBN OUT OUTB CB CT IN
XI0 VDDPI VSS VBP VBN OUTB IN CB CT
+ mm17a04_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=180n wn2=180n
+ wp1=180n wp2=180n
XI1 VDDPI VSS VBP VBN OUTB OUT CT CB
+ mm17a04_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
*XI8 VBP VBN OUTB VDDPI mm17a04_u_lat_set_op_pfv
XI2 VDDPI VSS VBP VBN OUT OUTB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
.ends

.subckt mm17a04_u_hdrf2p_lsltch VDDP VDDPI VSS VBP VBN LITESLP LWMEB RWLCKB LS
+ MEWR RFLOAT WFLOAT
XLSLTCH VDDPI VDDP VSS VBP VBN LLS LLSB RWLCKB RWLCKT LS
+ mm17a04_u_blatch_ctrl_lsltch
XRWME VDDPI VDDP VSS VBP VBN net168 LWEN WLCKB WLCKT WMEB
+ mm17a04_u_blatch_ctrl_lsltch
XI63 VDDPI VSS VBP VBN LWMEB LLSB LLSB
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=240n
+ wp2=240n
XI42 VDDPI VSS VBP VBN RWLCKT WFLOAT RFLOAT
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=120n
+ wp2=120n
XI76 VDDPI VSS VBP VBN LITESLP LLSB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI71 VDDPI VSS VBP VBN WLCKT WFLOAT mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI67 VDDP VSS VBP VBN WLCKB WLCKT mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI59 VDDPI VSS VBP VBN WMEB MEWR mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI41 VDDP VSS VBP VBN RWLCKB RWLCKT mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=320n
.ends

.subckt mm17a04_u_hdrf2p_gcen VDDP VDDPI VSS VBP VBN CKGATE_RD CLKDELRD
+ CLKDELWR CLKRDB CLKWRB DCKBIO_L DCKBIO_R DEF1B_RD DEF1B_WR DEF1_RD DEF1_WR
+ DEF2B_RD DEF2B_WR DEF2_RD DEF2_WR DEF_RD_MODE DEF_WR_MODE FAST1_RD_MODE
+ FAST1_WR_MODE FAST2_RD_MODE FAST2_WR_MODE LCLKRDB LCLKRDT LCLKWRB LCLKWRT
+ LCLKWRT_DEL_2 LCLKWRT_DEL_4 LITESLP LMERD LMEWR LRWMEB LWE LXADRBRD[0]
+ LXADRBRD[1] LXADRBRD[2] LXADRBRD[3] LXADRBRD[4] LXADRBRD[5] LXADRBRD[6]
+ LXADRBRD[7] LXADRBWR[0] LXADRBWR[1] LXADRBWR[2] LXADRBWR[3] LXADRBWR[4]
+ LXADRBWR[5] LXADRBWR[6] LXADRBWR[7] LXADRRD[0] LXADRRD[1] LXADRRD[2]
+ LXADRRD[3] LXADRRD[4] LXADRRD[5] LXADRRD[6] LXADRRD[7] LXADRWR[0] LXADRWR[1]
+ LXADRWR[2] LXADRWR[3] LXADRWR[4] LXADRWR[5] LXADRWR[6] LXADRWR[7] LYADRBRD[0]
+ LYADRBRD[1] LYADRBWR[0] LYADRBWR[1] LYADRRD[0] LYADRRD[1] LYADRWR[0]
+ LYADRWR[1] MCLKRDB MCLKRDT MCLKWRB MCLKWRT RABUF[0] RABUF[1] RFLOAT RMTRD[0]
+ RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLCKB STRSB
+ T1TRD T1TWR TKEEPB WABUF[0] WABUF[1] WABUF[2] WFLOAT WPBUF[0] WPBUF[1]
+ WPBUF[2] YSELIO[0] YSELIO[1] YSELIO[2] YSELIO[3] YSELRD[0] YSELRD[1]
+ YSELRD[2] YSELRD[3] ARYSD CENDP FISO LOG0 LOG1 LOG1RMRD_VDDPI LOG1RMWR_VDDPI
+ LOG1_RMRD LOG1_RMWR RSCEN RSCIN RSCLK RSCOUT RSCRST YCOLRD[0] YCOLRD[1]
+ YCOLRD[2] YCOLRD[3] CLKFLTRD CLKFLTWR CLKMXB_RD CLKMXB_WR CLKRD CLKWR
+ CLPSEBUF DEF12B_RD_PGM DEF12B_WR_PGM DEF12_RD_PGM DEF12_WR_PGM DEF_RD_PGM
+ DEF_WR_PGM DFTCKRD DFTCKWR DFT_OR_SERD DFT_OR_SEWR DLYPW DSORSD LCLKWRT_prog
+ LME_GATING_RD LME_GATING_WR LS MERD MEWR OPT_Y[0] OPT_Y[1] OPT_Y[2] OPT_Y[3]
+ PROCOM[0] PROCOM[1] RA[0] RA[1] RFLT_RET RMDEF12_RD_PROCOM00[0]
+ RMDEF12_RD_PROCOM00[1] RMDEF12_RD_PROCOM00[2] RMDEF12_RD_PROCOM00[3]
+ RMDEF12_RD_PROCOM01[0] RMDEF12_RD_PROCOM01[1] RMDEF12_RD_PROCOM01[2]
+ RMDEF12_RD_PROCOM01[3] RMDEF12_WR_PROCOM00[0] RMDEF12_WR_PROCOM00[1]
+ RMDEF12_WR_PROCOM00[2] RMDEF12_WR_PROCOM00[3] RMDEF12_WR_PROCOM01[0]
+ RMDEF12_WR_PROCOM01[1] RMDEF12_WR_PROCOM01[2] RMDEF12_WR_PROCOM01[3]
+ RMDEF1_RD[0] RMDEF1_RD[1] RMDEF1_RD[2] RMDEF1_RD[3] RMDEF1_WR[0] RMDEF1_WR[1]
+ RMDEF1_WR[2] RMDEF1_WR[3] RMDEF2_RD[0] RMDEF2_RD[1] RMDEF2_RD[2] RMDEF2_RD[3]
+ RMDEF2_WR[0] RMDEF2_WR[1] RMDEF2_WR[2] RMDEF2_WR[3] RMENI_RD[0] RMENI_RD[1]
+ RMENI_RD[2] RMENI_WR[0] RMENI_WR[1] RMENI_WR[2] RMERD RMEWR RMRD[0] RMRD[1]
+ RMRD[2] RMRD[3] RMSLOW_RD[0] RMSLOW_RD[1] RMSLOW_RD[2] RMSLOW_RD[3]
+ RMSLOW_WR[0] RMSLOW_WR[1] RMSLOW_WR[2] RMSLOW_WR[3] RMWR[0] RMWR[1] RMWR[2]
+ RMWR[3] TEST1RD TEST1WR TEST_RNM WA[0] WA[1] WE WFLT_RET WP[0] WP[1] WP[2]
+ XADRRD[0] XADRRD[1] XADRRD[2] XADRRD[3] XADRRD[4] XADRRD[5] XADRRD[6]
+ XADRRD[7] XADRWR[0] XADRWR[1] XADRWR[2] XADRWR[3] XADRWR[4] XADRWR[5]
+ XADRWR[6] XADRWR[7] YADRRD[0] YADRRD[1] YADRWR[0] YADRWR[1]
XRDGCEN VDDP VDDPI VSS VBP VBN CKGATE_RD CLKRDB CLKDELRD RFLOAT RFLOATT LCLKRDB
+ LCLKRDT LMERD LXADRRD[0] LXADRRD[1] LXADRRD[2] LXADRRD[3] LXADRRD[4]
+ LXADRRD[5] LXADRRD[6] LXADRRD[7] LXADRBRD[0] LXADRBRD[1] LXADRBRD[2]
+ LXADRBRD[3] LXADRBRD[4] LXADRBRD[5] LXADRBRD[6] LXADRBRD[7] LYADRRD[0]
+ LYADRRD[1] LYADRBRD[0] LYADRBRD[1] MCLKRDB MCLKRDT T1TRD YSELRD[0] YSELRD[1]
+ YSELRD[2] YSELRD[3] YSELIO[0] YSELIO[1] YSELIO[2] YSELIO[3] LOG1 CLKRD
+ CLKFLTRD CLKMXB_RD CLPSEBUF DFTCKRD DFT_OR_SERD DLYPW DSORSD RFLT_RET LOG0
+ LME_GATING_RD LS MERD OPT_Y[0] OPT_Y[1] OPT_Y[2] OPT_Y[3] TEST1RD XADRRD[0]
+ XADRRD[1] XADRRD[2] XADRRD[3] XADRRD[4] XADRRD[5] XADRRD[6] XADRRD[7]
+ YADRRD[0] YADRRD[1] mm17a04_u_hdrf2p_rdgcen
XWRGCEN VDDP VDDPI VSS VBP VBN CLKWRB CLKDELWR DCKBIO_L DCKBIO_R WFLOAT WFLOATT
+ LCLKWRB LCLKWRT LCLKWRT_DEL_2 LCLKWRT_DEL_4 LMEWR LWE LXADRWR[0] LXADRWR[1]
+ LXADRWR[2] LXADRWR[3] LXADRWR[4] LXADRWR[5] LXADRWR[6] LXADRWR[7] LXADRBWR[0]
+ LXADRBWR[1] LXADRBWR[2] LXADRBWR[3] LXADRBWR[4] LXADRBWR[5] LXADRBWR[6]
+ LXADRBWR[7] LYADRWR[0] LYADRWR[1] LYADRBWR[0] LYADRBWR[1] MCLKWRB MCLKWRT
+ T1TWR CLKWR CLKFLTWR CLKMXB_WR CLPSEBUF DFTCKWR DFT_OR_SEWR DLYPW DSORSD
+ WFLT_RET LCLKWRT_prog LOG0 LME_GATING_WR LS MEWR TEST1WR WE XADRWR[0]
+ XADRWR[1] XADRWR[2] XADRWR[3] XADRWR[4] XADRWR[5] XADRWR[6] XADRWR[7]
+ YADRWR[0] YADRWR[1] mm17a04_u_hdrf2p_wrgcen
XBC VDDP VDDPI VDDP VSS VBP VBN net1475 net1473 net1474 RABUF[0] RABUF[1] STRSB
+ WABUF[0] WABUF[1] WABUF[2] WPBUF[0] WPBUF[1] WPBUF[2] net1476 net1477 LOG0
+ RA[0] RA[1] net1478 TEST_RNM WA[0] WA[1] WP[0] WP[1] WP[2]
+ mm17a04_u_hdrf2p_bcctrl
XRMCTRL VDDP VDDPI VSS VBP VBN DEF1B_RD DEF1B_WR DEF1_RD DEF1_WR DEF2B_RD
+ DEF2B_WR DEF2_RD DEF2_WR DEF_RD_MODE DEF_WR_MODE FAST1_RD_MODE FAST1_WR_MODE
+ FAST2_RD_MODE FAST2_WR_MODE RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0]
+ RMTWR[1] RMTWR[2] RMTWR[3] TKEEPB LOG0 LOG1RMRD_VDDPI LOG1RMWR_VDDPI
+ LOG1_RMRD LOG1_RMWR DEF12B_RD_PGM DEF12B_WR_PGM DEF12_RD_PGM DEF12_WR_PGM
+ DEF_RD_PGM DEF_WR_PGM DLYPW LCLKRDB LCLKRDT LCLKWRB LCLKWRT PROCOM[0]
+ PROCOM[1] RMDEF12_RD_PROCOM00[0] RMDEF12_RD_PROCOM00[1]
+ RMDEF12_RD_PROCOM00[2] RMDEF12_RD_PROCOM00[3] RMDEF12_RD_PROCOM01[0]
+ RMDEF12_RD_PROCOM01[1] RMDEF12_RD_PROCOM01[2] RMDEF12_RD_PROCOM01[3]
+ RMDEF12_WR_PROCOM00[0] RMDEF12_WR_PROCOM00[1] RMDEF12_WR_PROCOM00[2]
+ RMDEF12_WR_PROCOM00[3] RMDEF12_WR_PROCOM01[0] RMDEF12_WR_PROCOM01[1]
+ RMDEF12_WR_PROCOM01[2] RMDEF12_WR_PROCOM01[3] RMDEF1_RD[0] RMDEF1_RD[1]
+ RMDEF1_RD[2] RMDEF1_RD[3] RMDEF1_WR[0] RMDEF1_WR[1] RMDEF1_WR[2] RMDEF1_WR[3]
+ RMDEF2_RD[0] RMDEF2_RD[1] RMDEF2_RD[2] RMDEF2_RD[3] RMDEF2_WR[0] RMDEF2_WR[1]
+ RMDEF2_WR[2] RMDEF2_WR[3] RMENI_RD[0] RMENI_RD[1] RMENI_RD[2] RMENI_WR[0]
+ RMENI_WR[1] RMENI_WR[2] RMERD RMEWR RMRD[0] RMRD[1] RMRD[2] RMRD[3]
+ RMSLOW_RD[0] RMSLOW_RD[1] RMSLOW_RD[2] RMSLOW_RD[3] RMSLOW_WR[0] RMSLOW_WR[1]
+ RMSLOW_WR[2] RMSLOW_WR[3] RMWR[0] RMWR[1] RMWR[2] RMWR[3]
+ mm17a04_u_hdrf2p_rmctrl
XLOG0 VDDP VDDP VSS VBP VBN LOG0 mm17a04_u_log01_gen
XI370 VDDP VDDP VSS VBP VBN LOG0 LOG1 mm17a04_u_logrep_rf2p
XLSLTCH VDDP VDDPI VSS VBP VBN LITESLP LRWMEB RWLCKB LS MEWR RFLOAT WFLOAT
+ mm17a04_u_hdrf2p_lsltch
.ends

.subckt mm17a04_u_hdrf2p_gcenbuf VDDA VDDP VDDPI VSS VBP VBN DCLKT RASSB[0]
+ RASSB[1] SE_DB SE_DT YSELB[0] YSELB[1] YSELB[2] YSELB[3] LOG0 LOG1 DCKBIO
+ DLYPDB LCLKB LCLKT RABUF[0] RABUF[1] SEDB SEDT YSELIO[0] YSELIO[1] YSELIO[2]
+ YSELIO[3]
XI101 VDDPI VSS VBP VBN SE_DT SEDB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1 wn=280n
+ wp=360n
XI104 VDDPI VSS VBP VBN SE_DB SEDT mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1 wn=280n
+ wp=360n
XI96[0] VDDPI VSS VBP VBN RASSB[0] net169[0] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1
+ wn=280n wp=360n
XI96[1] VDDPI VSS VBP VBN RASSB[1] net169[1] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1
+ wn=280n wp=360n
XI109[0] VDDP VSS VBP VBN YSELB[0] YSELT[0] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1
+ wn=280n wp=360n
XI109[1] VDDP VSS VBP VBN YSELB[1] YSELT[1] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1
+ wn=280n wp=360n
XI109[2] VDDP VSS VBP VBN YSELB[2] YSELT[2] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1
+ wn=280n wp=360n
XI109[3] VDDP VSS VBP VBN YSELB[3] YSELT[3] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1
+ wn=280n wp=360n
XI115[0] VDDPI VSS VBP VBN net169[0] RABUF[0] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI115[1] VDDPI VSS VBP VBN net169[1] RABUF[1] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI113[0] VDDPI VSS VBP VBN YSELT[0] YSELBB[0] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI113[1] VDDPI VSS VBP VBN YSELT[1] YSELBB[1] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI113[2] VDDPI VSS VBP VBN YSELT[2] YSELBB[2] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI113[3] VDDPI VSS VBP VBN YSELT[3] YSELBB[3] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI64 VDDPI VSS VBP VBN DCLKT DCKBIO mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1 wn=240n
+ wp=320n
XI119[0] VDDP VSS VBP VBN YSELBB[0] YSELIO[0] DLYPDB
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=240n
+ wp2=240n
XI119[1] VDDP VSS VBP VBN YSELBB[1] YSELIO[1] DLYPDB
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=240n
+ wp2=240n
XI119[2] VDDP VSS VBP VBN YSELBB[2] YSELIO[2] DLYPDB
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=240n
+ wp2=240n
XI119[3] VDDP VSS VBP VBN YSELBB[3] YSELIO[3] DLYPDB
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=240n
+ wp2=240n
.ends

.subckt mm17a04_u_hdrf2p_l2bio VDDPI VNWP VSS VBP VBN Q QB CB CT DIN
XI7 VDDPI VSS VBP VBN Q QB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
XI3 VDDPI VSS VBP VBN QB Q CT CB
+ mm17a04_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XI11 VDDPI VSS VBP VBN QB DIN CB CT
+ mm17a04_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
.ends

.subckt mm17a04_u_hdrf2p_di VDDPI VNWP VSS VBP VBN D_AL LDIB WBI WEM_AL WTI
+ DIB_LT CB CT DIN DINB SE_DB SE_DT WEM WEMB
XI15 VDDPI VSS VBP VBN DWEMB net143 net142
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=288n wn2=288n wp1=120n
+ wp2=120n
XI16 VDDPI VSS VBP VBN DWEMT DINB net142
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=160n
+ wp2=160n
XW VDDPI VNWP VSS VBP VBN LWIB WB CB CT WIB mm17a04_u_hdrf2p_l2bio
XD VDDPI VNWP VSS VBP VBN LDIB WT CB CT DIB_LT mm17a04_u_hdrf2p_l2bio
XI44 VDDPI VSS VBP VBN net142 WEMB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI14 VDDPI VSS VBP VBN WEM_AL WEM mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI5 VDDPI VSS VBP VBN D_AL DIN mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI4 VDDPI VSS VBP VBN WBI WT mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n wp=240n
XI28 VDDPI VSS VBP VBN net143 DINB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI30 VDDPI VSS VBP VBN WIB DWEMB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=288n
+ wp=320n
XI20 VDDPI VSS VBP VBN WTI WB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n wp=240n
XI26 VDDPI VSS VBP VBN DIB_LT DWEMT SE_DB SE_DT
+ mm17a04_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n
+ wp1=160n wp2=160n
.ends

.subckt
+ mm17a04_u_nd4_bulk_n1_vt2_n2_vt2_n3_vt2_n4_vt2_p1_vt2_p2_vt2_p3_vt2_p4_vt2
+ VDD VSS VBP VBN X A1 A2 A3 A4 CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_n3=4n
+ P_LA_n4=4n P_LA_p1=4n P_LA_p2=4n P_LA_p3=4n P_LA_p4=4n ULP=0 ln1=20n ln2=20n
+ ln3=20n ln4=20n lp1=20n lp2=20n lp3=20n lp4=20n m_n1=1 m_n2=1 m_n3=1 m_n4=1
+ m_p1=1 m_p2=1 m_p3=1 m_p4=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_n4=1 nf_p1=1 nf_p2=1
+ nf_p3=1 nf_p4=1 wn1=800n wn2=800n wn3=800n wn4=800n wp1=120n wp2=120n
+ wp3=120n wp4=120n
MNA1 X A1 net19 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 net19 A2 net018 VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2
+ w=wn2 m=m_n2
MNA3 net018 A3 net024 VBN slvtnfet cpp=cpp p_la=p_la_n3 ulp=ulp nf=nf_n3 l=ln3
+ w=wn3 m=m_n3
MNA4 net024 A4 VSS VBN slvtnfet cpp=cpp p_la=p_la_n4 ulp=ulp nf=nf_n4 l=ln4
+ w=wn4 m=m_n4
MPA1 X A1 VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MPA4 X A4 VDD VBP slvtpfet cpp=cpp p_la=p_la_p4 ulp=ulp nf=nf_p4 l=lp4 w=wp4
+ m=m_p4
MPA2 X A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
MPA3 X A3 VDD VBP slvtpfet cpp=cpp p_la=p_la_p3 ulp=ulp nf=nf_p3 l=lp3 w=wp3
+ m=m_p3
.ends

.subckt mm17a04_u_output_drv VDDP VDDPI VSS VBP VBN Q_OUT Q_IN
XI4 VDDPI VSS VBP VBN Q_OUT Q_IN mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=163n
+ wp=240n
.ends

.subckt mm17a04_u_hdrf2p_do VDDP VDDPI VSS VBP VBN Q LQB DFTBIO DFTBIOB NOFF
+ POFF
MI75 net215 POFF net192 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n
+ m=1
MI76 net192 IFF LQB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n m=1
MI85 VDDP DFTBIO net215 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n
+ m=1
XI31 VDDP VSS VBP VBN IFF LQB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=160n wp=160n
MI80 net198 NOFF net211 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n
+ m=1
MI77 LQB IFF net198 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n m=1
MI84 net211 DFTBIOB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n
+ m=1
XI86 VDDP VDDPI VSS VBP VBN Q LQB mm17a04_u_output_drv
.ends

.subckt mm17a04_u_hdrf2p_resolver VDDP VDDPI VSS VBP VBN LQB YSELPIB QT YSELPI
MI115 LQB YSELPIB net310 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=165n
+ m=2
MI117 net310 QT VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=165n m=2
MI113 VDDP QT LQB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=4
XI119 VDDPI VSS VBP VBN YSELPIB YSELPI mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
.ends

.subckt mm17a04_u_dclk_ct_cb_gen VDDPI VSS VBP VBN CB CT DCLK
XI2 VDDPI VSS VBP VBN CB CT mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=240n wp=240n
XI1 VDDPI VSS VBP VBN CT DCLKB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI0 VDDPI VSS VBP VBN DCLKB DCLK mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
.ends

.subckt mm17a04_u_hdrf2p_giom2x2 VDDP VDDPI VSS VBP VBN D_AL[0] D_AL[1] LDIB[0]
+ LDIB[1] Q[0] Q[1] WBI[0] WBI[1] WEM_AL[0] WEM_AL[1] WTI[0] WTI[1] CB CT
+ DIB_LT[0] DIB_LT[1] LOG0 LOG1 LQB[0] LQB[1] RASSB[0] RASSB[1] D[0] D[1] DCLKT
+ DFTBIO DFTBIOB DINB[0] DINB[1] QT[0] QT[1] QT[2] QT[3] SE_DB SE_DT WEM[0]
+ WEM[1] WEMB[0] WEMB[1] YSELB[0] YSELB[1] YSELB[2] YSELB[3]
XDI[0] VDDPI VDDP VSS VBP VBN D_AL[0] LDIB[0] WBI[0] WEM_AL[0] WTI[0] DIB_LT[0]
+ CB CT D[0] DINB[0] SE_DB SE_DT WEM[0] WEMB[0] mm17a04_u_hdrf2p_di
XDI[1] VDDPI VDDP VSS VBP VBN D_AL[1] LDIB[1] WBI[1] WEM_AL[1] WTI[1] DIB_LT[1]
+ CB CT D[1] DINB[1] SE_DB SE_DT WEM[1] WEMB[1] mm17a04_u_hdrf2p_di
XI28 VDDPI VSS VBP VBN POFF YSELB[0] YSELB[1] YSELB[2] YSELB[3]
+ mm17a04_u_nd4_bulk_n1_vt2_n2_vt2_n3_vt2_n4_vt2_p1_vt2_p2_vt2_p3_vt2_p4_vt2
+ cpp=104n p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_n4=4n p_la_p1=4n p_la_p2=4n
+ p_la_p3=4n p_la_p4=4n ulp=0 ln1=20n ln2=20n ln3=20n ln4=20n lp1=20n lp2=20n
+ lp3=20n lp4=20n m_n1=1 m_n2=1 m_n3=1 m_n4=1 m_p1=1 m_p2=1 m_p3=1 m_p4=1
+ nf_n1=1 nf_n2=1 nf_n3=1 nf_n4=1 nf_p1=1 nf_p2=1 nf_p3=1 nf_p4=1 wn1=120n
+ wn2=120n wn3=120n wn4=120n wp1=120n wp2=120n wp3=120n wp4=120n
XDO[0] VDDP VDDPI VSS VBP VBN Q[0] LQB[0] DFTBIO DFTBIOB NOFF[0] POFF
+ mm17a04_u_hdrf2p_do
XDO[1] VDDP VDDPI VSS VBP VBN Q[1] LQB[1] DFTBIO DFTBIOB NOFF[1] POFF
+ mm17a04_u_hdrf2p_do
XQTMUX[0] VDDP VDDPI VSS VBP VBN LQB[0] YSELPIB[0] QT[0] YSELB[0]
+ mm17a04_u_hdrf2p_resolver
XQTMUX[1] VDDP VDDPI VSS VBP VBN LQB[0] YSELPIB[1] QT[1] YSELB[1]
+ mm17a04_u_hdrf2p_resolver
XQTMUX[2] VDDP VDDPI VSS VBP VBN LQB[1] YSELPIB[2] QT[2] YSELB[2]
+ mm17a04_u_hdrf2p_resolver
XQTMUX[3] VDDP VDDPI VSS VBP VBN LQB[1] YSELPIB[3] QT[3] YSELB[3]
+ mm17a04_u_hdrf2p_resolver
XI29 VDDPI VSS VBP VBN CB CT DCLKT mm17a04_u_dclk_ct_cb_gen
XI27[0] VDDPI VSS VBP VBN NOFF[0] NOFF_B[0] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI27[1] VDDPI VSS VBP VBN NOFF[1] NOFF_B[1] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI26[0] VDDPI VSS VBP VBN NOFF_B[0] QT[0] QT[1]
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI26[1] VDDPI VSS VBP VBN NOFF_B[1] QT[2] QT[3]
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
.ends

.subckt mm17a04_u_hdrf2p_gcenrebuf VDDA VDDP VDDPI VSS VBP VBN REDCLKT
+ RERASSB[0] RERASSB[1] RESE_DB RESE_DT REYSELB[0] REYSELB[1] REYSELB[2]
+ REYSELB[3] LOG0 LOG1 DCLKT RASSB[0] RASSB[1] SE_DB SE_DT YSELB[0] YSELB[1]
+ YSELB[2] YSELB[3]
XI101 VDDPI VSS VBP VBN RESE_DT SE_DB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=640n
+ wp=640n
XI104 VDDPI VSS VBP VBN RESE_DB SE_DT mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=640n
+ wp=640n
XI115[0] VDDPI VSS VBP VBN net160[0] RASSB[0] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI115[1] VDDPI VSS VBP VBN net160[1] RASSB[1] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI113 VDDPI VSS VBP VBN net150 DCLKT mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=480n
+ wp=320n
XI109[0] VDDP VSS VBP VBN REYSELB[0] net152[0] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=480n wp=720n
XI109[1] VDDP VSS VBP VBN REYSELB[1] net152[1] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=480n wp=720n
XI109[2] VDDP VSS VBP VBN REYSELB[2] net152[2] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=480n wp=720n
XI109[3] VDDP VSS VBP VBN REYSELB[3] net152[3] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=480n wp=720n
XI114[0] VDDPI VSS VBP VBN net152[0] YSELB[0] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=320n wp=240n
XI114[1] VDDPI VSS VBP VBN net152[1] YSELB[1] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=320n wp=240n
XI114[2] VDDPI VSS VBP VBN net152[2] YSELB[2] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=320n wp=240n
XI114[3] VDDPI VSS VBP VBN net152[3] YSELB[3] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=320n wp=240n
XI96[0] VDDPI VSS VBP VBN RERASSB[0] net160[0] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=640n wp=640n
XI96[1] VDDPI VSS VBP VBN RERASSB[1] net160[1] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=640n wp=640n
XI64 VDDPI VSS VBP VBN REDCLKT net150 mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1 wn=240n
+ wp=320n
.ends

.subckt mm17a04_u_hdrf2p_capgio VDDA VDDP VDDPI VSS VBP VBN LOG0 LOG1 PWDO
+ VEDGE
XLOGREP VDDP VDDP VSS VBP VBN LOG0 LOG1 mm17a04_u_logrep_rf2p
.ends

.subckt mm17a04_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=120n wn2=120n wp1=240n wp2=240n
MNA1 X A1 VSS VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 X A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MPA2 net10 A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2
+ w=wp2 m=m_p2
MPA1 X A1 net10 VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
.ends

.subckt mm17a04_u_hdrf2p_WACLK_PG_DELAY VDDPI VNWP VSS VBP VBN TAP1 TAP2 TAP3
+ PRCLK_INT
XI56 VDDPI VSS VBP VBN net41 TAP1 TAP1 TAP1
+ mm17a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XI55 VDDPI VSS VBP VBN TAP2 net41 net41 net41
+ mm17a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XI54 VDDPI VSS VBP VBN net32 PRCLK_INT PRCLK_INT PRCLK_INT
+ mm17a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XI58 VDDPI VSS VBP VBN net43 TAP2 TAP2 TAP2
+ mm17a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XI53 VDDPI VSS VBP VBN TAP1 net32 net32 net32
+ mm17a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XI57 VDDPI VSS VBP VBN TAP3 net43 net43 net43
+ mm17a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
.ends

.subckt mm17a04_u_tg_bulk_n_vt3_p_vt3 VBP VBN A B S SB CPP=104n P_LA_n=4n
+ P_LA_p=4n ULP=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
MNS A S B VBN slvtnfet cpp=cpp p_la=p_la_n ulp=ulp nf=nf_n l=ln w=wn m=m_n
MPSB A SB B VBP slvtpfet cpp=cpp p_la=p_la_p ulp=ulp nf=nf_p l=lp w=wp m=m_p
.ends

.subckt mm17a04_u_hdrf2p_WACLK_DELAY VDDPI VNWP VSS VBP VBN WAPRCLK_OUT
+ WAPRCLK_IN WPBUFB[0] WPBUFB[1]
XI28 VDDPI VSS VBP VBN DB WP[0] WP[1]
+ mm17a04_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI25 VDDPI VSS VBP VBN CB WPBUFB[0] WP[1]
+ mm17a04_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI20 VDDPI VSS VBP VBN AB WPBUFB[0] WPBUFB[1]
+ mm17a04_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI23 VDDPI VSS VBP VBN BB WP[0] WPBUFB[1]
+ mm17a04_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI18[0] VDDPI VSS VBP VBN WP[0] WPBUFB[0] mm17a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI18[1] VDDPI VSS VBP VBN WP[1] WPBUFB[1] mm17a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI22 VDDPI VSS VBP VBN net2 DLY2 mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI21 VDDPI VSS VBP VBN DLY3 net2 mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI19 VDDPI VSS VBP VBN net4 DLY1 mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI15 VDDPI VSS VBP VBN net6 WAPRCLK_IN mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI16 VDDPI VSS VBP VBN DLY1 net6 mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI17 VDDPI VSS VBP VBN DLY2 net4 mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI24 VDDPI VSS VBP VBN B BB mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n wp=120n
XI4 VDDPI VSS VBP VBN A AB mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n wp=120n
XI26 VDDPI VSS VBP VBN C CB mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n wp=120n
XI27 VDDPI VSS VBP VBN D DB mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n wp=120n
XI31 VBP VBN DLY3 WAPRCLK_OUT D DB mm17a04_u_tg_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI30 VBP VBN DLY2 WAPRCLK_OUT C CB mm17a04_u_tg_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI29 VBP VBN DLY1 WAPRCLK_OUT B BB mm17a04_u_tg_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI33 VBP VBN WAPRCLK_IN WAPRCLK_OUT A AB mm17a04_u_tg_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
.ends

.subckt mm17a04_u_wa_ctrl_hc VDDPI VNWP VSS VBP VBN TAP[0] TAP[1] TAP[2] TAP[3]
+ WAPRCLK LWEIB PRCKDLY RBLWA STCLK WABUF[2] WPBUF[0] WPBUF[1] WPBUF[2]
XI17 VDDPI VSS VBP VBN WAPRCLK net92 TAP[0]
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=640n wn2=640n wp1=320n
+ wp2=320n
XI35 VDDPI VSS VBP VBN TAP[0] RBLWA WABUF[2]
+ mm17a04_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=480n
+ wp2=480n
XWADLY VDDPI VNWP VSS VBP VBN TAP[1] TAP[2] TAP[3] TAP[0]
+ mm17a04_u_hdrf2p_WACLK_PG_DELAY
XWPDLY VDDPI VNWP VSS VBP VBN net92 PRCKDLY WPBUF[0] WPBUF[1]
+ mm17a04_u_hdrf2p_WACLK_DELAY
.ends

.subckt mm17a04_u_hdrf2p_pred2to4_nd2_wa VDDP VDDPI VSS VBP VBN POUT[0] POUT[1]
+ POUT[2] POUT[3] A[0] A[1] AB[0] AB[1]
XI76 VDDPI VSS VBP VBN POUT[2] AB[0] A[1]
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=240n
+ wp2=240n
XI87 VDDPI VSS VBP VBN POUT[3] A[0] A[1]
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=240n
+ wp2=240n
XI77 VDDPI VSS VBP VBN POUT[0] AB[0] AB[1]
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=240n
+ wp2=240n
XI75 VDDPI VSS VBP VBN POUT[1] A[0] AB[1]
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=240n
+ wp2=240n
MI86 POUT[0] AB[0] net174 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
MI82 POUT[2] AB[0] net166 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
MI84 POUT[1] A[0] net170 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
MI81 net166 A[1] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
MI83 net170 AB[1] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
MI79 POUT[3] A[0] net161 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
MI85 net174 AB[1] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
MI80 net161 A[1] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
.ends

.subckt mm17a04_u_hdrf2p_pred2to4_wa VDDPI VNWP VSS VBP VBN POUT[0] POUT[1]
+ POUT[2] POUT[3] A[0] A[1] AB[0] AB[1]
XI72 VDDPI VSS VBP VBN POUT[1] AB[0] A[1]
+ mm17a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=400n
+ wp2=400n
XI87 VDDPI VSS VBP VBN POUT[0] A[0] A[1]
+ mm17a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=400n
+ wp2=400n
XI73 VDDPI VSS VBP VBN POUT[2] A[0] AB[1]
+ mm17a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=400n
+ wp2=400n
XI74 VDDPI VSS VBP VBN POUT[3] AB[0] AB[1]
+ mm17a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=400n
+ wp2=400n
MI83 net169 AB[0] POUT[3] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=400n
+ m=1
MI79 net161 AB[0] POUT[1] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=400n
+ m=1
MI81 net165 A[0] POUT[2] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=400n
+ m=1
MI78 VDDPI A[1] net161 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=400n
+ m=1
MI80 VDDPI AB[1] net165 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=400n
+ m=1
MI76 net158 A[0] POUT[0] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=400n
+ m=1
MI82 VDDPI AB[1] net169 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=400n
+ m=1
MI77 VDDPI A[1] net158 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=400n
+ m=1
.ends

.subckt mm17a04_u_hdrf2p_wpredec VDDPI VNWP VSS VBP VBN PA[0] PA[1] PA[2] PA[3]
+ PAA[0] PAA[1] PAA[2] PAA[3] PB[0] PB[1] PB[2] PB[3] PC[0] PC[1] PC[2] PC[3]
+ YCOL[0] YCOL[1] YCOL[2] YCOL[3] LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+ LXADR[5] LXADR[6] LXADR[7] LXADRB[0] LXADRB[1] LXADRB[2] LXADRB[3] LXADRB[4]
+ LXADRB[5] LXADRB[6] LXADRB[7] LYADR[0] LYADR[1] LYADRB[0] LYADRB[1]
XPD VNWP VDDPI VSS VBP VBN PC[0] PC[1] PC[2] PC[3] LXADR[6] LXADR[7] LXADRB[6]
+ LXADRB[7] mm17a04_u_hdrf2p_pred2to4_nd2_wa
XPC VNWP VDDPI VSS VBP VBN PB[0] PB[1] PB[2] PB[3] LXADR[4] LXADR[5] LXADRB[4]
+ LXADRB[5] mm17a04_u_hdrf2p_pred2to4_nd2_wa
XPB VNWP VDDPI VSS VBP VBN PA[0] PA[1] PA[2] PA[3] LXADR[2] LXADR[3] LXADRB[2]
+ LXADRB[3] mm17a04_u_hdrf2p_pred2to4_nd2_wa
XPA VNWP VDDPI VSS VBP VBN PAA[0] PAA[1] PAA[2] PAA[3] LXADR[0] LXADR[1]
+ LXADRB[0] LXADRB[1] mm17a04_u_hdrf2p_pred2to4_nd2_wa
XCOL VDDPI VNWP VSS VBP VBN YCOL[0] YCOL[1] YCOL[2] YCOL[3] LYADR[0] LYADR[1]
+ LYADRB[0] LYADRB[1] mm17a04_u_hdrf2p_pred2to4_wa
.ends

.subckt mm17a04_u_hdrf2p_predec VDDPI VNWP VSS VBP VBN PA[0] PA[1] PA[2] PA[3]
+ PAA[0] PAA[1] PAA[2] PAA[3] PB[0] PB[1] PB[2] PB[3] YCOL[0] YCOL[1] YCOL[2]
+ YCOL[3] LXADR[0] LXADR[1] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LXADRB[0]
+ LXADRB[1] LXADRB[4] LXADRB[5] LXADRB[6] LXADRB[7] LYADR[0] LYADR[1] LYADRB[0]
+ LYADRB[1]
XPC VNWP VDDPI VSS VBP VBN PB[0] PB[1] PB[2] PB[3] LXADR[6] LXADR[7] LXADRB[6]
+ LXADRB[7] mm17a04_u_hdrf2p_pred2to4_nd2_wa
XPB VNWP VDDPI VSS VBP VBN PA[0] PA[1] PA[2] PA[3] LXADR[4] LXADR[5] LXADRB[4]
+ LXADRB[5] mm17a04_u_hdrf2p_pred2to4_nd2_wa
XPA VNWP VDDPI VSS VBP VBN PAA[0] PAA[1] PAA[2] PAA[3] LXADR[0] LXADR[1]
+ LXADRB[0] LXADRB[1] mm17a04_u_hdrf2p_pred2to4_nd2_wa
XCOL VDDPI VNWP VSS VBP VBN YCOL[0] YCOL[1] YCOL[2] YCOL[3] LYADR[0] LYADR[1]
+ LYADRB[0] LYADRB[1] mm17a04_u_hdrf2p_pred2to4_wa
.ends

.subckt mm17a04_u_hdrf2p_lcen_wa VDDA VDDF VDDP VDDPI VSS VBP VBN TAP[0] TAP[1]
+ TAP[2] TAP[3] WAPRCLK ARYSD CENDP CKGATE_RD DEF1_RD DEF1_WR FAST1_RD FAST1_WR
+ FAST2_RD FAST2_WR LITESLP LOG0 LOG1 LRWMEB LXADRBRD[0] LXADRBRD[1]
+ LXADRBRD[2] LXADRBRD[3] LXADRBRD[4] LXADRBRD[5] LXADRBRD[6] LXADRBRD[7]
+ LXADRBWR[0] LXADRBWR[1] LXADRBWR[2] LXADRBWR[3] LXADRBWR[4] LXADRBWR[5]
+ LXADRBWR[6] LXADRBWR[7] LXADRRD[0] LXADRRD[1] LXADRRD[2] LXADRRD[3]
+ LXADRRD[4] LXADRRD[5] LXADRRD[6] LXADRRD[7] LXADRWR[0] LXADRWR[1] LXADRWR[2]
+ LXADRWR[3] LXADRWR[4] LXADRWR[5] LXADRWR[6] LXADRWR[7] LYADRBRD[0]
+ LYADRBRD[1] LYADRBWR[0] LYADRBWR[1] LYADRRD[0] LYADRRD[1] LYADRWR[0]
+ LYADRWR[1] PAARD[0] PAARD[1] PAARD[2] PAARD[3] PAAWR[0] PAAWR[1] PAAWR[2]
+ PAAWR[3] PAWR[0] PAWR[1] PAWR[2] PAWR[3] PBRD[0] PBRD[1] PBRD[2] PBRD[3]
+ PBWR[0] PBWR[1] PBWR[2] PBWR[3] PCRD[0] PCRD[1] PCRD[2] PCRD[3] PCWR[0]
+ PCWR[1] PCWR[2] PCWR[3] RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2]
+ RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] STRSB T1TRD T1TWR TKEEPB
+ WABUFB[0] WABUFB[1] WABUFB[2] WAPRCLKB_RET WAPRCLKB_RET_DEL
+ WAPRCLKB_RET_DEL_2 WAPRCLKB_RET_DEL_4 WAPRCLKB_RET_LCEN WFLOAT WFLT_RET
+ YCOLRD[0] YCOLRD[1] YCOLRD[2] YCOLRD[3] YCOLWR[0] YCOLWR[1] YCOLWR[2]
+ YCOLWR[3] YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] PRCKDLY RBLWA STCLK
+ WPBUFB[0] WPBUFB[1] WPBUFB[2]
XWACTRL_A VDDPI VDDP VSS VBP VBN TAP[0] TAP[1] TAP[2] TAP[3] WAPRCLK WABUFB[2]
+ PRCKDLY RBLWA STCLK WABUFB[2] WPBUFB[0] WPBUFB[1] WPBUFB[2]
+ mm17a04_u_wa_ctrl_hc
XPRED_WR VDDPI net327 VSS VBP VBN PAWR[0] PAWR[1] PAWR[2] PAWR[3] PAAWR[0]
+ PAAWR[1] PAAWR[2] PAAWR[3] PBWR[0] PBWR[1] PBWR[2] PBWR[3] PCWR[0] PCWR[1]
+ PCWR[2] PCWR[3] YCOLWR[0] YCOLWR[1] YCOLWR[2] YCOLWR[3] LXADRWR[0] LXADRWR[1]
+ LXADRWR[2] LXADRWR[3] LXADRWR[4] LXADRWR[5] LXADRWR[6] LXADRWR[7] LXADRBWR[0]
+ LXADRBWR[1] LXADRBWR[2] LXADRBWR[3] LXADRBWR[4] LXADRBWR[5] LXADRBWR[6]
+ LXADRBWR[7] LYADRWR[0] LYADRWR[1] LYADRBWR[0] LYADRBWR[1]
+ mm17a04_u_hdrf2p_wpredec
XPRED_RD VDDPI net329 VSS VBP VBN PBRD[0] PBRD[1] PBRD[2] PBRD[3] PAARD[0]
+ PAARD[1] PAARD[2] PAARD[3] PCRD[0] PCRD[1] PCRD[2] PCRD[3] YCOLRD[0]
+ YCOLRD[1] YCOLRD[2] YCOLRD[3] LXADRRD[0] LXADRRD[1] LXADRRD[4] LXADRRD[5]
+ LXADRRD[6] LXADRRD[7] LXADRBRD[0] LXADRBRD[1] LXADRBRD[4] LXADRBRD[5]
+ LXADRBRD[6] LXADRBRD[7] LYADRRD[0] LYADRRD[1] LYADRBRD[0] LYADRBRD[1]
+ mm17a04_u_hdrf2p_predec
XINV_DEL[1] VDDPI VSS VBP VBN WAPRCLKB_RET_DEL_2 DEL_1 DEL_1 DEL_1
+ mm17a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XINV_DEL[5] VDDPI VSS VBP VBN WAPRCLKB_RET_DEL DEL_5 DEL_5 DEL_5
+ mm17a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XINV_DEL[2] VDDPI VSS VBP VBN DEL_3 WAPRCLKB_RET_DEL_2 WAPRCLKB_RET_DEL_2
+ WAPRCLKB_RET_DEL_2 mm17a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n
+ lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n
+ wn2=120n wp1=120n wp2=120n
XINV_DEL[4] VDDPI VSS VBP VBN DEL_5 WAPRCLKB_RET_DEL_4 WAPRCLKB_RET_DEL_4
+ WAPRCLKB_RET_DEL_4 mm17a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n
+ lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n
+ wn2=120n wp1=120n wp2=120n
XINV_EDL[3] VDDPI VSS VBP VBN WAPRCLKB_RET_DEL_4 DEL_3 DEL_3 DEL_3
+ mm17a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XINV_DEL[0] VDDPI VSS VBP VBN DEL_1 WAPRCLKB_RET WAPRCLKB_RET WAPRCLKB_RET
+ mm17a04_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
.ends

.subckt mm17a04_u_inv_bulk_n_vt1_p_vt1 VDD VSS VBP VBN X A CPP=104n P_LA_n=4n
+ P_LA_p=4n ULP=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
MNA X A VSS VBN lvtnfet cpp=cpp p_la=p_la_n ulp=ulp nf=nf_n l=ln w=wn m=m_n
MPA X A VDD VBP lvtpfet cpp=cpp p_la=p_la_p ulp=ulp nf=nf_p l=lp w=wp m=m_p
.ends

.subckt mm17a04_u_hdrf2p_lcenbuf_wa VDDA VDDP VDDPI VSS VBP VBN WAB[0] WAB[1]
+ WAPCLK LOG0 RASSB[0] RASSB[1] WACKB LIOPD WABUF[0] WABUF[1] WAPCLKB
MPMOS_PG_PWLIO VDDP LIOPD VDDPI VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=640n m=14
MI60 VDDP LIOPD VDDPI VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=960n
+ m=10
XI19[0] VDDPI VSS VBP VBN WAB[0] net93[0] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=320n wp=320n
XI19[1] VDDPI VSS VBP VBN WAB[1] net93[1] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=320n wp=320n
XI68[0] VDDPI VSS VBP VBN net93[0] WABUF[0] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI68[1] VDDPI VSS VBP VBN net93[1] WABUF[1] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI26 VDDPI VSS VBP VBN WAPCLK net89 mm17a04_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI67 VDDPI VSS VBP VBN net89 WAPCLKB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=480n
+ wp=480n
.ends

.subckt mm17a04_u_WA_CAP_NMOSPD_RPB128_CM2 VSS VSS_WA VBP VBN CC_0 CC_1 PRCHBWA
MI233 CC_1 VSS_WA CC_1 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=277n
+ m=26
MI232 CC_0 VSS_WA CC_0 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=375n
+ m=8
MI230 VSS_WA PRCHBWA VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=500n
+ m=4
.ends

.subckt mm17a04_u_hdrf2p_wacap_rpb128_cm2 VDDP VDDPI VSS VSS_WA[0] VSS_WA[1]
+ VBP VBN WA[0] WA[1] WACLK_INT WAPRCLK
XI22 VSS VSS_WA[1] VBP VBN CC_0 CC_1 PRCHB_WA
+ mm17a04_u_WA_CAP_NMOSPD_RPB128_CM2
XI76 VSS VSS_WA[0] VBP VBN CC_0 CC_1 PRCHB_WA
+ mm17a04_u_WA_CAP_NMOSPD_RPB128_CM2
XI40 VDDPI VSS VBP VBN WACLK_INT PRCHB_WA mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=430n wp=430n
XI81 VDDPI VSS VBP VBN PRCHB_WA WAPRCLK mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=430n
+ wp=430n
XI39 VDDPI VSS VBP VBN CC_0 WACLK_INT WA[0]
+ mm17a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=453n wn2=453n wp1=138n
+ wp2=138n
XI34 VDDPI VSS VBP VBN CC_1 WACLK_INT WA[1]
+ mm17a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=664n wn2=664n wp1=253n
+ wp2=253n
.ends

.subckt mm17a04_u_hdrf2p_cmux2x2_wa_128 VDDA VDDAI VDDAI_SAC VDDP VDDPI VSS VBP
+ VBN BADB QT[0] QT[1] QT[2] QT[3] WAB[0] WAB[1] WACKB WAGND[0] WAGND[1] WAPCLK
+ WBI[0] WBI[1] WTI[0] WTI[1]
XWA_A VDDP VDDPI VSS WAGND[0] WAGND[1] VBP VBN WAB[0] WAB[1] WACLK_INT WAPRCLKB
+ mm17a04_u_hdrf2p_wacap_rpb128_cm2
XI64 VDDPI VSS VBP VBN WAPRCLKB WAPCLK mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=240n
.ends

.subckt mm17a04_u_hdrf2p_lcenrebuf_wa VDDA VDDP VDDPI VSS VBP VBN REWAB[0]
+ REWAB[1] REWAPCLK WACKB LOG0 LOG1 RASSB[0] RASSB[1] LIOPD WAB[0] WAB[1]
+ WAPCLK
XI26 VDDPI VSS VBP VBN REWAPCLK net82 mm17a04_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=480n
+ wp=480n
XI57 VDDPI VSS VBP VBN net82 WAPCLK mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI19[0] VDDPI VSS VBP VBN REWAB[0] net60[0] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=640n wp=640n
XI19[1] VDDPI VSS VBP VBN REWAB[1] net60[1] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=640n wp=640n
XI55[0] VDDPI VSS VBP VBN net60[0] WAB[0] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI55[1] VDDPI VSS VBP VBN net60[1] WAB[1] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=120n wp=120n
MI73 VDDP LIOPD VDDPI VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=1536n
+ m=10
MPMOS_PG_PWLIO VDDP LIOPD VDDPI VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=1303n m=14
.ends

.subckt mm17a04_u_hdrf2p_capmux_wa VDDP VDDPI VSS VBP VBN REWAPCLK WACKB LOG0
+ LOG1 PWDO VEDGE WAPCLK
XI34 VDDPI VSS VBP VBN net39 WAPCLK mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI26 VDDPI VSS VBP VBN REWAPCLK net39 mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=16 m_p=16 nf_n=1 nf_p=1 wn=120n
+ wp=120n
.ends

.subckt mm17a04_u_hdrf2p_pcbbuf VDDP VDDPI VSS VBP VBN PBB[0] PBB[1] PBB[2]
+ PBB[3] PCB[0] PCB[1] PCB[2] PCB[3] PB[0] PB[1] PB[2] PB[3] PC[0] PC[1] PC[2]
+ PC[3]
XI145[0] VDDPI VSS VBP VBN PCB[0] PC[0] mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI145[1] VDDPI VSS VBP VBN PCB[1] PC[1] mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI145[2] VDDPI VSS VBP VBN PCB[2] PC[2] mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI145[3] VDDPI VSS VBP VBN PCB[3] PC[3] mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI131[0] VDDPI VSS VBP VBN PBB[0] PB[0] mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI131[1] VDDPI VSS VBP VBN PBB[1] PB[1] mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI131[2] VDDPI VSS VBP VBN PBB[2] PB[2] mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI131[3] VDDPI VSS VBP VBN PBB[3] PB[3] mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=320n
+ wp=320n
.ends

.subckt mm17a04_u_hdrf2p_lshift_vddpi_vt2_ckwl VDDA VDDP VSS VBP VBN CKWLHV
+ CKGATE CLPSEBUFB CLP_VSS FLOAT
MN2 OUTB FLOAT VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=3
MN1 CKWLHV CKGATE CLP_VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=220n
+ m=9
MI3 CKWLHV FLOATB CLP_VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
MI9 VDDA CLPSEBUFB CKWLHV VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
MP2 VAL FLOAT OUTB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=2
MP1 VAH CKGATE CKWLHV VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=4
M1 VDDA OUTB VAH VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=4
M0 VDDA CKWLHV VAL VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=2
XI4 VDDP VSS VBP VBN FLOATB FLOAT mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
.ends

.subckt mm17a04_u_hdrf2p_inv_wclk VDDA VDDAI VSS VBP VBN OUT COM IN
MNM3 OUT IN COM VBN slvtnfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=320n m=2
MNR2_COM_PM VDDAI IN OUT VBP slvtpfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=480n
+ m=2
.ends

.subckt mm17a04_u_hdrf2p_wclk_nr2_rd VDDA VSS VSSWL VBP VBN WCLKB[0] WCLKB[1]
+ WCLKB[2] WCLKB[3] CLKWLB_prog PAA_prog[0] PAA_prog[1] PAA_prog[2] PAA_prog[3]
XINV_WCLKB[0] VDDA VSSWL VBP VBN WCLKB[0] WCLK[0]
+ mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=480n wp=400n
XINV_WCLKB[1] VDDA VSSWL VBP VBN WCLKB[1] WCLK[1]
+ mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=480n wp=400n
XINV_WCLKB[2] VDDA VSSWL VBP VBN WCLKB[2] WCLK[2]
+ mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=480n wp=400n
XINV_WCLKB[3] VDDA VSSWL VBP VBN WCLKB[3] WCLK[3]
+ mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=480n wp=400n
XI162[0] VDDA VDD_COM VSS VBP VBN WCLK[0] VSS PAA_prog[0]
+ mm17a04_u_hdrf2p_inv_wclk
XI162[1] VDDA VDD_COM VSS VBP VBN WCLK[1] VSS PAA_prog[1]
+ mm17a04_u_hdrf2p_inv_wclk
XI162[2] VDDA VDD_COM VSS VBP VBN WCLK[2] VSS PAA_prog[2]
+ mm17a04_u_hdrf2p_inv_wclk
XI162[3] VDDA VDD_COM VSS VBP VBN WCLK[3] VSS PAA_prog[3]
+ mm17a04_u_hdrf2p_inv_wclk
MNM[0] WCLK[0] CLKWLB_prog VSS VBN slvtnfet cpp=104n p_la=0 ulp=0 nf=1 l=20n
+ w=240n m=2
MNM[1] WCLK[1] CLKWLB_prog VSS VBN slvtnfet cpp=104n p_la=0 ulp=0 nf=1 l=20n
+ w=240n m=2
MNM[2] WCLK[2] CLKWLB_prog VSS VBN slvtnfet cpp=104n p_la=0 ulp=0 nf=1 l=20n
+ w=240n m=2
MNM[3] WCLK[3] CLKWLB_prog VSS VBN slvtnfet cpp=104n p_la=0 ulp=0 nf=1 l=20n
+ w=240n m=2
MPM_COMMON VDDA CLKWLB_prog VDD_COM VBP slvtpfet cpp=104n p_la=0 ulp=0 nf=1
+ l=20n w=240n m=4
.ends

.subckt mm17a04_u_hdrf2p_wclkdec_rd_opt VDDA VDDAI VDDP VDDPI VSS VSSWL VBP VBN
+ CLKWLB CLKWLB_HV FLOATB OPT_RET WCLK[0] WCLK[1] WCLK[2] WCLK[3] CKGATE
+ CKGATE_rlcen_prog CLKWLB_prog CLPSEBUFB FLOAT FLOAT_rlcen_prog PAA_prog[0]
+ PAA_prog[1] PAA_prog[2] PAA_prog[3]
XI182 VDDA VDDP VSS VBP VBN CLKWLB_HV CKGATE_rlcen_prog CLPSEBUFB CLP_VSS
+ FLOAT_rlcen_prog mm17a04_u_hdrf2p_lshift_vddpi_vt2_ckwl
XI164 VDDP VSS VBP VBN CLKWLB FLOATB CKGATE
+ mm17a04_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=400n wn2=400n wp1=800n
+ wp2=800n
XWCLK_NR2 VDDA VSS VSS VBP VBN WCLK[0] WCLK[1] WCLK[2] WCLK[3] CLKWLB_prog
+ PAA_prog[0] PAA_prog[1] PAA_prog[2] PAA_prog[3] mm17a04_u_hdrf2p_wclk_nr2_rd
XI143 VDDPI VSS VBP VBN FLOATB FLOAT mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI147 VDDPI VSS VBP VBN OPT_RET FLOATB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=240n
+ wp=240n
MI166 CLP_VSS CLPSEBUFB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=200n m=8
.ends

.subckt mm17a04_u_hdrf2p_rlcen VDDA VDDAI VDDP VDDPI VSS VSSWL VBP VBN
+ CLKWLB_RD CLKWLB_RD_HV LCGTL OPT_RET PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3]
+ PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PRCLKRDB_L PRCLKRDB_R WCLKRD[0] WCLKRD[1]
+ WCLKRD[2] WCLKRD[3] RFLT_RET CENDP CKGATE_RD CLKWLB_RD_prog CLPSEBUFB LITESLP
+ PAARD_prog[0] PAARD_prog[1] PAARD_prog[2] PAARD_prog[3] PBRD[0] PBRD[1]
+ PBRD[2] PBRD[3] PCRD[0] PCRD[1] PCRD[2] PCRD[3] RFLOAT ckgate_rlcen_prog
+ rfloat_rlcen_prog
XI7 VDDPI VSS VBP VBN net598 LITESLP CENDP
+ mm17a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=320n
+ wp2=320n
XINV_PRCLKRDB_R VDDPI VSS VBP VBN PRCLKRDB_R RWCLKB
+ mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=1 m_p=2 nf_n=1 nf_p=1 wn=240n wp=240n
XI22 VDDP VSS VBP VBN LCGTL net598 mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=400n
+ wp=400n
XINV_PRCLKRDB_L VDDPI VSS VBP VBN PRCLKRDB_L RWCLKB
+ mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=1 m_p=2 nf_n=1 nf_p=1 wn=240n wp=240n
XI148 VDDPI VSS VBP VBN REFCLKT RFLT_RET mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI155 VDDPI VSS VBP VBN RWCLKB net638 mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=200n
+ wp=240n
XI152 VDDPI VSS VBP VBN net643 REFCLKT mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI184 VDDPI VSS VBP VBN net638 net643 RFLT_RET
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=200n wn2=200n wp1=240n
+ wp2=240n
XPCBBUF VDDP VDDPI VSS VBP VBN PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PCRDB[0]
+ PCRDB[1] PCRDB[2] PCRDB[3] PBRD[0] PBRD[1] PBRD[2] PBRD[3] PCRD[0] PCRD[1]
+ PCRD[2] PCRD[3] mm17a04_u_hdrf2p_pcbbuf
XWCLKDEC VDDA VDDAI VDDP VDDPI VSS VSSWL VBP VBN CLKWLB_RD CLKWLB_RD_HV FLOATB
+ OPT_RET WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] CKGATE_RD ckgate_rlcen_prog
+ CLKWLB_RD_prog CLPSEBUFB RFLOAT rfloat_rlcen_prog PAARD_prog[0] PAARD_prog[1]
+ PAARD_prog[2] PAARD_prog[3] mm17a04_u_hdrf2p_wclkdec_rd_opt
.ends

.subckt mm17a04_u_hdrf2p_nd2_nr2_prckwr VDDP VDDPI VSS VBP VBN PRCLKB LSB TRNM
+ WFLOAT
MI91 VDDPI LSB PRCLKB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=474n m=1
MI86 VDDPI TRNM net18 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=474n m=1
MI88 net18 WFLOAT PRCLKB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=474n
+ m=1
MI89 net12 LSB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=480n m=2
MI90 PRCLKB WFLOAT net12 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=480n
+ m=2
MI92 PRCLKB TRNM net12 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=152n
+ m=3
.ends

.subckt mm17a04_u_hdrf2p_inv_prch VDDP VDDPI VSS VBP VBN OUT COM IN
MNM3 OUT IN COM VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
MNR2_COM_PM VDDPI IN OUT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
.ends

.subckt mm17a04_u_hdrf2p_prchwr_gen VDDP VDDPI VSS VBP VBN PRCLKB_L PRCLKB_R
+ YSEL_L[0] YSEL_L[1] YSEL_L[2] YSEL_L[3] YSEL_R[0] YSEL_R[1] YSEL_R[2]
+ YSEL_R[3] LRMEB STRSB WFLOAT YCOL[0] YCOL[1] YCOL[2] YCOL[3]
XI106 VDDP VDDPI VSS VBP VBN PRCLKB_L net296 TRNM WFLOAT
+ mm17a04_u_hdrf2p_nd2_nr2_prckwr
XI105 VDDP VDDPI VSS VBP VBN PRCLKB_R net296 TRNM WFLOAT
+ mm17a04_u_hdrf2p_nd2_nr2_prckwr
XYSEL_L[0] VDDPI VSS VBP VBN YSEL_L[0] WFLOAT YSELB[0]
+ mm17a04_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=174n wn2=174n wp1=440n
+ wp2=440n
XYSEL_L[1] VDDPI VSS VBP VBN YSEL_L[1] WFLOAT YSELB[1]
+ mm17a04_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=174n wn2=174n wp1=440n
+ wp2=440n
XYSEL_L[2] VDDPI VSS VBP VBN YSEL_L[2] WFLOAT YSELB[2]
+ mm17a04_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=174n wn2=174n wp1=440n
+ wp2=440n
XYSEL_L[3] VDDPI VSS VBP VBN YSEL_L[3] WFLOAT YSELB[3]
+ mm17a04_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=174n wn2=174n wp1=440n
+ wp2=440n
XYSEL_R[0] VDDPI VSS VBP VBN YSEL_R[0] WFLOAT YSELB[0]
+ mm17a04_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=174n wn2=174n wp1=440n
+ wp2=440n
XYSEL_R[1] VDDPI VSS VBP VBN YSEL_R[1] WFLOAT YSELB[1]
+ mm17a04_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=174n wn2=174n wp1=440n
+ wp2=440n
XYSEL_R[2] VDDPI VSS VBP VBN YSEL_R[2] WFLOAT YSELB[2]
+ mm17a04_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=174n wn2=174n wp1=440n
+ wp2=440n
XYSEL_R[3] VDDPI VSS VBP VBN YSEL_R[3] WFLOAT YSELB[3]
+ mm17a04_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=174n wn2=174n wp1=440n
+ wp2=440n
XI131[0] VDDP VDDPI VSS VBP VBN YSELB[0] NN1 YCOL[0] mm17a04_u_hdrf2p_inv_prch
XI131[1] VDDP VDDPI VSS VBP VBN YSELB[1] NN1 YCOL[1] mm17a04_u_hdrf2p_inv_prch
XI131[2] VDDP VDDPI VSS VBP VBN YSELB[2] NN1 YCOL[2] mm17a04_u_hdrf2p_inv_prch
XI131[3] VDDP VDDPI VSS VBP VBN YSELB[3] NN1 YCOL[3] mm17a04_u_hdrf2p_inv_prch
XI97 VDDPI VSS VBP VBN net296 LRMEB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=400n
+ wp=240n
XI93 VDDPI VSS VBP VBN TRNM STRSB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=400n
+ wp=240n
M21 NN1 STRSB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n m=4
M22[0] VDDPI STRSB YSELB[0] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=234n m=1
M22[1] VDDPI STRSB YSELB[1] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=234n m=1
M22[2] VDDPI STRSB YSELB[2] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=234n m=1
M22[3] VDDPI STRSB YSELB[3] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=234n m=1
.ends

.subckt mm17a04_u_hdrf2p_aoi21 VDD VSS VBP VBN X A1 A2 B
MNA1 X A1 net26 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
MNA2 net26 A2 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
MNB X B VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
MPA2 XP A2 X VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
M4 XP A1 X VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
M0 VDD B XP VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
.ends

.subckt
+ mm17a04_u_nd4_bulk_n1_vt3_n2_vt3_n3_vt3_n4_vt3_p1_vt3_p2_vt3_p3_vt3_p4_vt3
+ VDD VSS VBP VBN X A1 A2 A3 A4 CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_n3=4n
+ P_LA_n4=4n P_LA_p1=4n P_LA_p2=4n P_LA_p3=4n P_LA_p4=4n ULP=0 ln1=20n ln2=20n
+ ln3=20n ln4=20n lp1=20n lp2=20n lp3=20n lp4=20n m_n1=1 m_n2=1 m_n3=1 m_n4=1
+ m_p1=1 m_p2=1 m_p3=1 m_p4=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_n4=1 nf_p1=1 nf_p2=1
+ nf_p3=1 nf_p4=1 wn1=800n wn2=800n wn3=800n wn4=800n wp1=120n wp2=120n
+ wp3=120n wp4=120n
MNA1 X A1 net19 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 net19 A2 net018 VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2
+ w=wn2 m=m_n2
MNA3 net018 A3 net024 VBN slvtnfet cpp=cpp p_la=p_la_n3 ulp=ulp nf=nf_n3 l=ln3
+ w=wn3 m=m_n3
MNA4 net024 A4 VSS VBN slvtnfet cpp=cpp p_la=p_la_n4 ulp=ulp nf=nf_n4 l=ln4
+ w=wn4 m=m_n4
MPA1 X A1 VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MPA4 X A4 VDD VBP slvtpfet cpp=cpp p_la=p_la_p4 ulp=ulp nf=nf_p4 l=lp4 w=wp4
+ m=m_p4
MPA2 X A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
MPA3 X A3 VDD VBP slvtpfet cpp=cpp p_la=p_la_p3 ulp=ulp nf=nf_p3 l=lp3 w=wp3
+ m=m_p3
.ends

.subckt mm17a04_u_hdrf2p_lcen_timer_3x1mux VDDP VDDPI VSS VBP VBN STCLK
+ DLY_WRTIMER DLY_WRTIMER_0 DLY_WRTIMER_4 DEF FLOAT_RETB FT1 FT2 RBL T1T
XI119 VDDPI VSS VBP VBN STCLK net379 FLOAT_RETB T1B DLY_WRTIMER_0
+ mm17a04_u_nd4_bulk_n1_vt3_n2_vt3_n3_vt3_n4_vt3_p1_vt3_p2_vt3_p3_vt3_p4_vt3
+ cpp=104n p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_n4=4n p_la_p1=4n p_la_p2=4n
+ p_la_p3=4n p_la_p4=4n ulp=0 ln1=20n ln2=20n ln3=20n ln4=20n lp1=20n lp2=20n
+ lp3=20n lp4=20n m_n1=1 m_n2=1 m_n3=1 m_n4=1 m_p1=1 m_p2=1 m_p3=1 m_p4=1
+ nf_n1=1 nf_n2=1 nf_n3=1 nf_n4=1 nf_p1=1 nf_p2=1 nf_p3=1 nf_p4=1 wn1=800n
+ wn2=800n wn3=800n wn4=800n wp1=120n wp2=120n wp3=120n wp4=120n
XI135 VDDPI VSS VBP VBN DLY_WRTIMER_0 RBL mm17a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=160n wp=160n
XI149 VDDPI VSS VBP VBN net287 net288 mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI138 VDDPI VSS VBP VBN net289 DLY_WRTIMER_0 mm17a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XT1B VDDPI VSS VBP VBN T1B T1T mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=2 nf_n=1 nf_p=1 wn=240n
+ wp=120n
XI139 VDDPI VSS VBP VBN net288 net289 mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI150 VDDPI VSS VBP VBN DLY_WRTIMER_4 net287 mm17a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI99 VDDPI VSS VBP VBN DEFAULT net206 mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI97 VDDPI VSS VBP VBN FAST1 net264 mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI134 VDDPI VSS VBP VBN net264 DLY_WRTIMER mm17a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=320n wp=320n
XI98 VDDPI VSS VBP VBN net206 FAST1 mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI102 VDDPI VSS VBP VBN net211 DEF mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI105 VDDPI VSS VBP VBN net225 FT2 mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI104 VDDPI VSS VBP VBN net233 FT1 mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI103 VBP VBN FAST1 net379 FT1 net233 mm17a04_u_tg_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI94 VBP VBN DEFAULT net379 DEF net211 mm17a04_u_tg_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=307n
XI106 VBP VBN DLY_WRTIMER_0 net379 FT2 net225 mm17a04_u_tg_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=240n
.ends

.subckt mm17a04_u_hdrf2p_dblbuf VDDP VDDPI VSS VBP VBN FLT_DEL_A FLT_DEL_B
+ STCLK DEF DLY_WRTIMER DLY_WRTIMER_0 DLY_WRTIMER_4 FLOAT FT1 FT2 STCLK_RST_PGM
+ T1T WABUFB[2] WAPRCLKB_RET WDBL
MI61 net79 FLOAT PULLD VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n
+ m=1
MI90 VDDPI T1T net79 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
MI0 VDDP STCLK FLOAT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=4
XI26 VDDPI VSS VBP VBN net69 FLOAT mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=320n
XI23 VDDPI VSS VBP VBN FLT_DEL_B net68 mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI22 VDDPI VSS VBP VBN net68 FLT_DEL_A mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI27 VDDPI VSS VBP VBN FLT_DEL_A net69 mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=320n
XI11 VDDPI VSS VBP VBN net45 WABUFB[2] mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI12 VDDPI VSS VBP VBN STCLK_OFF net45 WAPRCLKB_RET STCLK_RST_PGM
+ mm17a04_u_hdrf2p_aoi21
XTIMER_SACTRL VDDP VDDPI VSS VBP VBN STCLK DLY_WRTIMER DLY_WRTIMER_0
+ DLY_WRTIMER_4 DEF STCLK_OFF FT1 FT2 WDBL T1T
+ mm17a04_u_hdrf2p_lcen_timer_3x1mux
MI63 PULLD FLOAT VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=2
MI62 PULLD T1T VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=2
MI67 FLOAT STCLK net1 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=2
M40 net1 PULLD VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=2
.ends

.subckt mm17a04_u_hdrf2p_pcbbuf_wlcen VDDP VDDPI VSS VBP VBN PBB[0] PBB[1]
+ PBB[2] PBB[3] PCB[0] PCB[1] PCB[2] PCB[3] PB[0] PB[1] PB[2] PB[3] PC[0] PC[1]
+ PC[2] PC[3]
XI145[0] VDDPI VSS VBP VBN PCB[0] PC[0] mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=320n
+ wp=440n
XI145[1] VDDPI VSS VBP VBN PCB[1] PC[1] mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=320n
+ wp=440n
XI145[2] VDDPI VSS VBP VBN PCB[2] PC[2] mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=320n
+ wp=440n
XI145[3] VDDPI VSS VBP VBN PCB[3] PC[3] mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=320n
+ wp=440n
XI131[0] VDDPI VSS VBP VBN PBB[0] PB[0] mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=320n
+ wp=440n
XI131[1] VDDPI VSS VBP VBN PBB[1] PB[1] mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=320n
+ wp=440n
XI131[2] VDDPI VSS VBP VBN PBB[2] PB[2] mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=320n
+ wp=440n
XI131[3] VDDPI VSS VBP VBN PBB[3] PB[3] mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=320n
+ wp=440n
.ends

.subckt mm17a04_u_hdrf2p_wclk_nr2 VDDA VSS VSSWL VBP VBN WCLKB[0] WCLKB[1]
+ WCLKB[2] WCLKB[3] CLKWLB_prog PAA_prog[0] PAA_prog[1] PAA_prog[2] PAA_prog[3]
XINV_WCLKB[0] VDDA VSSWL VBP VBN WCLKB[0] WCLK[0]
+ mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=480n wp=400n
XINV_WCLKB[1] VDDA VSSWL VBP VBN WCLKB[1] WCLK[1]
+ mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=480n wp=400n
XINV_WCLKB[2] VDDA VSSWL VBP VBN WCLKB[2] WCLK[2]
+ mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=480n wp=400n
XINV_WCLKB[3] VDDA VSSWL VBP VBN WCLKB[3] WCLK[3]
+ mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=480n wp=400n
XI162[0] VDDA VDD_COM VSS VBP VBN WCLK[0] VSS PAA_prog[0]
+ mm17a04_u_hdrf2p_inv_wclk
XI162[1] VDDA VDD_COM VSS VBP VBN WCLK[1] VSS PAA_prog[1]
+ mm17a04_u_hdrf2p_inv_wclk
XI162[2] VDDA VDD_COM VSS VBP VBN WCLK[2] VSS PAA_prog[2]
+ mm17a04_u_hdrf2p_inv_wclk
XI162[3] VDDA VDD_COM VSS VBP VBN WCLK[3] VSS PAA_prog[3]
+ mm17a04_u_hdrf2p_inv_wclk
MNM[0] WCLK[0] CLKWLB_prog VSS VBN slvtnfet cpp=104n p_la=0 ulp=0 nf=1 l=20n
+ w=160n m=2
MNM[1] WCLK[1] CLKWLB_prog VSS VBN slvtnfet cpp=104n p_la=0 ulp=0 nf=1 l=20n
+ w=160n m=2
MNM[2] WCLK[2] CLKWLB_prog VSS VBN slvtnfet cpp=104n p_la=0 ulp=0 nf=1 l=20n
+ w=160n m=2
MNM[3] WCLK[3] CLKWLB_prog VSS VBN slvtnfet cpp=104n p_la=0 ulp=0 nf=1 l=20n
+ w=160n m=2
MPM_COMMON VDDA CLKWLB_prog VDD_COM VBP slvtpfet cpp=104n p_la=0 ulp=0 nf=1
+ l=20n w=240n m=4
.ends

.subckt mm17a04_u_hdrf2p_lshift_vddpi_vt2_lcen VDDA VDDP VDDPI VSS VBP VBN
+ WLHVB VCLPSGND WLLVB
XINV VDDPI VSS VBP VBN WLLV WLLVB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=140n
+ wp=140n
MI4 VDDA WLHVB VAL VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI3 VAH WLLV WLHVB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=360n m=2
M1 VDDA OUTB VAH VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=360n m=2
MI5 VAL WLLVB OUTB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI6 OUTB WLLVB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=2
MN1 WLHVB WLLV VCLPSGND VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=360n
+ m=3
.ends

.subckt mm17a04_u_hdrf2p_wclkdec VDDA VDDAI VDDP VDDPI VSS VSSWL VBP VBN
+ CLKWLB_HV FLOATB OPT_RET WCLK[0] WCLK[1] WCLK[2] WCLK[3] CLKWLB_prog
+ CLPSEBUFB FLOAT PAA_prog[0] PAA_prog[1] PAA_prog[2] PAA_prog[3]
MI166 CLP_VSS CLPSEBUFB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=400n m=4
XWCLK_NR2 VDDA VSS VSS VBP VBN WCLK[0] WCLK[1] WCLK[2] WCLK[3] CLKWLB_prog
+ PAA_prog[0] PAA_prog[1] PAA_prog[2] PAA_prog[3] mm17a04_u_hdrf2p_wclk_nr2
XI173 VDDA VDDP VDDP VSS VBP VBN CLKWLB_HV CLP_VSS FLOAT
+ mm17a04_u_hdrf2p_lshift_vddpi_vt2_lcen
XI143 VDDPI VSS VBP VBN FLOATB FLOAT mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI147 VDDPI VSS VBP VBN OPT_RET FLOATB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
MI9 VDDA CLPSEBUFB CLKWLB_HV VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=360n m=1
.ends

.subckt mm17a04_u_hdrf2p_wlcen VDDA VDDAI VDDP VDDPI VSS VSSWL VBP VBN
+ CLKWLB_WR_HV FLT_DEL_A FLT_DEL_B PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3] PBWRB[0]
+ PBWRB[1] PBWRB[2] PBWRB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3] PRCLKWRB_L
+ PRCLKWRB_R STCLK WCLKWR[0] WCLKWR[1] WCLKWR[2] WCLKWR[3] WFLT_RET YSELWR_L[0]
+ YSELWR_L[1] YSELWR_L[2] YSELWR_L[3] YSELWR_R[0] YSELWR_R[1] YSELWR_R[2]
+ YSELWR_R[3] DEF DLY_WRTIMER DLY_WRTIMER_0 DLY_WRTIMER_4 FT1 FT2
+ CLKWLB_WR_prog CLPSEBUFB LRMEB OPT_Y[0] OPT_Y[1] OPT_Y[2] OPT_Y[3]
+ PAAWR_prog[0] PAAWR_prog[1] PAAWR_prog[2] PAAWR_prog[3] PAWR[0] PAWR[1]
+ PAWR[2] PAWR[3] PBWR[0] PBWR[1] PBWR[2] PBWR[3] PCWR[0] PCWR[1] PCWR[2]
+ PCWR[3] STCLK_RST_PGM STRSB T1TWR WABUFB[2] WAPRCLKB_RET WDBL WFLOAT
+ YCOLWR[0] YCOLWR[1] YCOLWR[2] YCOLWR[3]
XY4WSEL VDDP VDDPI VSS VBP VBN PRCLKWRB_L PRCLKWRB_R YSELWR_L[0] YSELWR_L[1]
+ YSELWR_L[2] YSELWR_L[3] YSELWR_R[0] YSELWR_R[1] YSELWR_R[2] YSELWR_R[3] LRMEB
+ STRSB WFLOAT OPT_Y[0] OPT_Y[1] OPT_Y[2] OPT_Y[3] mm17a04_u_hdrf2p_prchwr_gen
XDBLBUF VDDP VDDPI VSS VBP VBN FLT_DEL_A FLT_DEL_B STCLK DEF DLY_WRTIMER
+ DLY_WRTIMER_0 DLY_WRTIMER_4 WFLOAT FT1 FT2 STCLK_RST_PGM T1TWR WABUFB[2]
+ WAPRCLKB_RET WDBL mm17a04_u_hdrf2p_dblbuf
XPCBBUF VDDP VDDPI VSS VBP VBN PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3] PBWRB[0]
+ PBWRB[1] PBWRB[2] PBWRB[3] PAWR[0] PAWR[1] PAWR[2] PAWR[3] PBWR[0] PBWR[1]
+ PBWR[2] PBWR[3] mm17a04_u_hdrf2p_pcbbuf_wlcen
XI133[0] VDDPI VSS VBP VBN PCWRB[0] PCWR[0] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=320n wp=440n
XI133[1] VDDPI VSS VBP VBN PCWRB[1] PCWR[1] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=320n wp=440n
XI133[2] VDDPI VSS VBP VBN PCWRB[2] PCWR[2] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=320n wp=440n
XI133[3] VDDPI VSS VBP VBN PCWRB[3] PCWR[3] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=320n wp=440n
XWCLKDEC VDDA VDDAI VDDP VDDPI VSS VSSWL VBP VBN CLKWLB_WR_HV FLOATB_WR
+ WFLT_RET WCLKWR[0] WCLKWR[1] WCLKWR[2] WCLKWR[3] CLKWLB_WR_prog CLPSEBUFB
+ WFLOAT PAAWR_prog[0] PAAWR_prog[1] PAAWR_prog[2] PAAWR_prog[3]
+ mm17a04_u_hdrf2p_wclkdec
.ends

.subckt mm17a04_u_hdrf2p_lcen VDDA VDDAPI VDDF VDDP VDDPI VSS VSSWL VBP VBN
+ CLKWLB_RD CLKWLB_RD_HV CLKWLB_WR_HV LCGTL OPT_RET PAWRB[0] PAWRB[1] PAWRB[2]
+ PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2]
+ PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2]
+ PCWRB[3] PRCLKRDB_L PRCLKRDB_R PRCLKWRB_L PRCLKWRB_R WCLKRD[0] WCLKRD[1]
+ WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2] WCLKWR[3] WFLT_DEL_A
+ WFLT_DEL_B WFLT_RET WSTCLK YSELWR_L[0] YSELWR_L[1] YSELWR_L[2] YSELWR_L[3]
+ YSELWR_R[0] YSELWR_R[1] YSELWR_R[2] YSELWR_R[3] ARYSD CENDP CLPSEBUFB DEF1_RD
+ DEF1_WR DLY_WRTIMER DLY_WRTIMER_0 DLY_WRTIMER_4 FAST1_RD FAST1_WR FAST2_RD
+ FAST2_WR LOG0 LOG1 LRWMEB LXADRB[2] LXADRB[3] LXADRB[4] RBLWA RDBL RFLOAT
+ RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1]
+ RMTWR[2] RMTWR[3] T1TRD T1TWR TKEEPB WFLOAT YSELRD[0] YSELRD[1] YSELRD[2]
+ YSELRD[3] CKGATE_RD CKGATE_RLCEN_PROG CLKWLB_RD_prog CLKWLB_WR_prog LITESLP
+ OPT_Y[0] OPT_Y[1] OPT_Y[2] OPT_Y[3] PAARD[0] PAARD[1] PAARD[2] PAARD[3]
+ PAARD_HV[0] PAARD_HV[1] PAARD_HV[2] PAARD_HV[3] PAARD_prog[0] PAARD_prog[1]
+ PAARD_prog[2] PAARD_prog[3] PAAWR[0] PAAWR[1] PAAWR[2] PAAWR[3] PAAWR_HV[0]
+ PAAWR_HV[1] PAAWR_HV[2] PAAWR_HV[3] PAAWR_prog[0] PAAWR_prog[1] PAAWR_prog[2]
+ PAAWR_prog[3] PAWR[0] PAWR[1] PAWR[2] PAWR[3] PBRD[0] PBRD[1] PBRD[2] PBRD[3]
+ PBWR[0] PBWR[1] PBWR[2] PBWR[3] PCRD[0] PCRD[1] PCRD[2] PCRD[3] PCWR[0]
+ PCWR[1] PCWR[2] PCWR[3] RFLOAT_RLCEN_PROG STCLK_WR_RST_PGM STRSB WABUFB[2]
+ WAPRCLKB_RET_LCEN WDBL YCOLWR[0] YCOLWR[1] YCOLWR[2] YCOLWR[3]
XRLCEN VDDA VDDAPI VDDP VDDPI VSS VSSWL VBP VBN CLKWLB_RD CLKWLB_RD_HV LCGTL
+ OPT_RET PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PCRDB[0] PCRDB[1] PCRDB[2]
+ PCRDB[3] PRCLKRDB_L PRCLKRDB_R WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3]
+ RFLT_RET CENDP CKGATE_RD CLKWLB_RD_prog CLPSEBUFB LITESLP PAARD_prog[0]
+ PAARD_prog[1] PAARD_prog[2] PAARD_prog[3] PBRD[0] PBRD[1] PBRD[2] PBRD[3]
+ PCRD[0] PCRD[1] PCRD[2] PCRD[3] RFLOAT CKGATE_RLCEN_PROG RFLOAT_RLCEN_PROG
+ mm17a04_u_hdrf2p_rlcen
XWLCEN VDDA VDDAPI VDDP VDDPI VSS VSSWL VBP VBN CLKWLB_WR_HV WFLT_DEL_A
+ WFLT_DEL_B PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3] PBWRB[0] PBWRB[1] PBWRB[2]
+ PBWRB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3] PRCLKWRB_L PRCLKWRB_R WSTCLK
+ WCLKWR[0] WCLKWR[1] WCLKWR[2] WCLKWR[3] WFLT_RET YSELWR_L[0] YSELWR_L[1]
+ YSELWR_L[2] YSELWR_L[3] YSELWR_R[0] YSELWR_R[1] YSELWR_R[2] YSELWR_R[3]
+ DEF1_WR DLY_WRTIMER DLY_WRTIMER_0 DLY_WRTIMER_4 FAST1_WR FAST2_WR
+ CLKWLB_WR_prog CLPSEBUFB LRWMEB OPT_Y[0] OPT_Y[1] OPT_Y[2] OPT_Y[3]
+ PAAWR_prog[0] PAAWR_prog[1] PAAWR_prog[2] PAAWR_prog[3] PAWR[0] PAWR[1]
+ PAWR[2] PAWR[3] PBWR[0] PBWR[1] PBWR[2] PBWR[3] PCWR[0] PCWR[1] PCWR[2]
+ PCWR[3] STCLK_WR_RST_PGM STRSB T1TWR WABUFB[2] WAPRCLKB_RET_LCEN WDBL WFLOAT
+ YCOLWR[0] YCOLWR[1] YCOLWR[2] YCOLWR[3] mm17a04_u_hdrf2p_wlcen
.ends

.subckt mm17a04_u_hdrf2p_lcenbuf VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+ LCGTHBUF LCGTVB PRCHRD PRCHWR PRCLKWRB_DLY2 PRCLKWRB_DLY4 WPSGT[0] WPSGT[1]
+ WPSGT[2] WPSGT[3] LCGTV LOG1 RASSB[0] RASSB[1] LCGTH PRCLKRDB PRCLKWRB
+ PRCLKWRB_PGM YSELWR[0] YSELWR[1] YSELWR[2] YSELWR[3]
MI112 VDDA LCGTV VDDWL_WR VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n
+ m=10
MP89[0] VDDA YSELWR[0] net181[0] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=480n m=1
MP89[1] VDDA YSELWR[1] net181[1] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=480n m=1
MP89[2] VDDA YSELWR[2] net181[2] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=480n m=1
MP89[3] VDDA YSELWR[3] net181[3] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=480n m=1
MI73 VDDA LCGTV VDDWL_RD VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n
+ m=10
XI72 VDDA VSS VBP VBN LCGTV LCGTVB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI90 VDDA VSS VBP VBN LCGTVB LCGTH mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=360n
+ wp=180n
XI64 VDDPI VSS VBP VBN PRCHWR PRCLK mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI97 VDDA VSS VBP VBN LCGTHBUF LCGTVB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI107 VDDPI VSS VBP VBN net156 PRCLKWRB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI77[0] VDDA VSS VBP VBN WPSGT[0] net181[0] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=480n wp=560n
XI77[1] VDDA VSS VBP VBN WPSGT[1] net181[1] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=480n wp=560n
XI77[2] VDDA VSS VBP VBN WPSGT[2] net181[2] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=480n wp=560n
XI77[3] VDDA VSS VBP VBN WPSGT[3] net181[3] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=480n wp=560n
XI99 VDDPI VSS VBP VBN PRCHRD PRCLKRDB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=8 m_p=8 nf_n=1 nf_p=1 wn=180n
+ wp=180n
XI104 VDDPI VSS VBP VBN net154 PRCLKWRB_DLY2 mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI103 VDDPI VSS VBP VBN PRCLKWRB_DLY4 net154 mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI106 VDDPI VSS VBP VBN PRCLKWRB_DLY2 net156 mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI108 VDDPI VSS VBP VBN PRCLK PRCLKWRB PRCLKWRB_PGM
+ mm17a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=480n
+ wp2=480n
MN89[0] net181[0] YSELWR[0] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=480n m=1
MN89[1] net181[1] YSELWR[1] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=480n m=1
MN89[2] net181[2] YSELWR[2] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=480n m=1
MN89[3] net181[3] YSELWR[3] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=480n m=1
.ends

.subckt mm17a04_u_hdrf2p_cmux_rd VDDP VDDPI VSS VBP VBN QT PRCHB
MI5 VDDPI PRCHB QT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n m=3
MI13 VDDPI QT QTB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n m=2
MI48 VDDPI QTB QT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n m=1
MI14 QTB QT VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
.ends

.subckt mm17a04_u_hdrf2p_cmux_pg VSS VBP VBN BB BT WB WT WPASS
MI31 BB WPASS WB VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=278n m=3
MI32 BT WPASS WT VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=278n m=3
.ends

.subckt mm17a04_u_hdrf2p_cmux_pch VDDPI VNWP VBP VBN BB BT PRCHB
M0 VDDPI PRCHB BT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=2
M2 VDDPI PRCHB BB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=2
M3 BT PRCHB BB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
.ends

.subckt mm17a04_u_hdrf2p_cmux_wr VDDA VDDPI VNWP VSS VBP VBN WB WBB WBT WT
+ PRCHB WPSGT
XI35 VDDA VSS VBP VBN WPASS WPASSB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI40 VDDA VSS VBP VBN WPASSB WPSGT mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XPG VSS VBP VBN WBB WBT WB WT WPASS mm17a04_u_hdrf2p_cmux_pg
XPCH VDDPI VNWP VBP VBN WBB WBT PRCHB mm17a04_u_hdrf2p_cmux_pch
.ends

.subckt mm17a04_u_hdrf2p_wrdrv VDDPI VNWP VSS VBP VBN WB WT WAGND WBI WTI
XI6 VDDPI WAGND VBP VBN WT WBI mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=2 nf_n=1 nf_p=1 wn=320n
+ wp=160n
XI16 VDDPI WAGND VBP VBN WB WTI mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=2 nf_n=1 nf_p=1 wn=320n
+ wp=160n
.ends

.subckt mm17a04_u_hdrf2p_wr_cmux2x2 VDDA VDDAI VDDAI_SAC VDDP VDDPI VSS VBP VBN
+ BADB LCGTHBUF LOG1 QT[0] QT[1] QT[2] QT[3] WAGND[0] WAGND[1] WBLB[0] WBLB[1]
+ WBLB[2] WBLB[3] WBLT[0] WBLT[1] WBLT[2] WBLT[3] PRCHRD PRCHWR WBI[0] WBI[1]
+ WPSGT[0] WPSGT[1] WPSGT[2] WPSGT[3] WTI[0] WTI[1]
XRMX[0] VDDP VDDPI VSS VBP VBN QT[0] PRCHRDB mm17a04_u_hdrf2p_cmux_rd
XRMX[1] VDDP VDDPI VSS VBP VBN QT[1] PRCHRDB mm17a04_u_hdrf2p_cmux_rd
XRMX[2] VDDP VDDPI VSS VBP VBN QT[2] PRCHRDB mm17a04_u_hdrf2p_cmux_rd
XRMX[3] VDDP VDDPI VSS VBP VBN QT[3] PRCHRDB mm17a04_u_hdrf2p_cmux_rd
XWMX[0] VDDA VDDPI VDDP VSS VBP VBN WB[0] WBLB[0] WBLT[0] WT[0] PRCHWRB
+ WPSGT[0] mm17a04_u_hdrf2p_cmux_wr
XWMX[1] VDDA VDDPI VDDP VSS VBP VBN WB[0] WBLB[1] WBLT[1] WT[0] PRCHWRB
+ WPSGT[1] mm17a04_u_hdrf2p_cmux_wr
XWMX[2] VDDA VDDPI VDDP VSS VBP VBN WB[1] WBLB[2] WBLT[2] WT[1] PRCHWRB
+ WPSGT[2] mm17a04_u_hdrf2p_cmux_wr
XWMX[3] VDDA VDDPI VDDP VSS VBP VBN WB[1] WBLB[3] WBLT[3] WT[1] PRCHWRB
+ WPSGT[3] mm17a04_u_hdrf2p_cmux_wr
XW[0] VDDPI VDDP VSS VBP VBN WB[0] WT[0] WAGND[0] WBI[0] WTI[0]
+ mm17a04_u_hdrf2p_wrdrv
XW[1] VDDPI VDDP VSS VBP VBN WB[0] WT[0] WAGND[0] WBI[0] WTI[0]
+ mm17a04_u_hdrf2p_wrdrv
XW[2] VDDPI VDDP VSS VBP VBN WB[1] WT[1] WAGND[1] WBI[1] WTI[1]
+ mm17a04_u_hdrf2p_wrdrv
XW[3] VDDPI VDDP VSS VBP VBN WB[1] WT[1] WAGND[1] WBI[1] WTI[1]
+ mm17a04_u_hdrf2p_wrdrv
XI47 VDDPI VSS VBP VBN PRCHWRB PRCHWRT mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=230n
+ wp=235n
XI54 VDDPI VSS VBP VBN PRCHRDB PRCHRD mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=230n
+ wp=235n
XI66 VDDPI VSS VBP VBN PRCHWRT PRCHWR mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=230n
+ wp=235n
.ends

.subckt mm17a04_u_hdrf2p_lcenrebuf VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP
+ VBN RELCGTH REPRCHRD REPRCHWR REWPSGT[0] REWPSGT[1] REWPSGT[2] REWPSGT[3]
+ LCGTV RASSB[0] RASSB[1] WL_VSS LCGTH PRCHRD PRCHWR WPSGT[0] WPSGT[1] WPSGT[2]
+ WPSGT[3]
MI73 VDDA LCGTV VDDWL_RD VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=800n
+ m=5
MI105 VDDA LCGTV VDDWL_WR VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=800n
+ m=5
MI101 WL_VSS LCGTB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=480n
+ m=3
XI72 VDDA VSS VBP VBN LCGTV LCGTB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI90 VDDA VSS VBP VBN LCGTB LCGTH mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI97 VDDA VSS VBP VBN RELCGTH LCGTB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI104 VDDPI VSS VBP VBN net155 net153 mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI103 VDDPI VSS VBP VBN net153 PRCHRD mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI82 VDDPI VSS VBP VBN REPRCHRD net144 mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI89[0] VDDA VSS VBP VBN net138[0] WPSGT[0] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=480n wp=480n
XI89[1] VDDA VSS VBP VBN net138[1] WPSGT[1] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=480n wp=480n
XI89[2] VDDA VSS VBP VBN net138[2] WPSGT[2] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=480n wp=480n
XI89[3] VDDA VSS VBP VBN net138[3] WPSGT[3] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=480n wp=480n
XI98 VDDPI VSS VBP VBN net143 PRCHWR mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI77[0] VDDA VSS VBP VBN REWPSGT[0] net138[0] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=480n wp=480n
XI77[1] VDDA VSS VBP VBN REWPSGT[1] net138[1] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=480n wp=480n
XI77[2] VDDA VSS VBP VBN REWPSGT[2] net138[2] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=480n wp=480n
XI77[3] VDDA VSS VBP VBN REWPSGT[3] net138[3] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=480n wp=480n
XI64 VDDPI VSS VBP VBN REPRCHWR net143 mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI99 VDDPI VSS VBP VBN net144 PRCHRD net155
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=320n
+ wp2=320n
.ends

.subckt mm17a04_u_hdrf2p_bkdec_rd_bk1 VDDP VDDPI VNWP VSS VBP VBN LCGTB LCGTL_O
+ LXADR[2] LXADR[3] LXADR[4] ROWBKD ROWBKDB ROWBKT ROWBKTB A[0] A[1] A[2] AB[0]
+ LCGTL LXADRB[2] LXADRB[3] LXADRB[4]
XI200 VDDPI VSS VBP VBN net427 net424 LCGTL
+ mm17a04_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=240n
+ wp2=240n
XI209 VDDPI VSS VBP VBN ROWBKDB A[0] mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=240n
XI190 VDDP VSS VBP VBN LCGTB LCGTL mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI208 VDDPI VSS VBP VBN ROWBKTB AB[0] mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=240n
XI187[0] VDDPI VSS VBP VBN LXADR[2] LXADRB[2] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI187[1] VDDPI VSS VBP VBN LXADR[3] LXADRB[3] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI187[2] VDDPI VSS VBP VBN LXADR[4] LXADRB[4] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI199 VDDP VSS VBP VBN LCGTL_O net427 mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI191 VDDPI VSS VBP VBN net424 LCGTB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
.ends

.subckt mm17a04_u_logrep VDDP VSS VBP VBN LOG0 LOG1
MPLOG VDDP LOG0 LOG1 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=3
M0 LOG0 LOG1 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=3
.ends

.subckt mm17a04_u_hdrf2p_sactrl_timer_3x1mux_bk1 VDDP VDDPI VSS VBP VBN STCLK
+ DLY_RDTIMER DLY_RDTIMER_0 DLY_RDTIMER_4 DEF FT1 FT2 RBL STCLK_RST T1T
XI135 VDDPI VSS VBP VBN DLY_RDTIMER_0 RBL mm17a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI150 VDDPI VSS VBP VBN DLY_RDTIMER_4 net325 mm17a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI139 VDDPI VSS VBP VBN net321 net318 mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI144 VDDPI VSS VBP VBN net313 FAST1 mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI138 VDDPI VSS VBP VBN net318 DLY_RDTIMER_0 mm17a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI149 VDDPI VSS VBP VBN net325 net321 mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XT1B VDDPI VSS VBP VBN T1B T1T mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=400n
+ wp=120n
XI97 VDDPI VSS VBP VBN FAST1 net319 mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI134 VDDPI VSS VBP VBN net319 DLY_RDTIMER mm17a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI146 VDDPI VSS VBP VBN DEFAULT net313 mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI102 VDDPI VSS VBP VBN net211 DEF mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI105 VDDPI VSS VBP VBN net225 FT2 mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI104 VDDPI VSS VBP VBN net233 FT1 mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI103 VBP VBN FAST1 net413 FT1 net233 mm17a04_u_tg_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI94 VBP VBN DEFAULT net413 DEF net211 mm17a04_u_tg_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI106 VBP VBN DLY_RDTIMER net413 FT2 net225 mm17a04_u_tg_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI119 VDDPI VSS VBP VBN STCLK net413 STCLK_RST T1B DLY_RDTIMER_0
+ mm17a04_u_nd4_bulk_n1_vt3_n2_vt3_n3_vt3_n4_vt3_p1_vt3_p2_vt3_p3_vt3_p4_vt3
+ cpp=104n p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_n4=4n p_la_p1=4n p_la_p2=4n
+ p_la_p3=4n p_la_p4=4n ulp=0 ln1=20n ln2=20n ln3=20n ln4=20n lp1=20n lp2=20n
+ lp3=20n lp4=20n m_n1=1 m_n2=1 m_n3=1 m_n4=1 m_p1=1 m_p2=1 m_p3=1 m_p4=1
+ nf_n1=1 nf_n2=1 nf_n3=1 nf_n4=1 nf_p1=1 nf_p2=1 nf_p3=1 nf_p4=1 wn1=400n
+ wn2=400n wn3=400n wn4=400n wp1=120n wp2=120n wp3=120n wp4=120n
.ends

.subckt mm17a04_u_hdrf2p_lshift_vddpi_vt2_sactrl_bk1 VDDA VDDP VDDPI VSS VBP
+ VBN WLHVB VCLPSGND WLLVB
XINV VDDPI VSS VBP VBN WLLV WLLVB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
MI4 VDDA WLHVB VAL VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI3 VAH WLLV WLHVB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M1 VDDA OUTB VAH VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI5 VAL WLLVB OUTB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI6 OUTB WLLVB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
MN1 WLHVB WLLV VCLPSGND VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=2
.ends

.subckt mm17a04_u_inv_bulk_n_vt1_p_vt3 VDD VSS VBP VBN X A CPP=104n P_LA_n=4n
+ P_LA_p=4n ULP=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
MNA X A VSS VBN lvtnfet cpp=cpp p_la=p_la_n ulp=ulp nf=nf_n l=ln w=wn m=m_n
MPA X A VDD VBP slvtpfet cpp=cpp p_la=p_la_p ulp=ulp nf=nf_p l=lp w=wp m=m_p
.ends

.subckt mm17a04_u_hdrf2p_selftimer_cvm_bk1 VDDA VDDP VDDPI VSS VBP VBN RFLOAT_H
+ RFLOAT_H_DEL0 RFLOAT_H_DEL2 RFLOAT_H_DEL4 RFLOAT_H_DEL6 RFLTB_DEL_A
+ RFLTB_DEL_B RFLTB_DEL_C RWLB_RD RWLB_WR WFLOAT_H WFLOAT_H_DEL0 WFLOAT_H_DEL2
+ WFLOAT_H_DEL4 WFLOAT_H_DEL6 CLPSEBUFB DEF DLY_RDTIMER DLY_RDTIMER_0
+ DLY_RDTIMER_4 FLOAT FT1 FT2 FT2_WR WFLOAT RBL RFLOAT_H_PGM RFLOAT_PGM
+ STCLK_RD_RST_PGM T1T WFLOAT_H_PGM WFLOAT_PGM
MI61 net199 FLOAT PULLD VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n
+ m=1
MI90 VDDPI T1T net199 VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
MI0 VDDP STCLK FLOAT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=4
XI106 VDDPI VSS VBP VBN RFLTB_DEL_C net309 net309 net309
+ mm17a04_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XI107 VDDPI VSS VBP VBN net309 RFLTB_DEL_B RFLTB_DEL_B RFLTB_DEL_B
+ mm17a04_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XI69 VBP VBN RFLOAT_H_PGM RFLOAT_H FT2B_SHIFT FT2_SHIFT
+ mm17a04_u_tg_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n wp=240n
XI68 VBP VBN RFLOAT_H_DEL0 RFLOAT_H FT2_SHIFT FT2B_SHIFT
+ mm17a04_u_tg_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n wp=240n
XI66 VBP VBN WFLOAT_H_PGM WFLOAT_H FT2B_WR_SHIFT FT2_WR_SHIFT
+ mm17a04_u_tg_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n wp=240n
XI103 VBP VBN WFLOAT_H_DEL0 WFLOAT_H FT2_WR_SHIFT FT2B_WR_SHIFT
+ mm17a04_u_tg_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n wp=240n
XTIMER_SACTRL VDDP VDDPI VSS VBP VBN STCLK DLY_RDTIMER DLY_RDTIMER_0
+ DLY_RDTIMER_4 DEF FT1 FT2 RBL STCLK_RD_RST_PGM T1T
+ mm17a04_u_hdrf2p_sactrl_timer_3x1mux_bk1
XI105 VDDA VDDP VDDPI VSS VBP VBN FT2_SHIFT CLP_VSS FT2
+ mm17a04_u_hdrf2p_lshift_vddpi_vt2_sactrl_bk1
XI102 VDDA VDDP VDDPI VSS VBP VBN FT2_WR_SHIFT CLP_VSS FT2_WR
+ mm17a04_u_hdrf2p_lshift_vddpi_vt2_sactrl_bk1
XI100 VDDA VDDP VDDPI VSS VBP VBN WFLOAT_H_DEL0 CLP_VSS WFLOAT
+ mm17a04_u_hdrf2p_lshift_vddpi_vt2_sactrl_bk1
XI98 VDDA VDDP VDDPI VSS VBP VBN RFLOAT_H_DEL0 CLP_VSS FLOAT
+ mm17a04_u_hdrf2p_lshift_vddpi_vt2_sactrl_bk1
XI94 VDDA VSS VBP VBN FT2B_SHIFT FT2_SHIFT mm17a04_u_inv_bulk_n_vt1_p_vt1
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI65 VDDA VSS VBP VBN FT2B_WR_SHIFT FT2_WR_SHIFT mm17a04_u_inv_bulk_n_vt1_p_vt1
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI59 VDDA VSS VBP VBN RFLOAT_H_DEL2 RFLOAT_H_B mm17a04_u_inv_bulk_n_vt1_p_vt1
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI58 VDDA VSS VBP VBN RFLOAT_H_B RFLOAT_H_DEL0 mm17a04_u_inv_bulk_n_vt1_p_vt1
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI57 VDDA VSS VBP VBN RFLOAT_H_DEL4 RFLOAT_H_D mm17a04_u_inv_bulk_n_vt1_p_vt1
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI56 VDDA VSS VBP VBN RFLOAT_H_D RFLOAT_H_DEL2 mm17a04_u_inv_bulk_n_vt1_p_vt1
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI55 VDDA VSS VBP VBN WFLOAT_H_DEL2 WFLOAT_H_B mm17a04_u_inv_bulk_n_vt1_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI54 VDDA VSS VBP VBN WFLOAT_H_B WFLOAT_H_DEL0 mm17a04_u_inv_bulk_n_vt1_p_vt1
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI53 VDDA VSS VBP VBN WFLOAT_H_DEL4 WFLOAT_H_D mm17a04_u_inv_bulk_n_vt1_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI52 VDDA VSS VBP VBN WFLOAT_H_D WFLOAT_H_DEL2 mm17a04_u_inv_bulk_n_vt1_p_vt1
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI46 VDDA VSS VBP VBN RFLOAT_H_DEL6 RFLOAT_H_F mm17a04_u_inv_bulk_n_vt1_p_vt1
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI45 VDDA VSS VBP VBN RFLOAT_H_F RFLOAT_H_DEL4 mm17a04_u_inv_bulk_n_vt1_p_vt1
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XINV_RWLB_WR VDDA VSS VBP VBN RWLB_WR RWL_WR mm17a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=5 m_p=5 nf_n=1 nf_p=1
+ wn=120n wp=120n
XINV_RWL_WR VDDA VSS VBP VBN RWL_WR WFLOAT_PGM mm17a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI25 VDDPI VSS VBP VBN net120 RFLTB_DEL_A mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI26 VDDPI VSS VBP VBN RFLTB_DEL_B net120 mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI17 VDDPI VSS VBP VBN RFLTB_DEL_A FLOAT mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XINV_RWLB_RD VDDA VSS VBP VBN RWLB_RD RWL_RD mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=5 m_p=5 nf_n=1 nf_p=1
+ wn=120n wp=120n
XINV_RWL_RD VDDA VSS VBP VBN RWL_RD RFLOAT_PGM mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
MI101 VDDA CLPSEBUFB FT2_WR_SHIFT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=120n m=1
MI104 VDDA CLPSEBUFB FT2_SHIFT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=1
MI99 VDDA CLPSEBUFB WFLOAT_H_DEL0 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=120n m=1
MI9 VDDA CLPSEBUFB RFLOAT_H_DEL0 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=1
MI63 PULLD FLOAT VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=180n m=2
MI62 PULLD T1T VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=180n m=2
MI47 CLP_VSS CLPSEBUFB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=3
MI166 CLP_VSS CLPSEBUFB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=6
MI67 FLOAT STCLK net1 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
M40 net1 PULLD VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
.ends

.subckt mm17a04_u_hdrf2p_sactrl_top_bk1 VDDA VDDAPI VDDF VDDP VDDPI VSS VSSWL
+ VBP VBN LCGTL_O OPT_RET PRCHG_T_L PRCHG_T_R RFLOAT_H RFLOAT_H_DEL0
+ RFLOAT_H_DEL2 RFLOAT_H_DEL4 RFLOAT_H_DEL6 RFLT_DEL_A RFLT_DEL_B RFLT_DEL_C
+ ROWBKDB ROWBKTB RWLB_RD RWLB_WR WFLOAT_H WFLOAT_H_DEL0 WFLOAT_H_DEL2
+ WFLOAT_H_DEL4 WFLOAT_H_DEL6 YSEL_L[0] YSEL_L[1] YSEL_L[2] YSEL_L[3] YSEL_R[0]
+ YSEL_R[1] YSEL_R[2] YSEL_R[3] ARYSD CENDP DEF1_RD DEF1_WR DLY_RDTIMER
+ DLY_RDTIMER_0 DLY_RDTIMER_4 FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0
+ LOG1 LRWMEB LXADR[2] LXADR[3] LXADR[4] LXADRB[2] LXADRB[3] LXADRB[4] PAWRB[0]
+ PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+ PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+ PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+ RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] T1TRD T1TWR
+ TKEEPB WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+ WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] CLPSEBUFB
+ LCGT_SACTRL_HV PLBKADR[0] PLBKADR[1] PLBKADR[2] PLBKADRB[0] RFLOAT_H_PGM
+ RFLOAT_PGM STCLK_RD_RST_PGM WFLOAT_H_PGM WFLOAT_PGM
XRDBKSEL VDDP VDDPI VDDP VSS VBP VBN LCGTB LCGTL_O LXADR[2] LXADR[3] LXADR[4]
+ ROWBKD ROWBKDB ROWBKT ROWBKTB PLBKADR[0] PLBKADR[1] PLBKADR[2] PLBKADRB[0]
+ LCGTL LXADRB[2] LXADRB[3] LXADRB[4] mm17a04_u_hdrf2p_bkdec_rd_bk1
XLOGREP VDDP VSS VBP VBN LOG0 LOG1 mm17a04_u_logrep
XND2_PCHT_R VDDP VSS VBP VBN PRCHG_T_R PRCHGB_T LCGTB
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=480n wn2=480n wp1=240n
+ wp2=240n
XND2_PCHT_L VDDP VSS VBP VBN PRCHG_T_L PRCHGB_T LCGTB
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=480n wn2=480n wp1=240n
+ wp2=240n
XND2_YSEL_R[0] VDDP VSS VBP VBN YSEL_R[0] YSELRD[0] LCGTB
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=480n wn2=480n wp1=240n
+ wp2=240n
XND2_YSEL_R[1] VDDP VSS VBP VBN YSEL_R[1] YSELRD[1] LCGTB
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=480n wn2=480n wp1=240n
+ wp2=240n
XND2_YSEL_R[2] VDDP VSS VBP VBN YSEL_R[2] YSELRD[2] LCGTB
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=480n wn2=480n wp1=240n
+ wp2=240n
XND2_YSEL_R[3] VDDP VSS VBP VBN YSEL_R[3] YSELRD[3] LCGTB
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=480n wn2=480n wp1=240n
+ wp2=240n
XI231 VDDPI VSS VBP VBN REFCLK RFLOAT RFLT_RET
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=120n
+ wp2=120n
XND2_YSEL_L[0] VDDP VSS VBP VBN YSEL_L[0] YSELRD[0] LCGTB
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=480n wn2=480n wp1=240n
+ wp2=240n
XND2_YSEL_L[1] VDDP VSS VBP VBN YSEL_L[1] YSELRD[1] LCGTB
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=480n wn2=480n wp1=240n
+ wp2=240n
XND2_YSEL_L[2] VDDP VSS VBP VBN YSEL_L[2] YSELRD[2] LCGTB
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=480n wn2=480n wp1=240n
+ wp2=240n
XND2_YSEL_L[3] VDDP VSS VBP VBN YSEL_L[3] YSELRD[3] LCGTB
+ mm17a04_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=480n wn2=480n wp1=240n
+ wp2=240n
XI225 VDDPI VSS VBP VBN OPT_RET net780 mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI297 VDDPI VSS VBP VBN net780 RFLOAT mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI328 VDDPI VSS VBP VBN PRCHGB_T REFCLK mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=2 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI243 VDDA VSS VBP VBN net779 LCGT_SACTRL_HV mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=120n wp=120n
MI250 VSSWL net779 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=480n
+ m=7
XSELFTIMER VDDA VDDP VDDPI VSS VBP VBN RFLOAT_H RFLOAT_H_DEL0 RFLOAT_H_DEL2
+ RFLOAT_H_DEL4 RFLOAT_H_DEL6 RFLT_DEL_A RFLT_DEL_B RFLT_DEL_C RWLB_RD RWLB_WR
+ WFLOAT_H WFLOAT_H_DEL0 WFLOAT_H_DEL2 WFLOAT_H_DEL4 WFLOAT_H_DEL6 CLPSEBUFB
+ DEF1_RD DLY_RDTIMER DLY_RDTIMER_0 DLY_RDTIMER_4 RFLOAT FAST1_RD FAST2_RD
+ FAST2_WR WFLOAT RDBL RFLOAT_H_PGM RFLOAT_PGM STCLK_RD_RST_PGM T1TRD
+ WFLOAT_H_PGM WFLOAT_PGM mm17a04_u_hdrf2p_selftimer_cvm_bk1
.ends

.subckt mm17a04_u_nd2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=320n wn2=320n wp1=240n wp2=240n
MPA2 X A2 VDD VBP lvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
MPA1 X A1 VDD VBP lvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MNA1 X A1 net22 VBN lvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 net22 A2 VSS VBN lvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
.ends

.subckt mm17a04_u_hdrf2p_corner VSS VBP VBN EDGE_NC1 EDGE_NC2
MNPG_TA net142 VSS VSS VSS tpbnfetwl m=1 w=96n l=30n cpp=110n nf=1 p_la=0
.ends

.subckt mm17a04_u_hdrf2p_sacbuf_bk1 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP
+ VBN PRCHGB_T TKEEPT_LCGTL YSELB_BUF[0] YSELB_BUF[1] YSELB_BUF[2] YSELB_BUF[3]
+ DMY_EDGE_LT DMY_EDGE_T1 LCGTV RASSB[0] RASSB[1] LCGTL PRCHG_T TKEEPB YSELB[0]
+ YSELB[1] YSELB[2] YSELB[3]
XI125 VDDA VSS VBP VBN TKEEPT_LCGTL TKEEPB LCGTB
+ mm17a04_u_nd2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=390n wn2=390n wp1=230n
+ wp2=230n
XDMY_T VSS VBP VBN DMY_EDGE_LT DMY_EDGE_T1 mm17a04_u_hdrf2p_corner
XI116 VDDA VSS VBP VBN LCGTB LCGTL mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=230n
+ wp=230n
XI84[0] VDDA VSS VBP VBN YSELB_BUF[0] net150[0] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=1000n wp=1000n
XI84[1] VDDA VSS VBP VBN YSELB_BUF[1] net150[1] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=1000n wp=1000n
XI84[2] VDDA VSS VBP VBN YSELB_BUF[2] net150[2] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=1000n wp=1000n
XI84[3] VDDA VSS VBP VBN YSELB_BUF[3] net150[3] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=1000n wp=1000n
XI108[0] VDDA VSS VBP VBN net150[0] YSELB[0] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=480n wp=480n
XI108[1] VDDA VSS VBP VBN net150[1] YSELB[1] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=480n wp=480n
XI108[2] VDDA VSS VBP VBN net150[2] YSELB[2] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=480n wp=480n
XI108[3] VDDA VSS VBP VBN net150[3] YSELB[3] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=480n wp=480n
XI64 VDDWL_WR VSS VBP VBN PRCHGB_T PRCHG_T mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=11 m_p=11 nf_n=1 nf_p=1
+ wn=180n wp=180n
MI89 VDDA LCGTV VDDWL_RD VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=5
MI95 VDDA LCGTV VDDWL_WR VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=533n
+ m=3
.ends

.subckt mm17a04_u_hdrf2p_strap_edge_x1 VDDA VDDAI VDDP VDDPI VSS VBP VBN BB BT
+ EDGE_N GATE_NC QT RBL
MPD VSS net08 net231 VBN tpbnfetrpd m=1 w=140n l=30n cpp=110n nf=1 p_la=0
MNPG_TA net245 VSS BB VSS tpbnfetwl m=1 w=96n l=30n cpp=110n nf=1 p_la=0
MNPD_T VSS net08 net235 VSS tpbnfetpd m=1 w=100n l=30n cpp=110n nf=1 p_la=0
MPPU_B VDDAI net08 net240 VSS tpbpfetpu m=1 w=50n l=30n cpp=110n nf=1 p_la=0
.ends

.subckt mm17a04_u_hdrf2p_strap_edge_x4 VDDA VDDAI VDDP VDDPI VSS VBP VBN BB[0]
+ BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3] QT[0] QT[1] QT[2] QT[3] RBL[0]
+ RBL[1] RBL[2] RBL[3]
XEDGE1[0] VDDA VDDAI VDDP VDDPI VSS VBP VBN BB[0] BT[0] EDGE_N1 GATE_NC1 QT[0]
+ RBL[0] mm17a04_u_hdrf2p_strap_edge_x1
XEDGE1[1] VDDA VDDAI VDDP VDDPI VSS VBP VBN BB[1] BT[1] EDGE_MID2 GATE_NC1
+ QT[1] RBL[1] mm17a04_u_hdrf2p_strap_edge_x1
XEDGE1[2] VDDA VDDAI VDDP VDDPI VSS VBP VBN BB[2] BT[2] EDGE_MID1 GATE_NC2
+ QT[2] RBL[2] mm17a04_u_hdrf2p_strap_edge_x1
XEDGE1[3] VDDA VDDAI VDDP VDDPI VSS VBP VBN BB[3] BT[3] EDGE_N2 GATE_NC2 QT[3]
+ RBL[3] mm17a04_u_hdrf2p_strap_edge_x1
.ends

.subckt mm17a04_u_hdrf2p_sac_lite_bk1_rpb128 VDDAI VNWA VSS VBP VBN QT RBLT
+ PRCHG_T SEL_B TKEEPT_LCGTL
MI121 VDDAI TKEEPT_LCGTL net351 VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=1
MI119 net351 SEL_B net344 VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
MI92 net344 RDB RBLT VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
Xsense_inv net287 VSS VBP VBN RDB RBLT mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=300n
MI85 VDDAI PRCHG_T RBLT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=300n
+ m=2
MI82 VDDAI SEL_B net287 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=300n
+ m=2
MNS0 QT RDB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=215n m=4
MI83 RDB SEL_B VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
.ends

.subckt mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128 VDDA VDDAI VDDAI_SAC VDDP VDDPI VSS
+ VBP VBN DMY_EDGE_T1 DMY_EDGE_T2 PRCHGB_T QT[0] QT[1] QT[2] QT[3] RBLT[0]
+ RBLT[1] RBLT[2] RBLT[3] TKEEPT_LCGTL WBLB[0] WBLB[1] WBLB[2] WBLB[3] WBLT[0]
+ WBLT[1] WBLT[2] WBLT[3] YSELB[0] YSELB[1] YSELB[2] YSELB[3]
XINV1 VDDAI_SAC VSS VBP VBN PRCHG_T PRCHGB_T mm17a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=215n wp=120n
XEDGET VDDA VDDAI VDDP VDDPI VSS VBP VBN WBLB[0] WBLB[1] WBLB[2] WBLB[3]
+ WBLT[0] WBLT[1] WBLT[2] WBLT[3] QT[0] QT[1] QT[2] QT[3] RBLT[0] RBLT[1]
+ RBLT[2] RBLT[3] mm17a04_u_hdrf2p_strap_edge_x4
Xcmux_sac[0] VDDAI_SAC VDDA VSS VBP VBN QT[0] RBLT[0] PRCHG_T YSELB[0]
+ TKEEPT_LCGTL mm17a04_u_hdrf2p_sac_lite_bk1_rpb128
Xcmux_sac[1] VDDAI_SAC VDDA VSS VBP VBN QT[1] RBLT[1] PRCHG_T YSELB[1]
+ TKEEPT_LCGTL mm17a04_u_hdrf2p_sac_lite_bk1_rpb128
Xcmux_sac[2] VDDAI_SAC VDDA VSS VBP VBN QT[2] RBLT[2] PRCHG_T YSELB[2]
+ TKEEPT_LCGTL mm17a04_u_hdrf2p_sac_lite_bk1_rpb128
Xcmux_sac[3] VDDAI_SAC VDDA VSS VBP VBN QT[3] RBLT[3] PRCHG_T YSELB[3]
+ TKEEPT_LCGTL mm17a04_u_hdrf2p_sac_lite_bk1_rpb128
.ends

.subckt mm17a04_u_hdrf2p_sacrebuf_bk1 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP
+ VBN REPRCHGB_T RETKEEP_LCGTL REYSELB[0] REYSELB[1] REYSELB[2] REYSELB[3]
+ DMY_EDGE_LT DMY_EDGE_RT DMY_EDGE_T1 DMY_EDGE_T2 LCGTV RASSB[0] RASSB[1]
+ WL_VSS PRCHGB_T TKEEP_LCGTL YSELB[0] YSELB[1] YSELB[2] YSELB[3]
MI103 VDDA LCGTV VDDWL_RD VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=534n
+ m=3
MI112 VDDA LCGTV VDDWL_WR VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=534n
+ m=3
XDMY_T1 VSS VBP VBN DMY_EDGE_RT DMY_EDGE_T2 mm17a04_u_hdrf2p_corner
XDMY_T0 VSS VBP VBN DMY_EDGE_LT DMY_EDGE_T1 mm17a04_u_hdrf2p_corner
XI82 VDDA VSS VBP VBN RETKEEP_LCGTL net147 mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=320n wp=320n
XI88[0] VDDA VSS VBP VBN net139[0] YSELB[0] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=480n wp=480n
XI88[1] VDDA VSS VBP VBN net139[1] YSELB[1] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=480n wp=480n
XI88[2] VDDA VSS VBP VBN net139[2] YSELB[2] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=480n wp=480n
XI88[3] VDDA VSS VBP VBN net139[3] YSELB[3] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=480n wp=480n
XI84[0] VDDA VSS VBP VBN REYSELB[0] net139[0] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=1120n wp=1120n
XI84[1] VDDA VSS VBP VBN REYSELB[1] net139[1] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=1120n wp=1120n
XI84[2] VDDA VSS VBP VBN REYSELB[2] net139[2] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=1120n wp=1120n
XI84[3] VDDA VSS VBP VBN REYSELB[3] net139[3] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=1120n wp=1120n
XI91 VDDA VSS VBP VBN net147 TKEEP_LCGTL mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI64 VDDWL_RD VSS VBP VBN REPRCHGB_T net138 mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=1120n wp=1120n
XI87 VDDA VSS VBP VBN net138 PRCHGB_T mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=480n
+ wp=480n
.ends

.subckt mm17a04_u_hdrf2p_capsac_bk1 VDDP VDDPI VSS VBP VBN DMY_EDGE_RT
+ DMY_EDGE_T2 LOG0 LOG1 PGIOI VEDGE
XCORNER VSS VBP VBN DMY_EDGE_RT DMY_EDGE_T2 mm17a04_u_hdrf2p_corner
.ends

.subckt mm17a04_u_hdrf2p_inv_weak VDDA VDDAI VSS VBP VBN OUT COM IN
MNM3 OUT IN COM VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=2
MNR2_COM_PM VDDAI IN OUT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=150n
+ m=2
.ends

.subckt mm17a04_u_hdrf2p_xdec VDDA VDDP VDDPI VDDWL VSS VSSWL VBP VBN DECB
+ L_WLB[0] L_WLB[1] L_WLB[2] L_WLB[3] WLB[0] WLB[1] WLB[2] WLB[3] DECB_HV
+ WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] XBB XCB XDB
XI190 VDDA SOFTVDD VSS VBP VBN WLBB[1] VSS WCLKB[1] mm17a04_u_hdrf2p_inv_weak
XI189 VDDA SOFTVDD VSS VBP VBN WLBB[2] VSS WCLKB[2] mm17a04_u_hdrf2p_inv_weak
XI188 VDDA SOFTVDD VSS VBP VBN WLBB[3] VSS WCLKB[3] mm17a04_u_hdrf2p_inv_weak
XI191 VDDA SOFTVDD VSS VBP VBN WLBB[0] VSS WCLKB[0] mm17a04_u_hdrf2p_inv_weak
XI180 VDDA VSSWL VBP VBN WLB[1] WLBB[1] mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI185 VDDA VSSWL VBP VBN L_WLB[3] WLBB[3] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=160n wp=160n
XI186 VDDA VSSWL VBP VBN L_WLB[1] WLBB[1] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=160n wp=160n
XI182 VDDA VSSWL VBP VBN WLB[3] WLBB[3] mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI183 VDDA VSSWL VBP VBN L_WLB[2] WLBB[2] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=160n wp=160n
XI178 VDDA VSSWL VBP VBN WLB[0] WLBB[0] mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI181 VDDA VSSWL VBP VBN WLB[2] WLBB[2] mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI184 VDDA VSSWL VBP VBN L_WLB[0] WLBB[0] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=160n wp=160n
XDECNAND VDDPI VSS VBP VBN DECB XBB XCB XDB
+ mm17a04_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=400n
+ wn2=400n wn3=400n wp1=240n wp2=240n wp3=240n
MNM1 WLBB[1] DECB_HV VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=2
MNM3 WLBB[3] DECB_HV VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=2
MNM2 WLBB[2] DECB_HV VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=2
MNM0 WLBB[0] DECB_HV VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=2
MNR2_COM_PM VDDWL DECB_HV SOFTVDD VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=150n m=8
.ends

.subckt mm17a04_u_hdrf2p_rbl_load_rd VDDPI VSS VBP VBN LOG0 RDBL
MNPG_T RDBL LOG0 net57 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n
+ m=1
M14 RDBL LOG0 net57 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
MI28 RDBL LOG0 net57 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
MI29 RDBL LOG0 net57 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
.ends

.subckt mm17a04_u_hdrf2p_rbl_load_wr VSS VBP VBN LOG0 RBLWA RDBL
MI25 RDBL LOG0 RBLWA VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI23 RDBL LOG0 RBLWA VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI24 RDBL LOG0 RBLWA VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI22 RDBL LOG0 RBLWA VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
.ends

.subckt mm17a04_u_hdrf2p_x4dec VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR
+ VSS VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3]
+ WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2]
+ WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128
+ BKRDB_PROG CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL
+ LOG0 LOG1 LRWMEB LXADRB[2] LXADRB[3] LXADRB[4] PAWRB[0] PAWRB[1] PAWRB[2]
+ PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2]
+ PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2]
+ PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2]
+ RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR
+ TKEEPB WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+ WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+ DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB
XWRDEC VDDA VDDP VDDPI VDDWL_WR VSS VSSWL VBP VBN DECBWR WLWRB_L[0] WLWRB_L[1]
+ WLWRB_L[2] WLWRB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3] DECB_HV_WR
+ WCLKWR[0] WCLKWR[1] WCLKWR[2] WCLKWR[3] XBWRB XCWRB XAWRB
+ mm17a04_u_hdrf2p_xdec
XRDDEC VDDA VDDP VDDPI VDDWL_RD VSS VSSWL VBP VBN DECBRD WLRDB_L[0] WLRDB_L[1]
+ WLRDB_L[2] WLRDB_L[3] WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] DECB_HV_RD
+ WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] XBRDB XCRDB BKRDB_PROG
+ mm17a04_u_hdrf2p_xdec
XRDBLLD VDDPI VSS VBP VBN LOG0 RDBL mm17a04_u_hdrf2p_rbl_load_rd
XWDBLLD VSS VBP VBN LOG0 RBLWA WDBL mm17a04_u_hdrf2p_rbl_load_wr
.ends

.subckt mm17a04_u_hdrf2p_edge1 VSS VBP VBN EDGE_BOT EDGE_TOP WLWR
MNPD_B VSS net173 net174 VSS tpbnfetpd m=1 w=100n l=30n cpp=110n nf=1 p_la=0
MNPG_TA VSS WLWR net174 VSS tpbnfetwl m=1 w=96n l=30n cpp=110n nf=1 p_la=0
.ends

.subckt mm17a04_u_hdrf2p_edge4 VSS VBP VBN EDGE_BOT EDGE_TOP WLRD[0] WLRD[1]
+ WLRD[2] WLRD[3] WLWR[0] WLWR[1] WLWR[2] WLWR[3]
XEDGE3 VSS VBP VBN EDGE_TOP VSS WLWR[3] mm17a04_u_hdrf2p_edge1
XEDGE1 VSS VBP VBN net206 VSS WLWR[1] mm17a04_u_hdrf2p_edge1
XEDGE0 VSS VBP VBN EDGE_BOT VSS WLWR[0] mm17a04_u_hdrf2p_edge1
XEDGE2 VSS VBP VBN net206 VSS WLWR[2] mm17a04_u_hdrf2p_edge1
.ends

.subckt mm17a04_u_hdrf2p_xbuf1 VDDWL VDDWL_PCOM VDD_BK VSS VBP VBN WL WLB
MI6 VDDWL WLB WL VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=680n m=4
M17 WL WLB VSS VBN lvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=480n m=4
.ends

.subckt mm17a04_u_read_assist_ulv VDD_BULK VSS VBP VBN RD_ASSIST_BIAS[0]
+ RD_ASSIST_BIAS[1] WL
M0 WL RD_ASSIST_BIAS[0] VSS VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=140n m=2
M1 WL RD_ASSIST_BIAS[1] VSS VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=360n m=2
.ends

.subckt mm17a04_u_hdrf2p_x4buf VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+ WLRD[0] WLRD[1] WLRD[2] WLRD[3] WLWR[0] WLWR[1] WLWR[2] WLWR[3] DMY_EDGE_LB
+ DMY_EDGE_LT LCGTV RASSB[0] RASSB[1] WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3]
+ WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
XEDGE VSS VBP VBN DMY_EDGE_LB DMY_EDGE_LT WLRD[0] WLRD[1] WLRD[2] WLRD[3]
+ WLWR[0] WLWR[1] WLWR[2] WLWR[3] mm17a04_u_hdrf2p_edge4
XBUFRD[0] VDDWL_RD VDDWL_RD VDDA VSS VBP VBN WLRD[0] WLRDB[0]
+ mm17a04_u_hdrf2p_xbuf1
XBUFRD[1] VDDWL_RD VDDWL_RD VDDA VSS VBP VBN WLRD[1] WLRDB[1]
+ mm17a04_u_hdrf2p_xbuf1
XBUFRD[2] VDDWL_RD VDDWL_RD VDDA VSS VBP VBN WLRD[2] WLRDB[2]
+ mm17a04_u_hdrf2p_xbuf1
XBUFRD[3] VDDWL_RD VDDWL_RD VDDA VSS VBP VBN WLRD[3] WLRDB[3]
+ mm17a04_u_hdrf2p_xbuf1
XBUFWR[0] VDDWL_WR VDDWL_WR VDDA VSS VBP VBN WLWR[0] WLWRB[0]
+ mm17a04_u_hdrf2p_xbuf1
XBUFWR[1] VDDWL_WR VDDWL_WR VDDA VSS VBP VBN WLWR[1] WLWRB[1]
+ mm17a04_u_hdrf2p_xbuf1
XBUFWR[2] VDDWL_WR VDDWL_WR VDDA VSS VBP VBN WLWR[2] WLWRB[2]
+ mm17a04_u_hdrf2p_xbuf1
XBUFWR[3] VDDWL_WR VDDWL_WR VDDA VSS VBP VBN WLWR[3] WLWRB[3]
+ mm17a04_u_hdrf2p_xbuf1
XRA[0] VDDA VSS VBP VBN RASSB[0] RASSB[1] WLWR[0] mm17a04_u_read_assist_ulv
XRA[1] VDDA VSS VBP VBN RASSB[0] RASSB[1] WLWR[1] mm17a04_u_read_assist_ulv
XRA[2] VDDA VSS VBP VBN RASSB[0] RASSB[1] WLWR[2] mm17a04_u_read_assist_ulv
XRA[3] VDDA VSS VBP VBN RASSB[0] RASSB[1] WLWR[3] mm17a04_u_read_assist_ulv
.ends

.subckt mm17a04_u_hsram8x_base VDDA VDDNW VSS VSSC VBP VBN BB BT RBL RWL WWL
MPPU_T VDDA RB RT VSS tpbpfetpu m=1 w=50n l=30n cpp=110n nf=1 p_la=0
MPPU_B VDDA RT RB VSS tpbpfetpu m=1 w=50n l=30n cpp=110n nf=1 p_la=0
MNPG_BB XC RWL RBL VBN tpbnfetrwl m=1 w=130n l=30n cpp=110n nf=1 p_la=0
MNPG_BA BB WWL RB VSS tpbnfetwl m=1 w=96n l=30n cpp=110n nf=1 p_la=0
MNPD_T VSSC RB RT VSS tpbnfetpd m=1 w=100n l=30n cpp=110n nf=1 p_la=0
MNPG_TA BT WWL RT VSS tpbnfetwl m=1 w=96n l=30n cpp=110n nf=1 p_la=0
MNPD_B VSSC RT RB VSS tpbnfetpd m=1 w=100n l=30n cpp=110n nf=1 p_la=0
MPD VSSC RB XC VBN tpbnfetrpd m=1 w=140n l=30n cpp=110n nf=1 p_la=0
.ends

.subckt mm17a04_u_hsram8x VDDA VNWA VSS VSSC VBP VBN BB BT RBL RWL WWL
XBASE_2P VDDA VNWA VSS VSSC VBP VBN BB BT RBL RWL WWL mm17a04_u_hsram8x_base
.ends

.subckt mm17a04_u_hsram8t VDDA VNWA VSS VSSC VBP VBN BB BT RBL RWL WWL
XR VDDA VNWA VSS VSSC VBP VBN BB BT RBL RWL WWL mm17a04_u_hsram8x
.ends

.subckt mm17a04_u_hdrf2p_bar4x4m1 VDDA VDDAI VDDP VDDPI VNWA VSS VSSC VBP VBN
+ BB[0] BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3] RBL[0] RBL[1] RBL[2] RBL[3]
+ RWL[0] RWL[1] RWL[2] RWL[3] WWL[0] WWL[1] WWL[2] WWL[3]
XA00 VDDAI VNWA VSS VSSC VBP VBN BB[0] BT[0] RBL[0] RWL[0] WWL[0]
+ mm17a04_u_hsram8t
XA01 VDDAI VNWA VSS VSSC VBP VBN BB[1] BT[1] RBL[1] RWL[0] WWL[0]
+ mm17a04_u_hsram8t
XA02 VDDAI VNWA VSS VSSC VBP VBN BB[2] BT[2] RBL[2] RWL[0] WWL[0]
+ mm17a04_u_hsram8t
XAFF VDDAI VNWA VSS VSSC VBP VBN BB[3] BT[3] RBL[3] RWL[0] WWL[0]
+ mm17a04_u_hsram8t
XC00 VDDAI VNWA VSS VSSC VBP VBN BB[0] BT[0] RBL[0] RWL[2] WWL[2]
+ mm17a04_u_hsram8t
XCFF VDDAI VNWA VSS VSSC VBP VBN BB[3] BT[3] RBL[3] RWL[2] WWL[2]
+ mm17a04_u_hsram8t
XC01 VDDAI VNWA VSS VSSC VBP VBN BB[1] BT[1] RBL[1] RWL[2] WWL[2]
+ mm17a04_u_hsram8t
XBFF VDDAI VNWA VSS VSSC VBP VBN BB[3] BT[3] RBL[3] RWL[1] WWL[1]
+ mm17a04_u_hsram8t
XB02 VDDAI VNWA VSS VSSC VBP VBN BB[2] BT[2] RBL[2] RWL[1] WWL[1]
+ mm17a04_u_hsram8t
XB01 VDDAI VNWA VSS VSSC VBP VBN BB[1] BT[1] RBL[1] RWL[1] WWL[1]
+ mm17a04_u_hsram8t
XB00 VDDAI VNWA VSS VSSC VBP VBN BB[0] BT[0] RBL[0] RWL[1] WWL[1]
+ mm17a04_u_hsram8t
XD02 VDDAI VNWA VSS VSSC VBP VBN BB[2] BT[2] RBL[2] RWL[3] WWL[3]
+ mm17a04_u_hsram8t
XC02 VDDAI VNWA VSS VSSC VBP VBN BB[2] BT[2] RBL[2] RWL[2] WWL[2]
+ mm17a04_u_hsram8t
XD01 VDDAI VNWA VSS VSSC VBP VBN BB[1] BT[1] RBL[1] RWL[3] WWL[3]
+ mm17a04_u_hsram8t
XD00 VDDAI VNWA VSS VSSC VBP VBN BB[0] BT[0] RBL[0] RWL[3] WWL[3]
+ mm17a04_u_hsram8t
XDFF VDDAI VNWA VSS VSSC VBP VBN BB[3] BT[3] RBL[3] RWL[3] WWL[3]
+ mm17a04_u_hsram8t
.ends

.subckt mm17a04_u_hdrf2p_ar4x4m1 VDDA VDDAI VDDAI_SAC VDDP VDDPI VSS VBP VBN
+ BAB[0] BAB[1] BAB[2] BAB[3] BAT[0] BAT[1] BAT[2] BAT[3] QT[0] QT[1] QT[2]
+ QT[3] RBL[0] RBL[1] RBL[2] RBL[3] WLRD[0] WLRD[1] WLRD[2] WLRD[3] WLWR[0]
+ WLWR[1] WLWR[2] WLWR[3]
XBAR4 VDDA VDDAI VDDP VDDPI VDDA VSS VSS VBP VBN BAB[0] BAB[1] BAB[2] BAB[3]
+ BAT[0] BAT[1] BAT[2] BAT[3] RBL[0] RBL[1] RBL[2] RBL[3] WLRD[0] WLRD[1]
+ WLRD[2] WLRD[3] WLWR[0] WLWR[1] WLWR[2] WLWR[3] mm17a04_u_hdrf2p_bar4x4m1
.ends

.subckt mm17a04_u_hdrf2p_xrebuf1 VDDWL VDDWL_PCOM VDD_BK VSS VBP VBN WL WLB
MI6 VDDWL WLB WL VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=680n m=4
M17 WL WLB VSS VBN lvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=470n m=4
.ends

.subckt mm17a04_u_hdrf2p_x4rebuf VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+ REWLRD[0] REWLRD[1] REWLRD[2] REWLRD[3] REWLWR[0] REWLWR[1] REWLWR[2]
+ REWLWR[3] DMY_EDGE_LB DMY_EDGE_LT DMY_EDGE_RB DMY_EDGE_RT LCGTV RASSB[0]
+ RASSB[1] WL_VSS WLRD[0] WLRD[1] WLRD[2] WLRD[3] WLWR[0] WLWR[1] WLWR[2]
+ WLWR[3]
XWLWRB[0] VDDA WL_VSS VBP VBN WLWRB[0] WLWR[0] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=120n wp=120n
XWLWRB[1] VDDA WL_VSS VBP VBN WLWRB[1] WLWR[1] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=120n wp=120n
XWLWRB[2] VDDA WL_VSS VBP VBN WLWRB[2] WLWR[2] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=120n wp=120n
XWLWRB[3] VDDA WL_VSS VBP VBN WLWRB[3] WLWR[3] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=120n wp=120n
XWLRDB[0] VDDA WL_VSS VBP VBN WLRDB[0] WLRD[0] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=120n wp=120n
XWLRDB[1] VDDA WL_VSS VBP VBN WLRDB[1] WLRD[1] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=120n wp=120n
XWLRDB[2] VDDA WL_VSS VBP VBN WLRDB[2] WLRD[2] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=120n wp=120n
XWLRDB[3] VDDA WL_VSS VBP VBN WLRDB[3] WLRD[3] mm17a04_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=120n wp=120n
XEDGE_1 VSS VBP VBN DMY_EDGE_LB DMY_EDGE_LT WLRD[0] WLRD[1] WLRD[2] WLRD[3]
+ WLWR[0] WLWR[1] WLWR[2] WLWR[3] mm17a04_u_hdrf2p_edge4
XEDGE_2 VSS VBP VBN DMY_EDGE_RB DMY_EDGE_RT REWLRD[0] REWLRD[1] REWLRD[2]
+ REWLRD[3] REWLWR[0] REWLWR[1] REWLWR[2] REWLWR[3] mm17a04_u_hdrf2p_edge4
XRA[0] VDDA VSS VBP VBN RASSB[0] RASSB[1] REWLWR[0] mm17a04_u_read_assist_ulv
XRA[1] VDDA VSS VBP VBN RASSB[0] RASSB[1] REWLWR[1] mm17a04_u_read_assist_ulv
XRA[2] VDDA VSS VBP VBN RASSB[0] RASSB[1] REWLWR[2] mm17a04_u_read_assist_ulv
XRA[3] VDDA VSS VBP VBN RASSB[0] RASSB[1] REWLWR[3] mm17a04_u_read_assist_ulv
XBUFRD[0] VDDWL_RD VDDWL_RD VDDA VSS VBP VBN REWLRD[0] WLRDB[0]
+ mm17a04_u_hdrf2p_xrebuf1
XBUFRD[1] VDDWL_RD VDDWL_RD VDDA VSS VBP VBN REWLRD[1] WLRDB[1]
+ mm17a04_u_hdrf2p_xrebuf1
XBUFRD[2] VDDWL_RD VDDWL_RD VDDA VSS VBP VBN REWLRD[2] WLRDB[2]
+ mm17a04_u_hdrf2p_xrebuf1
XBUFRD[3] VDDWL_RD VDDWL_RD VDDA VSS VBP VBN REWLRD[3] WLRDB[3]
+ mm17a04_u_hdrf2p_xrebuf1
XBUFWR[0] VDDWL_WR VDDWL_WR VDDA VSS VBP VBN REWLWR[0] WLWRB[0]
+ mm17a04_u_hdrf2p_xrebuf1
XBUFWR[1] VDDWL_WR VDDWL_WR VDDA VSS VBP VBN REWLWR[1] WLWRB[1]
+ mm17a04_u_hdrf2p_xrebuf1
XBUFWR[2] VDDWL_WR VDDWL_WR VDDA VSS VBP VBN REWLWR[2] WLWRB[2]
+ mm17a04_u_hdrf2p_xrebuf1
XBUFWR[3] VDDWL_WR VDDWL_WR VDDA VSS VBP VBN REWLWR[3] WLWRB[3]
+ mm17a04_u_hdrf2p_xrebuf1
.ends

.subckt mm17a04_u_hdrf2p_edge4_dp VDDA VDDP VDDPI VSS VBP VBN DMY_EDGE_RB
+ DMY_EDGE_RT LOG0 LOG1 PGIOI VEDGE WLRD[0] WLRD[1] WLRD[2] WLRD[3] WLWR[0]
+ WLWR[1] WLWR[2] WLWR[3]
XEDGE VSS VBP VBN DMY_EDGE_RB DMY_EDGE_RT WLRD[0] WLRD[1] WLRD[2] WLRD[3]
+ WLWR[0] WLWR[1] WLWR[2] WLWR[3] mm17a04_u_hdrf2p_edge4
.ends

.subckt mm17a04_u_hdrf2p_rdtimer VDDA VSS VBP VBN DBL LOG1 RMT[0] RMT[1] RMT[2]
+ RMT[3] RWLD
MI170 net338 LOG1 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M159 DBL RWLD net376 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI169 net334 LOG1 net338 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
MI171 net352 RMT[0] net348 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=1
MI173 net360 RMT[1] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
MI177 DBL RWLD net385 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI179 DBL RWLD net393 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M155 net376 RMT[2] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
M152 net277 RMT[0] net352 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
M153 net393 RMT[0] net277 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
M154 net397 RMT[1] net360 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
M158 net373 RMT[3] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
M148 net385 LOG1 net258 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
MI180 DBL RWLD net397 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M149 net258 LOG1 net334 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
MI172 net348 RMT[0] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
M157 DBL RWLD net373 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
M161 VDDA RWLD DBL VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=4
.ends

.subckt mm17a04_u_dp_rwld VDDA VSS VBP VBN PULLD RWLB RWLD
M3 PULLD RWLB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
XI93 VBP VBN RWLD PULLD RWLT RWLB mm17a04_u_tg_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI6 VDDA VSS VBP VBN RWLT RWLB mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=160n
.ends

.subckt mm17a04_u_hdrf2p_rdmarg VDDA VSS VBP VBN RWLBRD RWLDRD_PASS RWLRD_INT
+ LOG1 RDBL RMT[0] RMT[1] RMT[2] RMT[3] RTWL RWLB_RD RWLRD_PROG T1TRD
XI91 VDDA VSS VBP VBN RWLBRD RWLRD_INT mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1 wn=180n
+ wp=180n
XI90 VDDA VSS VBP VBN RWLRD_INT RWLB_RD mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=180n
+ wp=180n
XRDTIMER VDDA VSS VBP VBN RDBL LOG1 RMT[0] RMT[1] RMT[2] RMT[3] RWLRD_PROG
+ mm17a04_u_hdrf2p_rdtimer
XRWLD VDDA VSS VBP VBN RWLDRD_PASS RWLBRD RTWL mm17a04_u_dp_rwld
.ends

.subckt mm17a04_u_hdrf2p_wrtimer VDDP VDDPI VSS VBP VBN DBL LOG1 RMT[0] RMT[1]
+ RMT[2] RMT[3] RWLD
MI174 net365 RMT[0] net361 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=1
M156 net377 RMT[1] net287 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
M157 DBL RWLD net397 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
M155 net334 RMT[2] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
MI175 net369 RMT[0] net365 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=1
MI177 net382 RMT[1] net377 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=1
M159 DBL RWLD net334 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
MI173 net361 RMT[0] net357 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=1
MI169 net342 LOG1 net336 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
MI172 DBL RWLD net350 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M152 net277 RMT[0] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
M153 net357 RMT[0] net277 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
M154 net287 RMT[1] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
MI182 net399 RMT[3] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
M148 net336 LOG1 net258 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
MI170 net346 LOG1 net342 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
M149 net258 LOG1 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI181 DBL RWLD net399 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
M158 net397 RMT[3] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
MI171 net350 LOG1 net346 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
MI178 DBL RWLD net382 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI176 DBL RWLD net369 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M161 VDDPI RWLD DBL VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=480n m=2
.ends

.subckt mm17a04_u_write_delay_slow_rf2p VDDP VDDPI VSS VBP VBN OUT IN RWLB WMT3
M2 net114 net222 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M0 net108 net213 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
XI18 VDDPI VSS VBP VBN net228 net227 net219
+ mm17a04_u_nd2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=120n
+ wp2=120n
XI19 VDDPI VSS VBP VBN net223 net227 net129
+ mm17a04_u_nd2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=120n
+ wp2=120n
M3 VDDPI net222 net113 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
M1 VDDPI net213 net107 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
XI16 VDDPI VSS VBP VBN net129 net226 mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI8 VDDPI VSS VBP VBN WMSLOW WMT3 mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI4 VDDPI VSS VBP VBN net227 IN mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI56 VDDPI VSS VBP VBN net110 net112 mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI51 net107 net108 VBP VBN net226 net213 mm17a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI55 VDDPI VSS VBP VBN net219 net110 mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI67 VDDPI VSS VBP VBN net213 net228 mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI11 VDDPI VSS VBP VBN WMSLOWB WMSLOW mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI5 VDDPI VSS VBP VBN net222 net227 mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI3 net113 net114 VBP VBN net112 net222 mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI7 VBP VBN IN DEF_BYPASS WMSLOWB WMSLOW mm17a04_u_tg_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI106 VBP VBN net223 DEF_BYPASS WMSLOW WMSLOWB mm17a04_u_tg_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI53 VDDPI VSS VBP VBN OUT RWLB DEF_BYPASS
+ mm17a04_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=400n
+ wp2=400n
.ends

.subckt mm17a04_u_hdrf2p_wrmargd VDDA VDDP VDDPI VSS VBP VBN RBLWA RWLBWR
+ RWLB_INT_WR LOG1 WDBL FAST2_WR_MODE RWLB_WR RWLDWR RWL_PROG T1TWR WFLOAT
+ WMT[0] WMT[1] WMT[2] WMT[3]
XWRTIMER VDDP VDDPI VSS VBP VBN WDBL LOG1 WMT[0] WMT[1] WMT[2] WMT[3] RWLD
+ mm17a04_u_hdrf2p_wrtimer
XI97 VDDP VDDPI VSS VBP VBN RWLD net435 RWLB_WR WMT[3]
+ mm17a04_u_write_delay_slow_rf2p
XI2 VDDPI VSS VBP VBN net435 RWL_PROG mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=240n
XI87 VDDP VSS VBP VBN RBLWA WFLOATB mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI88 VDDP VSS VBP VBN WFLOATB WFLOAT mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI90 VDDA VSS VBP VBN RWLB_INT_WR RWLB_WR mm17a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI91 VDDA VSS VBP VBN RWLBWR RWLB_INT_WR mm17a04_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=120n wp=120n
.ends

.subckt mm17a04_u_hdrf2p_rw VDDA VDDAPI VDDF VDDP VDDPI VSS VSSWL VBP VBN LLST
+ RBLWA RWLBRD RWLBWR RWLB_INT_WR RWLDRD_PASS RWLRD_INT ARYSD CENDP LCGTL LOG0
+ LOG1 LRWMEB RDBL RFLOAT RM3CNT T1TRD T1TWR WDBL WFLOAT DEF_RD DEF_WR FAST1_RD
+ FAST1_WR FAST2_RD FAST2_WR LCGTV RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0]
+ RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR RWLDRD RWLDWR RWLRD_PROG RWL_PROG
XRDMARG VDDA VSS VBP VBN RWLBRD RWLDRD_PASS RWLRD_INT LOG1 RDBL RMTRD[0]
+ RMTRD[1] RMTRD[2] RMTRD[3] RWLDRD RWLB_RD RWLRD_PROG T1TRD
+ mm17a04_u_hdrf2p_rdmarg
MI250 VSSWL LCGTBB VSS VBN lvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n
+ m=15
XWRMARG VDDA VDDP VDDPI VSS VBP VBN RBLWA RWLBWR RWLB_INT_WR LOG1 WDBL FAST2_WR
+ RWLB_WR RWLDWR RWL_PROG T1TWR WFLOAT RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3]
+ mm17a04_u_hdrf2p_wrmargd
MI106 VDDP CENDP VDDPI VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=400n
+ m=3
MI107 VDDP CENDP VDDPI VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=400n
+ m=3
XI248 VDDA VSS VBP VBN LCGTBB LCGTV mm17a04_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI12 VDDP VSS VBP VBN LLST ARYSD mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
.ends

.subckt mm17a04_u_hdrf2p_xbuf1_rw VDDWL VDDWL_PCOM VDD_BK VSS VBP VBN WL WLB
MI6 VDDWL WLB WL VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=340n m=8
M17 WL WLB VSS VBN lvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=8
.ends

.subckt mm17a04_u_pg_wlstkdp VDDA VDDWL VBP VBN LCGTH
M0 VDDA LCGTH VDDWL VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=400n m=10
M1 VDDA VDDWL VDDWL VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=2
.ends

.subckt mm17a04_u_hdrf2p_rwbuf VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+ LLSB RWLRD RWLWR DMY_EDGE_LB DMY_EDGE_T1 LCGTV LOG0 LOG1 RWLDRD RWLDWR LLST
+ RWLBRD RWLBWR
XBUFWR VDDA VDDA VDDA VSS VBP VBN RWLWR RWLBWR mm17a04_u_hdrf2p_xbuf1_rw
XBUFRD VDDA VDDA VDDA VSS VBP VBN RWLRD RWLBRD mm17a04_u_hdrf2p_xbuf1_rw
XDMY_T VSS VBP VBN DMY_EDGE_LB DMY_EDGE_T1 mm17a04_u_hdrf2p_corner
XWLSTACK1 VDDA VDDWL_RD VBP VBN LCGTV mm17a04_u_pg_wlstkdp
XWLSTACK2 VDDA VDDWL_WR VBP VBN LCGTV mm17a04_u_pg_wlstkdp
XLSB VDDA VSS VBP VBN LLSB LLST mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=240n
+ wp=240n
.ends

.subckt mm17a04_u_hdrf2p_pgarray_lpg VDDA VDDAI VDDAI_SAC VNWA VBP VBN LLSB
MI18 VDDA LLSB VDDAI VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=300n m=2
MI23 VDDA LLSB VDDAI_SAC VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=300n
+ m=4
.ends

.subckt mm17a04_u_hdrf2p_wlload_wr VSS VBP VBN RWL RWLD
M1 net10 RWL VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M4 VSS RWLD net10 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M8 net014 RWL VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M7 VSS RWLD net014 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
.ends

.subckt mm17a04_u_hdrf2p_wlload_rd VSS VBP VBN RWL RWLD
M1 net13 RWL VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M4 VSS RWLD net13 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
.ends

.subckt mm17a04_u_hdrf2p_rar2x4m1 VDDA VDDAI VDDAI_SAC VDDP VDDPI VSS VBP VBN
+ BAB[0] BAB[1] BAB[2] BAB[3] BAT[0] BAT[1] BAT[2] BAT[3] DMY_EDGE_T1
+ DMY_EDGE_T2 LLSB LOG0 LOG1 QT[0] QT[1] QT[2] QT[3] RBL[0] RBL[1] RBL[2]
+ RBL[3] RWLDRD RWLDWR RWLRD RWLWR
XI47 VDDA VDDAI VDDAI_SAC VDDA VBP VBN LLSB mm17a04_u_hdrf2p_pgarray_lpg
XI0 VSS VBP VBN RWLWR RWLDWR mm17a04_u_hdrf2p_wlload_wr
XI1 VSS VBP VBN RWLWR RWLDWR mm17a04_u_hdrf2p_wlload_wr
XI2 VSS VBP VBN RWLWR RWLDWR mm17a04_u_hdrf2p_wlload_wr
XI3 VSS VBP VBN RWLWR RWLDWR mm17a04_u_hdrf2p_wlload_wr
XI12 VSS VBP VBN RWLRD RWLDRD mm17a04_u_hdrf2p_wlload_rd
XI11 VSS VBP VBN RWLRD RWLDRD mm17a04_u_hdrf2p_wlload_rd
XI10 VSS VBP VBN RWLRD RWLDRD mm17a04_u_hdrf2p_wlload_rd
XI9 VSS VBP VBN RWLRD RWLDRD mm17a04_u_hdrf2p_wlload_rd
XEDGET VDDA VDDAI VDDP VDDPI VSS VBP VBN BAB[0] BAB[1] BAB[2] BAB[3] BAT[0]
+ BAT[1] BAT[2] BAT[3] QT[0] QT[1] QT[2] QT[3] RBL[0] RBL[1] RBL[2] RBL[3]
+ mm17a04_u_hdrf2p_strap_edge_x4
.ends

.subckt mm17a04_u_hdrf2p_rrar2x4m1 VDDA VDDAI VDDAI_SAC VDDP VDDPI VSS VBP VBN
+ BAB[0] BAB[1] BAB[2] BAB[3] BAT[0] BAT[1] BAT[2] BAT[3] DMY_EDGE_T1
+ DMY_EDGE_T2 LLSB LOG0 LOG1 QT[0] QT[1] QT[2] QT[3] RBL[0] RBL[1] RBL[2]
+ RBL[3] RWLDRD RWLDWR
XEDGET VDDA VDDAI VDDP VDDPI VSS VBP VBN BAB[0] BAB[1] BAB[2] BAB[3] BAT[0]
+ BAT[1] BAT[2] BAT[3] QT[0] QT[1] QT[2] QT[3] RBL[0] RBL[1] RBL[2] RBL[3]
+ mm17a04_u_hdrf2p_strap_edge_x4
XI12 VSS VBP VBN RWLDRD RWLDRD mm17a04_u_hdrf2p_wlload_rd
XI9 VSS VBP VBN RWLDRD RWLDRD mm17a04_u_hdrf2p_wlload_rd
XI10 VSS VBP VBN RWLDRD RWLDRD mm17a04_u_hdrf2p_wlload_rd
XI11 VSS VBP VBN RWLDRD RWLDRD mm17a04_u_hdrf2p_wlload_rd
XI3 VSS VBP VBN RWLDWR RWLDWR mm17a04_u_hdrf2p_wlload_wr
XI2 VSS VBP VBN RWLDWR RWLDWR mm17a04_u_hdrf2p_wlload_wr
XI1 VSS VBP VBN RWLDWR RWLDWR mm17a04_u_hdrf2p_wlload_wr
XI0 VSS VBP VBN RWLDWR RWLDWR mm17a04_u_hdrf2p_wlload_wr
XI47 VDDA VDDAI VDDAI_SAC VDDA VBP VBN LLSB mm17a04_u_hdrf2p_pgarray_lpg
.ends

.subckt mm17a04_u_hdrf2p_rwrebuf VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+ RELLSB RWLDRD RWLDWR DMY_EDGE_LB DMY_EDGE_RB DMY_EDGE_T1 DMY_EDGE_T2 LOG0
+ LOG1 WL_VSS LCGTV LLSB RWLRD RWLWR
XI63 VDDA VSS VBP VBN RELLSB net188 mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI97 VDDA VSS VBP VBN net188 LLSB mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI108 VDDA VSS VBP VBN LCGTB LCGTV mm17a04_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XDMY_T1 VSS VBP VBN DMY_EDGE_RB DMY_EDGE_T2 mm17a04_u_hdrf2p_corner
XDMY_T0 VSS VBP VBN DMY_EDGE_LB DMY_EDGE_T1 mm17a04_u_hdrf2p_corner
XI120 VDDA VDDWL_WR VBP VBN LCGTV mm17a04_u_pg_wlstkdp
XI114 VDDA VDDWL_RD VBP VBN LCGTV mm17a04_u_pg_wlstkdp
MI101 WL_VSS LCGTB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=480n
+ m=3
.ends

.subckt mm17a04_u_hdrf2p_pg_pwedge VDDA VDDP VDDPI VSS VBP VBN DMY_EDGE_RB
+ DMY_EDGE_T2 LOG0 LOG1 VEDGE PGIOI
XCORNER VSS VBP VBN DMY_EDGE_RB DMY_EDGE_T2 mm17a04_u_hdrf2p_corner
XI0 VDDP VSS VBP VBN VEDGE PGIOI mm17a04_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=157n
+ wp=157n
.ends

.SUBCKT SNPS_RF_DP_UHD_512x80_gio_cnt ARYSD CENDP CKGATE_RD CLKRD CLKWR DCLKT_H
+       DEF1_RD[1] DEF1_WR[1] DFTCKRD DFTCKWR DFT_OR_SERD DFT_OR_SEWR DLYPDB
+       DLYPW DSORSD FAST1_RD FAST1_WR FAST2_RD FAST2_WR FISO LCLKRDB LCLKRDT
+       LCLKWRB LCLKWRT LITESLP LMERD LMEWR LME_GATING_RD LME_GATING_WR LOG0
+       LOG1 LOG1RMRD_VDDPI LOG1RMWR_VDDPI LOG1_RMRD LOG1_RMWR LRWMEB LS LWE
+       LXADRBRD[0] LXADRBRD[1] LXADRBRD[2] LXADRBRD[3] LXADRBRD[4] LXADRBRD[5]
+       LXADRBRD[6] LXADRBRD[7] LXADRBWR[0] LXADRBWR[1] LXADRBWR[2] LXADRBWR[3]
+       LXADRBWR[4] LXADRBWR[5] LXADRBWR[6] LXADRBWR[7] LXADRRD[0] LXADRRD[1]
+       LXADRRD[2] LXADRRD[3] LXADRRD[4] LXADRRD[5] LXADRRD[6] LXADRRD[7]
+       LXADRWR[0] LXADRWR[1] LXADRWR[2] LXADRWR[3] LXADRWR[4] LXADRWR[5]
+       LXADRWR[6] LXADRWR[7] LYADRBRD[0] LYADRBRD[1] LYADRBWR[0] LYADRBWR[1]
+       LYADRRD[0] LYADRRD[1] LYADRWR[0] LYADRWR[1] MCLKRDB MCLKRDT MCLKWRB
+       MCLKWRT MERD MEWR PROCOM[0] PROCOM[1] RA[0] RA[1] RASSB_H[0] RASSB_H[1]
+       RFLOAT RFLT_RET RMDEF12_RD_PROCOM00[0] RMDEF12_RD_PROCOM00[1]
+       RMDEF12_RD_PROCOM00[2] RMDEF12_RD_PROCOM00[3] RMDEF12_RD_PROCOM01[0]
+       RMDEF12_RD_PROCOM01[1] RMDEF12_RD_PROCOM01[2] RMDEF12_RD_PROCOM01[3]
+       RMDEF12_WR_PROCOM00[0] RMDEF12_WR_PROCOM00[1] RMDEF12_WR_PROCOM00[2]
+       RMDEF12_WR_PROCOM00[3] RMDEF12_WR_PROCOM01[0] RMDEF12_WR_PROCOM01[1]
+       RMDEF12_WR_PROCOM01[2] RMDEF12_WR_PROCOM01[3] RMERD RMEWR RMRD[0]
+       RMRD[1] RMRD[2] RMRD[3] RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0]
+       RMTWR[1] RMTWR[2] RMTWR[3] RMWR[0] RMWR[1] RMWR[2] RMWR[3] RSCEN RSCIN
+       RSCLK RSCOUT RSCRST RWLCKB SEDB SEDT SE_DB SE_DT STRSB T1TRD T1TWR
+       TEST1RD TEST1WR TEST_RNM TKEEPB VBN VBP VDDA VDDP VDDPI VSS WA[0] WA[1]
+       WABUF[0] WABUF[1] WABUF[2] WE WFLOAT WFLT_RET WP[0] WP[1] WP[2] WPBUF[0]
+       WPBUF[1] WPBUF[2] XADRRD[0] XADRRD[1] XADRRD[2] XADRRD[3] XADRRD[4]
+       XADRRD[5] XADRRD[6] XADRRD[7] XADRWR[0] XADRWR[1] XADRWR[2] XADRWR[3]
+       XADRWR[4] XADRWR[5] XADRWR[6] XADRWR[7] YADRRD[0] YADRRD[1] YADRWR[0]
+       YADRWR[1] YCOLRD[0] YCOLRD[1] YCOLRD[2] YCOLRD[3] YSELB_H[0] YSELB_H[1]
+       YSELB_H[2] YSELB_H[3] YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: CLKDELRD CLKFLTRD
* Jumper: CLKDELWR CLKFLTWR
* Jumper: CLKRDB CLKMXB_RD
* Jumper: CLKWRB CLKMXB_WR
* Jumper: LCLKWRT_DEL_2 LCLKWRT_prog
* Jumper: LOG0 ARYSD CENDP DFTCKRD DFTCKWR DFT_OR_SERD DFT_OR_SEWR DLYPW DSORSD SEDT CLPSEBUF RMENI_RD[2] RMENI_WR[2]
* Jumper: LOG1 DLYPDB LME_GATING_RD LME_GATING_WR SEDB RMENI_RD[0] RMENI_RD[1] RMENI_WR[0] RMENI_WR[1]
* Jumper: LOG1RMRD_VDDPI LOG1_RMRD RMDEF1_RD[0] RMDEF1_RD[2] RMDEF1_RD[3] RMDEF2_RD[0] RMDEF2_RD[2] RMDEF2_RD[3] RMSLOW_RD[1] RMSLOW_RD[2] RMSLOW_RD[3]
* Jumper: LOG1RMWR_VDDPI LOG1_RMWR RMDEF1_WR[0] RMDEF1_WR[2] RMDEF2_WR[3] RMSLOW_WR[0] RMSLOW_WR[1] RMSLOW_WR[3]
* Jumper: VDDP VDDA VDDPI
* Jumper: VSS RMDEF1_RD[1] RMDEF1_WR[1] RMDEF1_WR[3] RMDEF2_RD[1] RMDEF2_WR[0] RMDEF2_WR[1] RMDEF2_WR[2] RMSLOW_RD[0] RMSLOW_WR[2]
* Jumper: YCOLRD[0] OPT_Y[0] OPT_Y[2]
* Jumper: YCOLRD[1] OPT_Y[1] OPT_Y[3]

*X_mm17a04_u_hdrf2p_gcen_edgel_cm2_cm4 VDDA VDDP VSS VBP VBN
*+  mm17a04_u_hdrf2p_gcen_edgel_cm2_cm4
X_mm17a04_u_hdrf2p_gcen_cm2_cm4 VDDP VDDPI VSS VBP VBN CKGATE_RD CLKDELRD
+   CLKDELWR CLKRDB CLKWRB DCKBIO_L DCKBIO_R DEF1B_RD DEF1B_WR DEF1_RD[0]
+   DEF1_WR[0] DEF2B_RD DEF2B_WR DEF2_RD DEF2_WR DEF1_RD[1] DEF1_WR[1] FAST1_RD
+   FAST1_WR FAST2_RD FAST2_WR LCLKRDB LCLKRDT LCLKWRB LCLKWRT LCLKWRT_DEL_2
+   LCLKWRT_DEL_4 LITESLP LMERD LMEWR LRWMEB LWE LXADRBRD[0] LXADRBRD[1]
+   LXADRBRD[2] LXADRBRD[3] LXADRBRD[4] LXADRBRD[5] LXADRBRD[6] LXADRBRD[7]
+   LXADRBWR[0] LXADRBWR[1] LXADRBWR[2] LXADRBWR[3] LXADRBWR[4] LXADRBWR[5]
+   LXADRBWR[6] LXADRBWR[7] LXADRRD[0] LXADRRD[1] LXADRRD[2] LXADRRD[3]
+   LXADRRD[4] LXADRRD[5] LXADRRD[6] LXADRRD[7] LXADRWR[0] LXADRWR[1] LXADRWR[2]
+   LXADRWR[3] LXADRWR[4] LXADRWR[5] LXADRWR[6] LXADRWR[7] LYADRBRD[0]
+   LYADRBRD[1] LYADRBWR[0] LYADRBWR[1] LYADRRD[0] LYADRRD[1] LYADRWR[0]
+   LYADRWR[1] MCLKRDB MCLKRDT MCLKWRB MCLKWRT RABUF[0] RABUF[1] RFLOAT RMTRD[0]
+   RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLCKB STRSB
+   T1TRD T1TWR TKEEPB WABUF[0] WABUF[1] WABUF[2] WFLOAT WPBUF[0] WPBUF[1]
+   WPBUF[2] YSELIO[0] YSELIO[1] YSELIO[2] YSELIO[3] YSELRD[0] YSELRD[1]
+   YSELRD[2] YSELRD[3] ARYSD CENDP FISO LOG0 LOG1 LOG1RMRD_VDDPI LOG1RMWR_VDDPI
+   LOG1_RMRD LOG1_RMWR RSCEN RSCIN RSCLK RSCOUT RSCRST YCOLRD[0] YCOLRD[1]
+   YCOLRD[2] YCOLRD[3] CLKDELRD CLKDELWR CLKRDB CLKWRB CLKRD CLKWR LOG0
+   DEF12B_RD_PGM DEF12B_WR_PGM DEF12_RD_PGM DEF12_WR_PGM DEF_RD_PGM DEF_WR_PGM
+   DFTCKRD DFTCKWR DFT_OR_SERD DFT_OR_SEWR DLYPW DSORSD LCLKWRT_DEL_2
+   LME_GATING_RD LME_GATING_WR LS MERD MEWR YCOLRD[0] YCOLRD[1] YCOLRD[0]
+   YCOLRD[1] PROCOM[0] PROCOM[1] RA[0] RA[1] RFLT_RET RMDEF12_RD_PROCOM00[0]
+   RMDEF12_RD_PROCOM00[1] RMDEF12_RD_PROCOM00[2] RMDEF12_RD_PROCOM00[3]
+   RMDEF12_RD_PROCOM01[0] RMDEF12_RD_PROCOM01[1] RMDEF12_RD_PROCOM01[2]
+   RMDEF12_RD_PROCOM01[3] RMDEF12_WR_PROCOM00[0] RMDEF12_WR_PROCOM00[1]
+   RMDEF12_WR_PROCOM00[2] RMDEF12_WR_PROCOM00[3] RMDEF12_WR_PROCOM01[0]
+   RMDEF12_WR_PROCOM01[1] RMDEF12_WR_PROCOM01[2] RMDEF12_WR_PROCOM01[3]
+   LOG1RMRD_VDDPI VSS LOG1RMRD_VDDPI LOG1RMRD_VDDPI LOG1RMWR_VDDPI VSS
+   LOG1RMWR_VDDPI VSS LOG1RMRD_VDDPI VSS LOG1RMRD_VDDPI LOG1RMRD_VDDPI VSS VSS
+   VSS LOG1RMWR_VDDPI LOG1 LOG1 LOG0 LOG1 LOG1 LOG0 RMERD RMEWR RMRD[0] RMRD[1]
+   RMRD[2] RMRD[3] VSS LOG1RMRD_VDDPI LOG1RMRD_VDDPI LOG1RMRD_VDDPI
+   LOG1RMWR_VDDPI LOG1RMWR_VDDPI VSS LOG1RMWR_VDDPI RMWR[0] RMWR[1] RMWR[2]
+   RMWR[3] TEST1RD TEST1WR TEST_RNM WA[0] WA[1] WE WFLT_RET WP[0] WP[1] WP[2]
+   XADRRD[0] XADRRD[1] XADRRD[2] XADRRD[3] XADRRD[4] XADRRD[5] XADRRD[6]
+   XADRRD[7] XADRWR[0] XADRWR[1] XADRWR[2] XADRWR[3] XADRWR[4] XADRWR[5]
+   XADRWR[6] XADRWR[7] YADRRD[0] YADRRD[1] YADRWR[0] YADRWR[1]
+   mm17a04_u_hdrf2p_gcen
X_mm17a04_u_hdrf2p_gcenbuf_cm2_cm4 VDDA VDDP VDDPI VSS VBP VBN DCLKT_H
+   RASSB_H[0] RASSB_H[1] SE_DB SE_DT YSELB_H[0] YSELB_H[1] YSELB_H[2]
+   YSELB_H[3] LOG0 LOG1 DCKBIO_R DLYPDB LCLKRDB LCLKRDT RABUF[0] RABUF[1] SEDB
+   SEDT YSELIO[0] YSELIO[1] YSELIO[2] YSELIO[3] mm17a04_u_hdrf2p_gcenbuf
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_gio_rt_seg1 CB[0] CB[1] CB[2] CB[3] CB[4] CB[5]
+       CB[6] CB[7] CB[8] CB[9] CB[10] CB[11] CB[12] CB[13] CB[14] CB[15] CB[16]
+       CB[17] CB[18] CB[19] CT[0] CT[1] CT[2] CT[3] CT[4] CT[5] CT[6] CT[7]
+       CT[8] CT[9] CT[10] CT[11] CT[12] CT[13] CT[14] CT[15] CT[16] CT[17]
+       CT[18] CT[19] D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] D[8] D[9] D[10]
+       D[11] D[12] D[13] D[14] D[15] D[16] D[17] D[18] D[19] D[20] D[21] D[22]
+       D[23] D[24] D[25] D[26] D[27] D[28] D[29] D[30] D[31] D[32] D[33] D[34]
+       D[35] D[36] D[37] D[38] D[39] DCLKT DFTBIO[0] DFTBIO[1] DFTBIO[2]
+       DFTBIO[3] DFTBIO[4] DFTBIO[5] DFTBIO[6] DFTBIO[7] DFTBIO[8] DFTBIO[9]
+       DFTBIO[10] DFTBIO[11] DFTBIO[12] DFTBIO[13] DFTBIO[14] DFTBIO[15]
+       DFTBIO[16] DFTBIO[17] DFTBIO[18] DFTBIO[19] DFTBIOB[0] DFTBIOB[1]
+       DFTBIOB[2] DFTBIOB[3] DFTBIOB[4] DFTBIOB[5] DFTBIOB[6] DFTBIOB[7]
+       DFTBIOB[8] DFTBIOB[9] DFTBIOB[10] DFTBIOB[11] DFTBIOB[12] DFTBIOB[13]
+       DFTBIOB[14] DFTBIOB[15] DFTBIOB[16] DFTBIOB[17] DFTBIOB[18] DFTBIOB[19]
+       DIB_LT[0] DIB_LT[1] DIB_LT[2] DIB_LT[3] DIB_LT[4] DIB_LT[5] DIB_LT[6]
+       DIB_LT[7] DIB_LT[8] DIB_LT[9] DIB_LT[10] DIB_LT[11] DIB_LT[12]
+       DIB_LT[13] DIB_LT[14] DIB_LT[15] DIB_LT[16] DIB_LT[17] DIB_LT[18]
+       DIB_LT[19] DIB_LT[20] DIB_LT[21] DIB_LT[22] DIB_LT[23] DIB_LT[24]
+       DIB_LT[25] DIB_LT[26] DIB_LT[27] DIB_LT[28] DIB_LT[29] DIB_LT[30]
+       DIB_LT[31] DIB_LT[32] DIB_LT[33] DIB_LT[34] DIB_LT[35] DIB_LT[36]
+       DIB_LT[37] DIB_LT[38] DIB_LT[39] DINB[0] DINB[1] DINB[2] DINB[3] DINB[4]
+       DINB[5] DINB[6] DINB[7] DINB[8] DINB[9] DINB[10] DINB[11] DINB[12]
+       DINB[13] DINB[14] DINB[15] DINB[16] DINB[17] DINB[18] DINB[19] DINB[20]
+       DINB[21] DINB[22] DINB[23] DINB[24] DINB[25] DINB[26] DINB[27] DINB[28]
+       DINB[29] DINB[30] DINB[31] DINB[32] DINB[33] DINB[34] DINB[35] DINB[36]
+       DINB[37] DINB[38] DINB[39] LDIB[0] LDIB[1] LDIB[2] LDIB[3] LDIB[4]
+       LDIB[5] LDIB[6] LDIB[7] LDIB[8] LDIB[9] LDIB[10] LDIB[11] LDIB[12]
+       LDIB[13] LDIB[14] LDIB[15] LDIB[16] LDIB[17] LDIB[18] LDIB[19] LDIB[20]
+       LDIB[21] LDIB[22] LDIB[23] LDIB[24] LDIB[25] LDIB[26] LDIB[27] LDIB[28]
+       LDIB[29] LDIB[30] LDIB[31] LDIB[32] LDIB[33] LDIB[34] LDIB[35] LDIB[36]
+       LDIB[37] LDIB[38] LDIB[39] LOG0 LOG1 LQB[0] LQB[1] LQB[2] LQB[3] LQB[4]
+       LQB[5] LQB[6] LQB[7] LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13]
+       LQB[14] LQB[15] LQB[16] LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22]
+       LQB[23] LQB[24] LQB[25] LQB[26] LQB[27] LQB[28] LQB[29] LQB[30] LQB[31]
+       LQB[32] LQB[33] LQB[34] LQB[35] LQB[36] LQB[37] LQB[38] LQB[39] Q[0]
+       Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13]
+       Q[14] Q[15] Q[16] Q[17] Q[18] Q[19] Q[20] Q[21] Q[22] Q[23] Q[24] Q[25]
+       Q[26] Q[27] Q[28] Q[29] Q[30] Q[31] Q[32] Q[33] Q[34] Q[35] Q[36] Q[37]
+       Q[38] Q[39] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9]
+       QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17] QT[18] QT[19]
+       QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28] QT[29]
+       QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38] QT[39]
+       QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49]
+       QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59]
+       QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+       QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79]
+       RASSB[0] RASSB[1] SE_DB SE_DT VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5]
+       VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14]
+       VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBP[0] VBP[1] VBP[2] VBP[3]
+       VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+       VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VDDP[0] VDDP[1]
+       VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+       VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+       VDDP[19] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6]
+       VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13]
+       VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VSS[0]
+       VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+       VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19]
+       WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9]
+       WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18]
+       WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27]
+       WBI[28] WBI[29] WBI[30] WBI[31] WBI[32] WBI[33] WBI[34] WBI[35] WBI[36]
+       WBI[37] WBI[38] WBI[39] WEM[0] WEM[1] WEM[2] WEM[3] WEM[4] WEM[5] WEM[6]
+       WEM[7] WEM[8] WEM[9] WEM[10] WEM[11] WEM[12] WEM[13] WEM[14] WEM[15]
+       WEM[16] WEM[17] WEM[18] WEM[19] WEM[20] WEM[21] WEM[22] WEM[23] WEM[24]
+       WEM[25] WEM[26] WEM[27] WEM[28] WEM[29] WEM[30] WEM[31] WEM[32] WEM[33]
+       WEM[34] WEM[35] WEM[36] WEM[37] WEM[38] WEM[39] WEMB[0] WEMB[1] WEMB[2]
+       WEMB[3] WEMB[4] WEMB[5] WEMB[6] WEMB[7] WEMB[8] WEMB[9] WEMB[10]
+       WEMB[11] WEMB[12] WEMB[13] WEMB[14] WEMB[15] WEMB[16] WEMB[17] WEMB[18]
+       WEMB[19] WEMB[20] WEMB[21] WEMB[22] WEMB[23] WEMB[24] WEMB[25] WEMB[26]
+       WEMB[27] WEMB[28] WEMB[29] WEMB[30] WEMB[31] WEMB[32] WEMB[33] WEMB[34]
+       WEMB[35] WEMB[36] WEMB[37] WEMB[38] WEMB[39] WTI[0] WTI[1] WTI[2] WTI[3]
+       WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12]
+       WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21]
+       WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27] WTI[28] WTI[29] WTI[30]
+       WTI[31] WTI[32] WTI[33] WTI[34] WTI[35] WTI[36] WTI[37] WTI[38] WTI[39]
+       YSELB[0] YSELB[1] YSELB[2] YSELB[3]

*** Jumper Report ***
* Jumper: DINB[0] D_AL[0]
* Jumper: DINB[1] D_AL[1]
* Jumper: DINB[2] D_AL[2]
* Jumper: DINB[3] D_AL[3]
* Jumper: DINB[4] D_AL[4]
* Jumper: DINB[5] D_AL[5]
* Jumper: DINB[6] D_AL[6]
* Jumper: DINB[7] D_AL[7]
* Jumper: DINB[8] D_AL[8]
* Jumper: DINB[9] D_AL[9]
* Jumper: DINB[10] D_AL[10]
* Jumper: DINB[11] D_AL[11]
* Jumper: DINB[12] D_AL[12]
* Jumper: DINB[13] D_AL[13]
* Jumper: DINB[14] D_AL[14]
* Jumper: DINB[15] D_AL[15]
* Jumper: DINB[16] D_AL[16]
* Jumper: DINB[17] D_AL[17]
* Jumper: DINB[18] D_AL[18]
* Jumper: DINB[19] D_AL[19]
* Jumper: DINB[20] D_AL[20]
* Jumper: DINB[21] D_AL[21]
* Jumper: DINB[22] D_AL[22]
* Jumper: DINB[23] D_AL[23]
* Jumper: DINB[24] D_AL[24]
* Jumper: DINB[25] D_AL[25]
* Jumper: DINB[26] D_AL[26]
* Jumper: DINB[27] D_AL[27]
* Jumper: DINB[28] D_AL[28]
* Jumper: DINB[29] D_AL[29]
* Jumper: DINB[30] D_AL[30]
* Jumper: DINB[31] D_AL[31]
* Jumper: DINB[32] D_AL[32]
* Jumper: DINB[33] D_AL[33]
* Jumper: DINB[34] D_AL[34]
* Jumper: DINB[35] D_AL[35]
* Jumper: DINB[36] D_AL[36]
* Jumper: DINB[37] D_AL[37]
* Jumper: DINB[38] D_AL[38]
* Jumper: DINB[39] D_AL[39]
* Jumper: LOG0 DFTBIO[0] DFTBIO[1] DFTBIO[2] DFTBIO[3] DFTBIO[4] DFTBIO[5] DFTBIO[6] DFTBIO[7] DFTBIO[8] DFTBIO[9] DFTBIO[10] DFTBIO[11] DFTBIO[12] DFTBIO[13] DFTBIO[14] DFTBIO[15] DFTBIO[16] DFTBIO[17] DFTBIO[18] DFTBIO[19]
* Jumper: LOG1 DFTBIOB[0] DFTBIOB[1] DFTBIOB[2] DFTBIOB[3] DFTBIOB[4] DFTBIOB[5] DFTBIOB[6] DFTBIOB[7] DFTBIOB[8] DFTBIOB[9] DFTBIOB[10] DFTBIOB[11] DFTBIOB[12] DFTBIOB[13] DFTBIOB[14] DFTBIOB[15] DFTBIOB[16] DFTBIOB[17] DFTBIOB[18] DFTBIOB[19] WEM[0] WEM[1] WEM[2] WEM[3] WEM[4] WEM[5] WEM[6] WEM[7] WEM[8] WEM[9] WEM[10] WEM[11] WEM[12] WEM[13] WEM[14] WEM[15] WEM[16] WEM[17] WEM[18] WEM[19] WEM[20] WEM[21] WEM[22] WEM[23] WEM[24] WEM[25] WEM[26] WEM[27] WEM[28] WEM[29] WEM[30] WEM[31] WEM[32] WEM[33] WEM[34] WEM[35] WEM[36] WEM[37] WEM[38] WEM[39]
* Jumper: VDDP[0] VDDPI[0]
* Jumper: VDDP[1] VDDPI[1]
* Jumper: VDDP[2] VDDPI[2]
* Jumper: VDDP[3] VDDPI[3]
* Jumper: VDDP[4] VDDPI[4]
* Jumper: VDDP[5] VDDPI[5]
* Jumper: VDDP[6] VDDPI[6]
* Jumper: VDDP[7] VDDPI[7]
* Jumper: VDDP[8] VDDPI[8]
* Jumper: VDDP[9] VDDPI[9]
* Jumper: VDDP[10] VDDPI[10]
* Jumper: VDDP[11] VDDPI[11]
* Jumper: VDDP[12] VDDPI[12]
* Jumper: VDDP[13] VDDPI[13]
* Jumper: VDDP[14] VDDPI[14]
* Jumper: VDDP[15] VDDPI[15]
* Jumper: VDDP[16] VDDPI[16]
* Jumper: VDDP[17] VDDPI[17]
* Jumper: VDDP[18] VDDPI[18]
* Jumper: VDDP[19] VDDPI[19]
* Jumper: WEMB[0] WEM_AL[0]
* Jumper: WEMB[1] WEM_AL[1]
* Jumper: WEMB[2] WEM_AL[2]
* Jumper: WEMB[3] WEM_AL[3]
* Jumper: WEMB[4] WEM_AL[4]
* Jumper: WEMB[5] WEM_AL[5]
* Jumper: WEMB[6] WEM_AL[6]
* Jumper: WEMB[7] WEM_AL[7]
* Jumper: WEMB[8] WEM_AL[8]
* Jumper: WEMB[9] WEM_AL[9]
* Jumper: WEMB[10] WEM_AL[10]
* Jumper: WEMB[11] WEM_AL[11]
* Jumper: WEMB[12] WEM_AL[12]
* Jumper: WEMB[13] WEM_AL[13]
* Jumper: WEMB[14] WEM_AL[14]
* Jumper: WEMB[15] WEM_AL[15]
* Jumper: WEMB[16] WEM_AL[16]
* Jumper: WEMB[17] WEM_AL[17]
* Jumper: WEMB[18] WEM_AL[18]
* Jumper: WEMB[19] WEM_AL[19]
* Jumper: WEMB[20] WEM_AL[20]
* Jumper: WEMB[21] WEM_AL[21]
* Jumper: WEMB[22] WEM_AL[22]
* Jumper: WEMB[23] WEM_AL[23]
* Jumper: WEMB[24] WEM_AL[24]
* Jumper: WEMB[25] WEM_AL[25]
* Jumper: WEMB[26] WEM_AL[26]
* Jumper: WEMB[27] WEM_AL[27]
* Jumper: WEMB[28] WEM_AL[28]
* Jumper: WEMB[29] WEM_AL[29]
* Jumper: WEMB[30] WEM_AL[30]
* Jumper: WEMB[31] WEM_AL[31]
* Jumper: WEMB[32] WEM_AL[32]
* Jumper: WEMB[33] WEM_AL[33]
* Jumper: WEMB[34] WEM_AL[34]
* Jumper: WEMB[35] WEM_AL[35]
* Jumper: WEMB[36] WEM_AL[36]
* Jumper: WEMB[37] WEM_AL[37]
* Jumper: WEMB[38] WEM_AL[38]
* Jumper: WEMB[39] WEM_AL[39]

X_mm17a04_u_hdrf2p_giom2x2_S0 VDDP[0] VDDPI[0] VSS[0] VBP[0] VBN[0] DINB[0]
+   DINB[1] LDIB[0] LDIB[1] Q[0] Q[1] WBI[0] WBI[1] WEMB[0] WEMB[1] WTI[0]
+   WTI[1] CB[0] CT[0] DIB_LT[0] DIB_LT[1] LOG0 LOG1 LQB[0] LQB[1] RASSB[0]
+   RASSB[1] D[0] D[1] DCLKT DFTBIO[0] DFTBIOB[0] DINB[0] DINB[1] QT[0] QT[1]
+   QT[2] QT[3] SE_DB SE_DT WEM[0] WEM[1] WEMB[0] WEMB[1] YSELB[0] YSELB[1]
+   YSELB[2] YSELB[3] mm17a04_u_hdrf2p_giom2x2
X_mm17a04_u_hdrf2p_giom2x2_S1 VDDP[1] VDDPI[1] VSS[1] VBP[1] VBN[1] DINB[2]
+   DINB[3] LDIB[2] LDIB[3] Q[2] Q[3] WBI[2] WBI[3] WEMB[2] WEMB[3] WTI[2]
+   WTI[3] CB[1] CT[1] DIB_LT[2] DIB_LT[3] LOG0 LOG1 LQB[2] LQB[3] RASSB[0]
+   RASSB[1] D[2] D[3] DCLKT DFTBIO[1] DFTBIOB[1] DINB[2] DINB[3] QT[4] QT[5]
+   QT[6] QT[7] SE_DB SE_DT WEM[2] WEM[3] WEMB[2] WEMB[3] YSELB[0] YSELB[1]
+   YSELB[2] YSELB[3] mm17a04_u_hdrf2p_giom2x2
X_mm17a04_u_hdrf2p_giom2x2_S2 VDDP[2] VDDPI[2] VSS[2] VBP[2] VBN[2] DINB[4]
+   DINB[5] LDIB[4] LDIB[5] Q[4] Q[5] WBI[4] WBI[5] WEMB[4] WEMB[5] WTI[4]
+   WTI[5] CB[2] CT[2] DIB_LT[4] DIB_LT[5] LOG0 LOG1 LQB[4] LQB[5] RASSB[0]
+   RASSB[1] D[4] D[5] DCLKT DFTBIO[2] DFTBIOB[2] DINB[4] DINB[5] QT[8] QT[9]
+   QT[10] QT[11] SE_DB SE_DT WEM[4] WEM[5] WEMB[4] WEMB[5] YSELB[0] YSELB[1]
+   YSELB[2] YSELB[3] mm17a04_u_hdrf2p_giom2x2
X_mm17a04_u_hdrf2p_giom2x2_S3 VDDP[3] VDDPI[3] VSS[3] VBP[3] VBN[3] DINB[6]
+   DINB[7] LDIB[6] LDIB[7] Q[6] Q[7] WBI[6] WBI[7] WEMB[6] WEMB[7] WTI[6]
+   WTI[7] CB[3] CT[3] DIB_LT[6] DIB_LT[7] LOG0 LOG1 LQB[6] LQB[7] RASSB[0]
+   RASSB[1] D[6] D[7] DCLKT DFTBIO[3] DFTBIOB[3] DINB[6] DINB[7] QT[12] QT[13]
+   QT[14] QT[15] SE_DB SE_DT WEM[6] WEM[7] WEMB[6] WEMB[7] YSELB[0] YSELB[1]
+   YSELB[2] YSELB[3] mm17a04_u_hdrf2p_giom2x2
X_mm17a04_u_hdrf2p_giom2x2_S4 VDDP[4] VDDPI[4] VSS[4] VBP[4] VBN[4] DINB[8]
+   DINB[9] LDIB[8] LDIB[9] Q[8] Q[9] WBI[8] WBI[9] WEMB[8] WEMB[9] WTI[8]
+   WTI[9] CB[4] CT[4] DIB_LT[8] DIB_LT[9] LOG0 LOG1 LQB[8] LQB[9] RASSB[0]
+   RASSB[1] D[8] D[9] DCLKT DFTBIO[4] DFTBIOB[4] DINB[8] DINB[9] QT[16] QT[17]
+   QT[18] QT[19] SE_DB SE_DT WEM[8] WEM[9] WEMB[8] WEMB[9] YSELB[0] YSELB[1]
+   YSELB[2] YSELB[3] mm17a04_u_hdrf2p_giom2x2
X_mm17a04_u_hdrf2p_giom2x2_S5 VDDP[5] VDDPI[5] VSS[5] VBP[5] VBN[5] DINB[10]
+   DINB[11] LDIB[10] LDIB[11] Q[10] Q[11] WBI[10] WBI[11] WEMB[10] WEMB[11]
+   WTI[10] WTI[11] CB[5] CT[5] DIB_LT[10] DIB_LT[11] LOG0 LOG1 LQB[10] LQB[11]
+   RASSB[0] RASSB[1] D[10] D[11] DCLKT DFTBIO[5] DFTBIOB[5] DINB[10] DINB[11]
+   QT[20] QT[21] QT[22] QT[23] SE_DB SE_DT WEM[10] WEM[11] WEMB[10] WEMB[11]
+   YSELB[0] YSELB[1] YSELB[2] YSELB[3] mm17a04_u_hdrf2p_giom2x2
X_mm17a04_u_hdrf2p_giom2x2_S6 VDDP[6] VDDPI[6] VSS[6] VBP[6] VBN[6] DINB[12]
+   DINB[13] LDIB[12] LDIB[13] Q[12] Q[13] WBI[12] WBI[13] WEMB[12] WEMB[13]
+   WTI[12] WTI[13] CB[6] CT[6] DIB_LT[12] DIB_LT[13] LOG0 LOG1 LQB[12] LQB[13]
+   RASSB[0] RASSB[1] D[12] D[13] DCLKT DFTBIO[6] DFTBIOB[6] DINB[12] DINB[13]
+   QT[24] QT[25] QT[26] QT[27] SE_DB SE_DT WEM[12] WEM[13] WEMB[12] WEMB[13]
+   YSELB[0] YSELB[1] YSELB[2] YSELB[3] mm17a04_u_hdrf2p_giom2x2
X_mm17a04_u_hdrf2p_giom2x2_S7 VDDP[7] VDDPI[7] VSS[7] VBP[7] VBN[7] DINB[14]
+   DINB[15] LDIB[14] LDIB[15] Q[14] Q[15] WBI[14] WBI[15] WEMB[14] WEMB[15]
+   WTI[14] WTI[15] CB[7] CT[7] DIB_LT[14] DIB_LT[15] LOG0 LOG1 LQB[14] LQB[15]
+   RASSB[0] RASSB[1] D[14] D[15] DCLKT DFTBIO[7] DFTBIOB[7] DINB[14] DINB[15]
+   QT[28] QT[29] QT[30] QT[31] SE_DB SE_DT WEM[14] WEM[15] WEMB[14] WEMB[15]
+   YSELB[0] YSELB[1] YSELB[2] YSELB[3] mm17a04_u_hdrf2p_giom2x2
X_mm17a04_u_hdrf2p_giom2x2_S8 VDDP[8] VDDPI[8] VSS[8] VBP[8] VBN[8] DINB[16]
+   DINB[17] LDIB[16] LDIB[17] Q[16] Q[17] WBI[16] WBI[17] WEMB[16] WEMB[17]
+   WTI[16] WTI[17] CB[8] CT[8] DIB_LT[16] DIB_LT[17] LOG0 LOG1 LQB[16] LQB[17]
+   RASSB[0] RASSB[1] D[16] D[17] DCLKT DFTBIO[8] DFTBIOB[8] DINB[16] DINB[17]
+   QT[32] QT[33] QT[34] QT[35] SE_DB SE_DT WEM[16] WEM[17] WEMB[16] WEMB[17]
+   YSELB[0] YSELB[1] YSELB[2] YSELB[3] mm17a04_u_hdrf2p_giom2x2
X_mm17a04_u_hdrf2p_giom2x2_S9 VDDP[9] VDDPI[9] VSS[9] VBP[9] VBN[9] DINB[18]
+   DINB[19] LDIB[18] LDIB[19] Q[18] Q[19] WBI[18] WBI[19] WEMB[18] WEMB[19]
+   WTI[18] WTI[19] CB[9] CT[9] DIB_LT[18] DIB_LT[19] LOG0 LOG1 LQB[18] LQB[19]
+   RASSB[0] RASSB[1] D[18] D[19] DCLKT DFTBIO[9] DFTBIOB[9] DINB[18] DINB[19]
+   QT[36] QT[37] QT[38] QT[39] SE_DB SE_DT WEM[18] WEM[19] WEMB[18] WEMB[19]
+   YSELB[0] YSELB[1] YSELB[2] YSELB[3] mm17a04_u_hdrf2p_giom2x2
X_mm17a04_u_hdrf2p_giom2x2_F9 VDDP[10] VDDPI[10] VSS[10] VBP[10] VBN[10]
+   DINB[20] DINB[21] LDIB[20] LDIB[21] Q[20] Q[21] WBI[20] WBI[21] WEMB[20]
+   WEMB[21] WTI[20] WTI[21] CB[10] CT[10] DIB_LT[20] DIB_LT[21] LOG0 LOG1
+   LQB[20] LQB[21] RASSB[0] RASSB[1] D[20] D[21] DCLKT DFTBIO[10] DFTBIOB[10]
+   DINB[20] DINB[21] QT[40] QT[41] QT[42] QT[43] SE_DB SE_DT WEM[20] WEM[21]
+   WEMB[20] WEMB[21] YSELB[0] YSELB[1] YSELB[2] YSELB[3]
+   mm17a04_u_hdrf2p_giom2x2
X_mm17a04_u_hdrf2p_giom2x2_F8 VDDP[11] VDDPI[11] VSS[11] VBP[11] VBN[11]
+   DINB[22] DINB[23] LDIB[22] LDIB[23] Q[22] Q[23] WBI[22] WBI[23] WEMB[22]
+   WEMB[23] WTI[22] WTI[23] CB[11] CT[11] DIB_LT[22] DIB_LT[23] LOG0 LOG1
+   LQB[22] LQB[23] RASSB[0] RASSB[1] D[22] D[23] DCLKT DFTBIO[11] DFTBIOB[11]
+   DINB[22] DINB[23] QT[44] QT[45] QT[46] QT[47] SE_DB SE_DT WEM[22] WEM[23]
+   WEMB[22] WEMB[23] YSELB[0] YSELB[1] YSELB[2] YSELB[3]
+   mm17a04_u_hdrf2p_giom2x2
X_mm17a04_u_hdrf2p_giom2x2_F7 VDDP[12] VDDPI[12] VSS[12] VBP[12] VBN[12]
+   DINB[24] DINB[25] LDIB[24] LDIB[25] Q[24] Q[25] WBI[24] WBI[25] WEMB[24]
+   WEMB[25] WTI[24] WTI[25] CB[12] CT[12] DIB_LT[24] DIB_LT[25] LOG0 LOG1
+   LQB[24] LQB[25] RASSB[0] RASSB[1] D[24] D[25] DCLKT DFTBIO[12] DFTBIOB[12]
+   DINB[24] DINB[25] QT[48] QT[49] QT[50] QT[51] SE_DB SE_DT WEM[24] WEM[25]
+   WEMB[24] WEMB[25] YSELB[0] YSELB[1] YSELB[2] YSELB[3]
+   mm17a04_u_hdrf2p_giom2x2
X_mm17a04_u_hdrf2p_giom2x2_F6 VDDP[13] VDDPI[13] VSS[13] VBP[13] VBN[13]
+   DINB[26] DINB[27] LDIB[26] LDIB[27] Q[26] Q[27] WBI[26] WBI[27] WEMB[26]
+   WEMB[27] WTI[26] WTI[27] CB[13] CT[13] DIB_LT[26] DIB_LT[27] LOG0 LOG1
+   LQB[26] LQB[27] RASSB[0] RASSB[1] D[26] D[27] DCLKT DFTBIO[13] DFTBIOB[13]
+   DINB[26] DINB[27] QT[52] QT[53] QT[54] QT[55] SE_DB SE_DT WEM[26] WEM[27]
+   WEMB[26] WEMB[27] YSELB[0] YSELB[1] YSELB[2] YSELB[3]
+   mm17a04_u_hdrf2p_giom2x2
X_mm17a04_u_hdrf2p_giom2x2_F5 VDDP[14] VDDPI[14] VSS[14] VBP[14] VBN[14]
+   DINB[28] DINB[29] LDIB[28] LDIB[29] Q[28] Q[29] WBI[28] WBI[29] WEMB[28]
+   WEMB[29] WTI[28] WTI[29] CB[14] CT[14] DIB_LT[28] DIB_LT[29] LOG0 LOG1
+   LQB[28] LQB[29] RASSB[0] RASSB[1] D[28] D[29] DCLKT DFTBIO[14] DFTBIOB[14]
+   DINB[28] DINB[29] QT[56] QT[57] QT[58] QT[59] SE_DB SE_DT WEM[28] WEM[29]
+   WEMB[28] WEMB[29] YSELB[0] YSELB[1] YSELB[2] YSELB[3]
+   mm17a04_u_hdrf2p_giom2x2
X_mm17a04_u_hdrf2p_giom2x2_F4 VDDP[15] VDDPI[15] VSS[15] VBP[15] VBN[15]
+   DINB[30] DINB[31] LDIB[30] LDIB[31] Q[30] Q[31] WBI[30] WBI[31] WEMB[30]
+   WEMB[31] WTI[30] WTI[31] CB[15] CT[15] DIB_LT[30] DIB_LT[31] LOG0 LOG1
+   LQB[30] LQB[31] RASSB[0] RASSB[1] D[30] D[31] DCLKT DFTBIO[15] DFTBIOB[15]
+   DINB[30] DINB[31] QT[60] QT[61] QT[62] QT[63] SE_DB SE_DT WEM[30] WEM[31]
+   WEMB[30] WEMB[31] YSELB[0] YSELB[1] YSELB[2] YSELB[3]
+   mm17a04_u_hdrf2p_giom2x2
X_mm17a04_u_hdrf2p_giom2x2_F3 VDDP[16] VDDPI[16] VSS[16] VBP[16] VBN[16]
+   DINB[32] DINB[33] LDIB[32] LDIB[33] Q[32] Q[33] WBI[32] WBI[33] WEMB[32]
+   WEMB[33] WTI[32] WTI[33] CB[16] CT[16] DIB_LT[32] DIB_LT[33] LOG0 LOG1
+   LQB[32] LQB[33] RASSB[0] RASSB[1] D[32] D[33] DCLKT DFTBIO[16] DFTBIOB[16]
+   DINB[32] DINB[33] QT[64] QT[65] QT[66] QT[67] SE_DB SE_DT WEM[32] WEM[33]
+   WEMB[32] WEMB[33] YSELB[0] YSELB[1] YSELB[2] YSELB[3]
+   mm17a04_u_hdrf2p_giom2x2
X_mm17a04_u_hdrf2p_giom2x2_F2 VDDP[17] VDDPI[17] VSS[17] VBP[17] VBN[17]
+   DINB[34] DINB[35] LDIB[34] LDIB[35] Q[34] Q[35] WBI[34] WBI[35] WEMB[34]
+   WEMB[35] WTI[34] WTI[35] CB[17] CT[17] DIB_LT[34] DIB_LT[35] LOG0 LOG1
+   LQB[34] LQB[35] RASSB[0] RASSB[1] D[34] D[35] DCLKT DFTBIO[17] DFTBIOB[17]
+   DINB[34] DINB[35] QT[68] QT[69] QT[70] QT[71] SE_DB SE_DT WEM[34] WEM[35]
+   WEMB[34] WEMB[35] YSELB[0] YSELB[1] YSELB[2] YSELB[3]
+   mm17a04_u_hdrf2p_giom2x2
X_mm17a04_u_hdrf2p_giom2x2_F1 VDDP[18] VDDPI[18] VSS[18] VBP[18] VBN[18]
+   DINB[36] DINB[37] LDIB[36] LDIB[37] Q[36] Q[37] WBI[36] WBI[37] WEMB[36]
+   WEMB[37] WTI[36] WTI[37] CB[18] CT[18] DIB_LT[36] DIB_LT[37] LOG0 LOG1
+   LQB[36] LQB[37] RASSB[0] RASSB[1] D[36] D[37] DCLKT DFTBIO[18] DFTBIOB[18]
+   DINB[36] DINB[37] QT[72] QT[73] QT[74] QT[75] SE_DB SE_DT WEM[36] WEM[37]
+   WEMB[36] WEMB[37] YSELB[0] YSELB[1] YSELB[2] YSELB[3]
+   mm17a04_u_hdrf2p_giom2x2
X_mm17a04_u_hdrf2p_giom2x2_F0 VDDP[19] VDDPI[19] VSS[19] VBP[19] VBN[19]
+   DINB[38] DINB[39] LDIB[38] LDIB[39] Q[38] Q[39] WBI[38] WBI[39] WEMB[38]
+   WEMB[39] WTI[38] WTI[39] CB[19] CT[19] DIB_LT[38] DIB_LT[39] LOG0 LOG1
+   LQB[38] LQB[39] RASSB[0] RASSB[1] D[38] D[39] DCLKT DFTBIO[19] DFTBIOB[19]
+   DINB[38] DINB[39] QT[76] QT[77] QT[78] QT[79] SE_DB SE_DT WEM[38] WEM[39]
+   WEMB[38] WEMB[39] YSELB[0] YSELB[1] YSELB[2] YSELB[3]
+   mm17a04_u_hdrf2p_giom2x2
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_gio_rt CB[0] CB[1] CB[2] CB[3] CB[4] CB[5] CB[6]
+       CB[7] CB[8] CB[9] CB[10] CB[11] CB[12] CB[13] CB[14] CB[15] CB[16]
+       CB[17] CB[18] CB[19] CB[20] CB[21] CB[22] CB[23] CB[24] CB[25] CB[26]
+       CB[27] CB[28] CB[29] CB[30] CB[31] CB[32] CB[33] CB[34] CB[35] CB[36]
+       CB[37] CB[38] CB[39] CT[0] CT[1] CT[2] CT[3] CT[4] CT[5] CT[6] CT[7]
+       CT[8] CT[9] CT[10] CT[11] CT[12] CT[13] CT[14] CT[15] CT[16] CT[17]
+       CT[18] CT[19] CT[20] CT[21] CT[22] CT[23] CT[24] CT[25] CT[26] CT[27]
+       CT[28] CT[29] CT[30] CT[31] CT[32] CT[33] CT[34] CT[35] CT[36] CT[37]
+       CT[38] CT[39] D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] D[8] D[9] D[10]
+       D[11] D[12] D[13] D[14] D[15] D[16] D[17] D[18] D[19] D[20] D[21] D[22]
+       D[23] D[24] D[25] D[26] D[27] D[28] D[29] D[30] D[31] D[32] D[33] D[34]
+       D[35] D[36] D[37] D[38] D[39] D[40] D[41] D[42] D[43] D[44] D[45] D[46]
+       D[47] D[48] D[49] D[50] D[51] D[52] D[53] D[54] D[55] D[56] D[57] D[58]
+       D[59] D[60] D[61] D[62] D[63] D[64] D[65] D[66] D[67] D[68] D[69] D[70]
+       D[71] D[72] D[73] D[74] D[75] D[76] D[77] D[78] D[79] DCLKT DFTBIO[0]
+       DFTBIO[1] DFTBIO[2] DFTBIO[3] DFTBIO[4] DFTBIO[5] DFTBIO[6] DFTBIO[7]
+       DFTBIO[8] DFTBIO[9] DFTBIO[10] DFTBIO[11] DFTBIO[12] DFTBIO[13]
+       DFTBIO[14] DFTBIO[15] DFTBIO[16] DFTBIO[17] DFTBIO[18] DFTBIO[19]
+       DFTBIO[20] DFTBIO[21] DFTBIO[22] DFTBIO[23] DFTBIO[24] DFTBIO[25]
+       DFTBIO[26] DFTBIO[27] DFTBIO[28] DFTBIO[29] DFTBIO[30] DFTBIO[31]
+       DFTBIO[32] DFTBIO[33] DFTBIO[34] DFTBIO[35] DFTBIO[36] DFTBIO[37]
+       DFTBIO[38] DFTBIO[39] DFTBIOB[0] DFTBIOB[1] DFTBIOB[2] DFTBIOB[3]
+       DFTBIOB[4] DFTBIOB[5] DFTBIOB[6] DFTBIOB[7] DFTBIOB[8] DFTBIOB[9]
+       DFTBIOB[10] DFTBIOB[11] DFTBIOB[12] DFTBIOB[13] DFTBIOB[14] DFTBIOB[15]
+       DFTBIOB[16] DFTBIOB[17] DFTBIOB[18] DFTBIOB[19] DFTBIOB[20] DFTBIOB[21]
+       DFTBIOB[22] DFTBIOB[23] DFTBIOB[24] DFTBIOB[25] DFTBIOB[26] DFTBIOB[27]
+       DFTBIOB[28] DFTBIOB[29] DFTBIOB[30] DFTBIOB[31] DFTBIOB[32] DFTBIOB[33]
+       DFTBIOB[34] DFTBIOB[35] DFTBIOB[36] DFTBIOB[37] DFTBIOB[38] DFTBIOB[39]
+       DIB_LT[0] DIB_LT[1] DIB_LT[2] DIB_LT[3] DIB_LT[4] DIB_LT[5] DIB_LT[6]
+       DIB_LT[7] DIB_LT[8] DIB_LT[9] DIB_LT[10] DIB_LT[11] DIB_LT[12]
+       DIB_LT[13] DIB_LT[14] DIB_LT[15] DIB_LT[16] DIB_LT[17] DIB_LT[18]
+       DIB_LT[19] DIB_LT[20] DIB_LT[21] DIB_LT[22] DIB_LT[23] DIB_LT[24]
+       DIB_LT[25] DIB_LT[26] DIB_LT[27] DIB_LT[28] DIB_LT[29] DIB_LT[30]
+       DIB_LT[31] DIB_LT[32] DIB_LT[33] DIB_LT[34] DIB_LT[35] DIB_LT[36]
+       DIB_LT[37] DIB_LT[38] DIB_LT[39] DIB_LT[40] DIB_LT[41] DIB_LT[42]
+       DIB_LT[43] DIB_LT[44] DIB_LT[45] DIB_LT[46] DIB_LT[47] DIB_LT[48]
+       DIB_LT[49] DIB_LT[50] DIB_LT[51] DIB_LT[52] DIB_LT[53] DIB_LT[54]
+       DIB_LT[55] DIB_LT[56] DIB_LT[57] DIB_LT[58] DIB_LT[59] DIB_LT[60]
+       DIB_LT[61] DIB_LT[62] DIB_LT[63] DIB_LT[64] DIB_LT[65] DIB_LT[66]
+       DIB_LT[67] DIB_LT[68] DIB_LT[69] DIB_LT[70] DIB_LT[71] DIB_LT[72]
+       DIB_LT[73] DIB_LT[74] DIB_LT[75] DIB_LT[76] DIB_LT[77] DIB_LT[78]
+       DIB_LT[79] DINB[0] DINB[1] DINB[2] DINB[3] DINB[4] DINB[5] DINB[6]
+       DINB[7] DINB[8] DINB[9] DINB[10] DINB[11] DINB[12] DINB[13] DINB[14]
+       DINB[15] DINB[16] DINB[17] DINB[18] DINB[19] DINB[20] DINB[21] DINB[22]
+       DINB[23] DINB[24] DINB[25] DINB[26] DINB[27] DINB[28] DINB[29] DINB[30]
+       DINB[31] DINB[32] DINB[33] DINB[34] DINB[35] DINB[36] DINB[37] DINB[38]
+       DINB[39] DINB[40] DINB[41] DINB[42] DINB[43] DINB[44] DINB[45] DINB[46]
+       DINB[47] DINB[48] DINB[49] DINB[50] DINB[51] DINB[52] DINB[53] DINB[54]
+       DINB[55] DINB[56] DINB[57] DINB[58] DINB[59] DINB[60] DINB[61] DINB[62]
+       DINB[63] DINB[64] DINB[65] DINB[66] DINB[67] DINB[68] DINB[69] DINB[70]
+       DINB[71] DINB[72] DINB[73] DINB[74] DINB[75] DINB[76] DINB[77] DINB[78]
+       DINB[79] LDIB[0] LDIB[1] LDIB[2] LDIB[3] LDIB[4] LDIB[5] LDIB[6] LDIB[7]
+       LDIB[8] LDIB[9] LDIB[10] LDIB[11] LDIB[12] LDIB[13] LDIB[14] LDIB[15]
+       LDIB[16] LDIB[17] LDIB[18] LDIB[19] LDIB[20] LDIB[21] LDIB[22] LDIB[23]
+       LDIB[24] LDIB[25] LDIB[26] LDIB[27] LDIB[28] LDIB[29] LDIB[30] LDIB[31]
+       LDIB[32] LDIB[33] LDIB[34] LDIB[35] LDIB[36] LDIB[37] LDIB[38] LDIB[39]
+       LDIB[40] LDIB[41] LDIB[42] LDIB[43] LDIB[44] LDIB[45] LDIB[46] LDIB[47]
+       LDIB[48] LDIB[49] LDIB[50] LDIB[51] LDIB[52] LDIB[53] LDIB[54] LDIB[55]
+       LDIB[56] LDIB[57] LDIB[58] LDIB[59] LDIB[60] LDIB[61] LDIB[62] LDIB[63]
+       LDIB[64] LDIB[65] LDIB[66] LDIB[67] LDIB[68] LDIB[69] LDIB[70] LDIB[71]
+       LDIB[72] LDIB[73] LDIB[74] LDIB[75] LDIB[76] LDIB[77] LDIB[78] LDIB[79]
+       LOG0 LOG1 LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7] LQB[8]
+       LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16] LQB[17]
+       LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25] LQB[26]
+       LQB[27] LQB[28] LQB[29] LQB[30] LQB[31] LQB[32] LQB[33] LQB[34] LQB[35]
+       LQB[36] LQB[37] LQB[38] LQB[39] LQB[40] LQB[41] LQB[42] LQB[43] LQB[44]
+       LQB[45] LQB[46] LQB[47] LQB[48] LQB[49] LQB[50] LQB[51] LQB[52] LQB[53]
+       LQB[54] LQB[55] LQB[56] LQB[57] LQB[58] LQB[59] LQB[60] LQB[61] LQB[62]
+       LQB[63] LQB[64] LQB[65] LQB[66] LQB[67] LQB[68] LQB[69] LQB[70] LQB[71]
+       LQB[72] LQB[73] LQB[74] LQB[75] LQB[76] LQB[77] LQB[78] LQB[79] PWDO
+       Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] Q[8] Q[9] Q[10] Q[11] Q[12]
+       Q[13] Q[14] Q[15] Q[16] Q[17] Q[18] Q[19] Q[20] Q[21] Q[22] Q[23] Q[24]
+       Q[25] Q[26] Q[27] Q[28] Q[29] Q[30] Q[31] Q[32] Q[33] Q[34] Q[35] Q[36]
+       Q[37] Q[38] Q[39] Q[40] Q[41] Q[42] Q[43] Q[44] Q[45] Q[46] Q[47] Q[48]
+       Q[49] Q[50] Q[51] Q[52] Q[53] Q[54] Q[55] Q[56] Q[57] Q[58] Q[59] Q[60]
+       Q[61] Q[62] Q[63] Q[64] Q[65] Q[66] Q[67] Q[68] Q[69] Q[70] Q[71] Q[72]
+       Q[73] Q[74] Q[75] Q[76] Q[77] Q[78] Q[79] QT[0] QT[1] QT[2] QT[3] QT[4]
+       QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15]
+       QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+       QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35]
+       QT[36] QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45]
+       QT[46] QT[47] QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55]
+       QT[56] QT[57] QT[58] QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65]
+       QT[66] QT[67] QT[68] QT[69] QT[70] QT[71] QT[72] QT[73] QT[74] QT[75]
+       QT[76] QT[77] QT[78] QT[79] QT[80] QT[81] QT[82] QT[83] QT[84] QT[85]
+       QT[86] QT[87] QT[88] QT[89] QT[90] QT[91] QT[92] QT[93] QT[94] QT[95]
+       QT[96] QT[97] QT[98] QT[99] QT[100] QT[101] QT[102] QT[103] QT[104]
+       QT[105] QT[106] QT[107] QT[108] QT[109] QT[110] QT[111] QT[112] QT[113]
+       QT[114] QT[115] QT[116] QT[117] QT[118] QT[119] QT[120] QT[121] QT[122]
+       QT[123] QT[124] QT[125] QT[126] QT[127] QT[128] QT[129] QT[130] QT[131]
+       QT[132] QT[133] QT[134] QT[135] QT[136] QT[137] QT[138] QT[139] QT[140]
+       QT[141] QT[142] QT[143] QT[144] QT[145] QT[146] QT[147] QT[148] QT[149]
+       QT[150] QT[151] QT[152] QT[153] QT[154] QT[155] QT[156] QT[157] QT[158]
+       QT[159] RASSB[0] RASSB[1] RERASSB[0] RERASSB[1] SE_DB SE_DT VBN[0]
+       VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10]
+       VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19]
+       VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28]
+       VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35] VBN[36] VBN[37]
+       VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4]
+       VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+       VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+       VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+       VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40]
+       VBP[41] VDDA[0] VDDA[1] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5]
+       VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+       VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21]
+       VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDP[29]
+       VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34] VDDP[35] VDDP[36] VDDP[37]
+       VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+       VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+       VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17]
+       VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24]
+       VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31]
+       VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36] VDDPI[37] VDDPI[38]
+       VDDPI[39] VDDPI[40] VDDPI[41] VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4]
+       VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13]
+       VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22]
+       VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31]
+       VSS[32] VSS[33] VSS[34] VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40]
+       VSS[41] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8]
+       WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17]
+       WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26]
+       WBI[27] WBI[28] WBI[29] WBI[30] WBI[31] WBI[32] WBI[33] WBI[34] WBI[35]
+       WBI[36] WBI[37] WBI[38] WBI[39] WBI[40] WBI[41] WBI[42] WBI[43] WBI[44]
+       WBI[45] WBI[46] WBI[47] WBI[48] WBI[49] WBI[50] WBI[51] WBI[52] WBI[53]
+       WBI[54] WBI[55] WBI[56] WBI[57] WBI[58] WBI[59] WBI[60] WBI[61] WBI[62]
+       WBI[63] WBI[64] WBI[65] WBI[66] WBI[67] WBI[68] WBI[69] WBI[70] WBI[71]
+       WBI[72] WBI[73] WBI[74] WBI[75] WBI[76] WBI[77] WBI[78] WBI[79] WEM[0]
+       WEM[1] WEM[2] WEM[3] WEM[4] WEM[5] WEM[6] WEM[7] WEM[8] WEM[9] WEM[10]
+       WEM[11] WEM[12] WEM[13] WEM[14] WEM[15] WEM[16] WEM[17] WEM[18] WEM[19]
+       WEM[20] WEM[21] WEM[22] WEM[23] WEM[24] WEM[25] WEM[26] WEM[27] WEM[28]
+       WEM[29] WEM[30] WEM[31] WEM[32] WEM[33] WEM[34] WEM[35] WEM[36] WEM[37]
+       WEM[38] WEM[39] WEM[40] WEM[41] WEM[42] WEM[43] WEM[44] WEM[45] WEM[46]
+       WEM[47] WEM[48] WEM[49] WEM[50] WEM[51] WEM[52] WEM[53] WEM[54] WEM[55]
+       WEM[56] WEM[57] WEM[58] WEM[59] WEM[60] WEM[61] WEM[62] WEM[63] WEM[64]
+       WEM[65] WEM[66] WEM[67] WEM[68] WEM[69] WEM[70] WEM[71] WEM[72] WEM[73]
+       WEM[74] WEM[75] WEM[76] WEM[77] WEM[78] WEM[79] WEMB[0] WEMB[1] WEMB[2]
+       WEMB[3] WEMB[4] WEMB[5] WEMB[6] WEMB[7] WEMB[8] WEMB[9] WEMB[10]
+       WEMB[11] WEMB[12] WEMB[13] WEMB[14] WEMB[15] WEMB[16] WEMB[17] WEMB[18]
+       WEMB[19] WEMB[20] WEMB[21] WEMB[22] WEMB[23] WEMB[24] WEMB[25] WEMB[26]
+       WEMB[27] WEMB[28] WEMB[29] WEMB[30] WEMB[31] WEMB[32] WEMB[33] WEMB[34]
+       WEMB[35] WEMB[36] WEMB[37] WEMB[38] WEMB[39] WEMB[40] WEMB[41] WEMB[42]
+       WEMB[43] WEMB[44] WEMB[45] WEMB[46] WEMB[47] WEMB[48] WEMB[49] WEMB[50]
+       WEMB[51] WEMB[52] WEMB[53] WEMB[54] WEMB[55] WEMB[56] WEMB[57] WEMB[58]
+       WEMB[59] WEMB[60] WEMB[61] WEMB[62] WEMB[63] WEMB[64] WEMB[65] WEMB[66]
+       WEMB[67] WEMB[68] WEMB[69] WEMB[70] WEMB[71] WEMB[72] WEMB[73] WEMB[74]
+       WEMB[75] WEMB[76] WEMB[77] WEMB[78] WEMB[79] WTI[0] WTI[1] WTI[2] WTI[3]
+       WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12]
+       WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21]
+       WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27] WTI[28] WTI[29] WTI[30]
+       WTI[31] WTI[32] WTI[33] WTI[34] WTI[35] WTI[36] WTI[37] WTI[38] WTI[39]
+       WTI[40] WTI[41] WTI[42] WTI[43] WTI[44] WTI[45] WTI[46] WTI[47] WTI[48]
+       WTI[49] WTI[50] WTI[51] WTI[52] WTI[53] WTI[54] WTI[55] WTI[56] WTI[57]
+       WTI[58] WTI[59] WTI[60] WTI[61] WTI[62] WTI[63] WTI[64] WTI[65] WTI[66]
+       WTI[67] WTI[68] WTI[69] WTI[70] WTI[71] WTI[72] WTI[73] WTI[74] WTI[75]
+       WTI[76] WTI[77] WTI[78] WTI[79] YSELB[0] YSELB[1] YSELB[2] YSELB[3]
X_gio_rt_seg1_S0 CB[0] CB[1] CB[2] CB[3] CB[4] CB[5] CB[6] CB[7] CB[8] CB[9]
+   CB[10] CB[11] CB[12] CB[13] CB[14] CB[15] CB[16] CB[17] CB[18] CB[19] CT[0]
+   CT[1] CT[2] CT[3] CT[4] CT[5] CT[6] CT[7] CT[8] CT[9] CT[10] CT[11] CT[12]
+   CT[13] CT[14] CT[15] CT[16] CT[17] CT[18] CT[19] D[0] D[1] D[2] D[3] D[4]
+   D[5] D[6] D[7] D[8] D[9] D[10] D[11] D[12] D[13] D[14] D[15] D[16] D[17]
+   D[18] D[19] D[20] D[21] D[22] D[23] D[24] D[25] D[26] D[27] D[28] D[29]
+   D[30] D[31] D[32] D[33] D[34] D[35] D[36] D[37] D[38] D[39] DCLKT DFTBIO[0]
+   DFTBIO[1] DFTBIO[2] DFTBIO[3] DFTBIO[4] DFTBIO[5] DFTBIO[6] DFTBIO[7]
+   DFTBIO[8] DFTBIO[9] DFTBIO[10] DFTBIO[11] DFTBIO[12] DFTBIO[13] DFTBIO[14]
+   DFTBIO[15] DFTBIO[16] DFTBIO[17] DFTBIO[18] DFTBIO[19] DFTBIOB[0] DFTBIOB[1]
+   DFTBIOB[2] DFTBIOB[3] DFTBIOB[4] DFTBIOB[5] DFTBIOB[6] DFTBIOB[7] DFTBIOB[8]
+   DFTBIOB[9] DFTBIOB[10] DFTBIOB[11] DFTBIOB[12] DFTBIOB[13] DFTBIOB[14]
+   DFTBIOB[15] DFTBIOB[16] DFTBIOB[17] DFTBIOB[18] DFTBIOB[19] DIB_LT[0]
+   DIB_LT[1] DIB_LT[2] DIB_LT[3] DIB_LT[4] DIB_LT[5] DIB_LT[6] DIB_LT[7]
+   DIB_LT[8] DIB_LT[9] DIB_LT[10] DIB_LT[11] DIB_LT[12] DIB_LT[13] DIB_LT[14]
+   DIB_LT[15] DIB_LT[16] DIB_LT[17] DIB_LT[18] DIB_LT[19] DIB_LT[20] DIB_LT[21]
+   DIB_LT[22] DIB_LT[23] DIB_LT[24] DIB_LT[25] DIB_LT[26] DIB_LT[27] DIB_LT[28]
+   DIB_LT[29] DIB_LT[30] DIB_LT[31] DIB_LT[32] DIB_LT[33] DIB_LT[34] DIB_LT[35]
+   DIB_LT[36] DIB_LT[37] DIB_LT[38] DIB_LT[39] DINB[0] DINB[1] DINB[2] DINB[3]
+   DINB[4] DINB[5] DINB[6] DINB[7] DINB[8] DINB[9] DINB[10] DINB[11] DINB[12]
+   DINB[13] DINB[14] DINB[15] DINB[16] DINB[17] DINB[18] DINB[19] DINB[20]
+   DINB[21] DINB[22] DINB[23] DINB[24] DINB[25] DINB[26] DINB[27] DINB[28]
+   DINB[29] DINB[30] DINB[31] DINB[32] DINB[33] DINB[34] DINB[35] DINB[36]
+   DINB[37] DINB[38] DINB[39] LDIB[0] LDIB[1] LDIB[2] LDIB[3] LDIB[4] LDIB[5]
+   LDIB[6] LDIB[7] LDIB[8] LDIB[9] LDIB[10] LDIB[11] LDIB[12] LDIB[13] LDIB[14]
+   LDIB[15] LDIB[16] LDIB[17] LDIB[18] LDIB[19] LDIB[20] LDIB[21] LDIB[22]
+   LDIB[23] LDIB[24] LDIB[25] LDIB[26] LDIB[27] LDIB[28] LDIB[29] LDIB[30]
+   LDIB[31] LDIB[32] LDIB[33] LDIB[34] LDIB[35] LDIB[36] LDIB[37] LDIB[38]
+   LDIB[39] LOG0 LOG1 LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7]
+   LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16]
+   LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25]
+   LQB[26] LQB[27] LQB[28] LQB[29] LQB[30] LQB[31] LQB[32] LQB[33] LQB[34]
+   LQB[35] LQB[36] LQB[37] LQB[38] LQB[39] Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6]
+   Q[7] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13] Q[14] Q[15] Q[16] Q[17] Q[18] Q[19]
+   Q[20] Q[21] Q[22] Q[23] Q[24] Q[25] Q[26] Q[27] Q[28] Q[29] Q[30] Q[31]
+   Q[32] Q[33] Q[34] Q[35] Q[36] Q[37] Q[38] Q[39] QT[0] QT[1] QT[2] QT[3]
+   QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79]
+   RASSB[0] RASSB[1] SE_DB SE_DT VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5]
+   VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15]
+   VBN[16] VBN[17] VBN[18] VBN[19] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5]
+   VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15]
+   VBP[16] VBP[17] VBP[18] VBP[19] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDPI[0] VDDPI[1]
+   VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9]
+   VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16]
+   VDDPI[17] VDDPI[18] VDDPI[19] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+   VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15]
+   VSS[16] VSS[17] VSS[18] VSS[19] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+   WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+   WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24]
+   WBI[25] WBI[26] WBI[27] WBI[28] WBI[29] WBI[30] WBI[31] WBI[32] WBI[33]
+   WBI[34] WBI[35] WBI[36] WBI[37] WBI[38] WBI[39] WEM[0] WEM[1] WEM[2] WEM[3]
+   WEM[4] WEM[5] WEM[6] WEM[7] WEM[8] WEM[9] WEM[10] WEM[11] WEM[12] WEM[13]
+   WEM[14] WEM[15] WEM[16] WEM[17] WEM[18] WEM[19] WEM[20] WEM[21] WEM[22]
+   WEM[23] WEM[24] WEM[25] WEM[26] WEM[27] WEM[28] WEM[29] WEM[30] WEM[31]
+   WEM[32] WEM[33] WEM[34] WEM[35] WEM[36] WEM[37] WEM[38] WEM[39] WEMB[0]
+   WEMB[1] WEMB[2] WEMB[3] WEMB[4] WEMB[5] WEMB[6] WEMB[7] WEMB[8] WEMB[9]
+   WEMB[10] WEMB[11] WEMB[12] WEMB[13] WEMB[14] WEMB[15] WEMB[16] WEMB[17]
+   WEMB[18] WEMB[19] WEMB[20] WEMB[21] WEMB[22] WEMB[23] WEMB[24] WEMB[25]
+   WEMB[26] WEMB[27] WEMB[28] WEMB[29] WEMB[30] WEMB[31] WEMB[32] WEMB[33]
+   WEMB[34] WEMB[35] WEMB[36] WEMB[37] WEMB[38] WEMB[39] WTI[0] WTI[1] WTI[2]
+   WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12]
+   WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21]
+   WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27] WTI[28] WTI[29] WTI[30]
+   WTI[31] WTI[32] WTI[33] WTI[34] WTI[35] WTI[36] WTI[37] WTI[38] WTI[39]
+   YSELB[0] YSELB[1] YSELB[2] YSELB[3] SNPS_RF_DP_UHD_512x80_gio_rt_seg1
X_mm17a04_u_hdrf2p_gcenrebuf_cm2_cm4 VDDA[0] VDDP[20] VDDPI[20] VSS[20] VBP[20]
+   VBN[20] REDCLKT RERASSB[0] RERASSB[1] RESE_DB RESE_DT REYSELB[0] REYSELB[1]
+   REYSELB[2] REYSELB[3] LOG0 LOG1 DCLKT RASSB[0] RASSB[1] SE_DB SE_DT YSELB[0]
+   YSELB[1] YSELB[2] YSELB[3] mm17a04_u_hdrf2p_gcenrebuf
X_gio_rt_seg1_F0 CB[20] CB[21] CB[22] CB[23] CB[24] CB[25] CB[26] CB[27] CB[28]
+   CB[29] CB[30] CB[31] CB[32] CB[33] CB[34] CB[35] CB[36] CB[37] CB[38] CB[39]
+   CT[20] CT[21] CT[22] CT[23] CT[24] CT[25] CT[26] CT[27] CT[28] CT[29] CT[30]
+   CT[31] CT[32] CT[33] CT[34] CT[35] CT[36] CT[37] CT[38] CT[39] D[40] D[41]
+   D[42] D[43] D[44] D[45] D[46] D[47] D[48] D[49] D[50] D[51] D[52] D[53]
+   D[54] D[55] D[56] D[57] D[58] D[59] D[60] D[61] D[62] D[63] D[64] D[65]
+   D[66] D[67] D[68] D[69] D[70] D[71] D[72] D[73] D[74] D[75] D[76] D[77]
+   D[78] D[79] REDCLKT DFTBIO[20] DFTBIO[21] DFTBIO[22] DFTBIO[23] DFTBIO[24]
+   DFTBIO[25] DFTBIO[26] DFTBIO[27] DFTBIO[28] DFTBIO[29] DFTBIO[30] DFTBIO[31]
+   DFTBIO[32] DFTBIO[33] DFTBIO[34] DFTBIO[35] DFTBIO[36] DFTBIO[37] DFTBIO[38]
+   DFTBIO[39] DFTBIOB[20] DFTBIOB[21] DFTBIOB[22] DFTBIOB[23] DFTBIOB[24]
+   DFTBIOB[25] DFTBIOB[26] DFTBIOB[27] DFTBIOB[28] DFTBIOB[29] DFTBIOB[30]
+   DFTBIOB[31] DFTBIOB[32] DFTBIOB[33] DFTBIOB[34] DFTBIOB[35] DFTBIOB[36]
+   DFTBIOB[37] DFTBIOB[38] DFTBIOB[39] DIB_LT[40] DIB_LT[41] DIB_LT[42]
+   DIB_LT[43] DIB_LT[44] DIB_LT[45] DIB_LT[46] DIB_LT[47] DIB_LT[48] DIB_LT[49]
+   DIB_LT[50] DIB_LT[51] DIB_LT[52] DIB_LT[53] DIB_LT[54] DIB_LT[55] DIB_LT[56]
+   DIB_LT[57] DIB_LT[58] DIB_LT[59] DIB_LT[60] DIB_LT[61] DIB_LT[62] DIB_LT[63]
+   DIB_LT[64] DIB_LT[65] DIB_LT[66] DIB_LT[67] DIB_LT[68] DIB_LT[69] DIB_LT[70]
+   DIB_LT[71] DIB_LT[72] DIB_LT[73] DIB_LT[74] DIB_LT[75] DIB_LT[76] DIB_LT[77]
+   DIB_LT[78] DIB_LT[79] DINB[40] DINB[41] DINB[42] DINB[43] DINB[44] DINB[45]
+   DINB[46] DINB[47] DINB[48] DINB[49] DINB[50] DINB[51] DINB[52] DINB[53]
+   DINB[54] DINB[55] DINB[56] DINB[57] DINB[58] DINB[59] DINB[60] DINB[61]
+   DINB[62] DINB[63] DINB[64] DINB[65] DINB[66] DINB[67] DINB[68] DINB[69]
+   DINB[70] DINB[71] DINB[72] DINB[73] DINB[74] DINB[75] DINB[76] DINB[77]
+   DINB[78] DINB[79] LDIB[40] LDIB[41] LDIB[42] LDIB[43] LDIB[44] LDIB[45]
+   LDIB[46] LDIB[47] LDIB[48] LDIB[49] LDIB[50] LDIB[51] LDIB[52] LDIB[53]
+   LDIB[54] LDIB[55] LDIB[56] LDIB[57] LDIB[58] LDIB[59] LDIB[60] LDIB[61]
+   LDIB[62] LDIB[63] LDIB[64] LDIB[65] LDIB[66] LDIB[67] LDIB[68] LDIB[69]
+   LDIB[70] LDIB[71] LDIB[72] LDIB[73] LDIB[74] LDIB[75] LDIB[76] LDIB[77]
+   LDIB[78] LDIB[79] LOG0 LOG1 LQB[40] LQB[41] LQB[42] LQB[43] LQB[44] LQB[45]
+   LQB[46] LQB[47] LQB[48] LQB[49] LQB[50] LQB[51] LQB[52] LQB[53] LQB[54]
+   LQB[55] LQB[56] LQB[57] LQB[58] LQB[59] LQB[60] LQB[61] LQB[62] LQB[63]
+   LQB[64] LQB[65] LQB[66] LQB[67] LQB[68] LQB[69] LQB[70] LQB[71] LQB[72]
+   LQB[73] LQB[74] LQB[75] LQB[76] LQB[77] LQB[78] LQB[79] Q[40] Q[41] Q[42]
+   Q[43] Q[44] Q[45] Q[46] Q[47] Q[48] Q[49] Q[50] Q[51] Q[52] Q[53] Q[54]
+   Q[55] Q[56] Q[57] Q[58] Q[59] Q[60] Q[61] Q[62] Q[63] Q[64] Q[65] Q[66]
+   Q[67] Q[68] Q[69] Q[70] Q[71] Q[72] Q[73] Q[74] Q[75] Q[76] Q[77] Q[78]
+   Q[79] QT[80] QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89]
+   QT[90] QT[91] QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99]
+   QT[100] QT[101] QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108]
+   QT[109] QT[110] QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117]
+   QT[118] QT[119] QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126]
+   QT[127] QT[128] QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135]
+   QT[136] QT[137] QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144]
+   QT[145] QT[146] QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153]
+   QT[154] QT[155] QT[156] QT[157] QT[158] QT[159] RASSB[2] RASSB[3] RESE_DB
+   RESE_DT VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28]
+   VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35] VBN[36] VBN[37]
+   VBN[38] VBN[39] VBN[40] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25] VBP[26]
+   VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32] VBP[33] VBP[34] VBP[35]
+   VBP[36] VBP[37] VBP[38] VBP[39] VBP[40] VDDP[21] VDDP[22] VDDP[23] VDDP[24]
+   VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32]
+   VDDP[33] VDDP[34] VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40]
+   VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27]
+   VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34]
+   VDDPI[35] VDDPI[36] VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VSS[21] VSS[22]
+   VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31]
+   VSS[32] VSS[33] VSS[34] VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40]
+   WBI[40] WBI[41] WBI[42] WBI[43] WBI[44] WBI[45] WBI[46] WBI[47] WBI[48]
+   WBI[49] WBI[50] WBI[51] WBI[52] WBI[53] WBI[54] WBI[55] WBI[56] WBI[57]
+   WBI[58] WBI[59] WBI[60] WBI[61] WBI[62] WBI[63] WBI[64] WBI[65] WBI[66]
+   WBI[67] WBI[68] WBI[69] WBI[70] WBI[71] WBI[72] WBI[73] WBI[74] WBI[75]
+   WBI[76] WBI[77] WBI[78] WBI[79] WEM[40] WEM[41] WEM[42] WEM[43] WEM[44]
+   WEM[45] WEM[46] WEM[47] WEM[48] WEM[49] WEM[50] WEM[51] WEM[52] WEM[53]
+   WEM[54] WEM[55] WEM[56] WEM[57] WEM[58] WEM[59] WEM[60] WEM[61] WEM[62]
+   WEM[63] WEM[64] WEM[65] WEM[66] WEM[67] WEM[68] WEM[69] WEM[70] WEM[71]
+   WEM[72] WEM[73] WEM[74] WEM[75] WEM[76] WEM[77] WEM[78] WEM[79] WEMB[40]
+   WEMB[41] WEMB[42] WEMB[43] WEMB[44] WEMB[45] WEMB[46] WEMB[47] WEMB[48]
+   WEMB[49] WEMB[50] WEMB[51] WEMB[52] WEMB[53] WEMB[54] WEMB[55] WEMB[56]
+   WEMB[57] WEMB[58] WEMB[59] WEMB[60] WEMB[61] WEMB[62] WEMB[63] WEMB[64]
+   WEMB[65] WEMB[66] WEMB[67] WEMB[68] WEMB[69] WEMB[70] WEMB[71] WEMB[72]
+   WEMB[73] WEMB[74] WEMB[75] WEMB[76] WEMB[77] WEMB[78] WEMB[79] WTI[40]
+   WTI[41] WTI[42] WTI[43] WTI[44] WTI[45] WTI[46] WTI[47] WTI[48] WTI[49]
+   WTI[50] WTI[51] WTI[52] WTI[53] WTI[54] WTI[55] WTI[56] WTI[57] WTI[58]
+   WTI[59] WTI[60] WTI[61] WTI[62] WTI[63] WTI[64] WTI[65] WTI[66] WTI[67]
+   WTI[68] WTI[69] WTI[70] WTI[71] WTI[72] WTI[73] WTI[74] WTI[75] WTI[76]
+   WTI[77] WTI[78] WTI[79] REYSELB[0] REYSELB[1] REYSELB[2] REYSELB[3]
+   SNPS_RF_DP_UHD_512x80_gio_rt_seg1
X_mm17a04_u_hdrf2p_capgio_cm2_cm4 VDDA[1] VDDP[41] VDDPI[41] VSS[41] VBP[41]
+   VBN[41] LOG0 LOG1 PWDO VEDGE mm17a04_u_hdrf2p_capgio
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_gio_row ARYSD CB[0] CB[1] CB[2] CB[3] CB[4] CB[5]
+       CB[6] CB[7] CB[8] CB[9] CB[10] CB[11] CB[12] CB[13] CB[14] CB[15] CB[16]
+       CB[17] CB[18] CB[19] CB[20] CB[21] CB[22] CB[23] CB[24] CB[25] CB[26]
+       CB[27] CB[28] CB[29] CB[30] CB[31] CB[32] CB[33] CB[34] CB[35] CB[36]
+       CB[37] CB[38] CB[39] CENDP CKGATE_RD CLKRD CLKWR CT[0] CT[1] CT[2] CT[3]
+       CT[4] CT[5] CT[6] CT[7] CT[8] CT[9] CT[10] CT[11] CT[12] CT[13] CT[14]
+       CT[15] CT[16] CT[17] CT[18] CT[19] CT[20] CT[21] CT[22] CT[23] CT[24]
+       CT[25] CT[26] CT[27] CT[28] CT[29] CT[30] CT[31] CT[32] CT[33] CT[34]
+       CT[35] CT[36] CT[37] CT[38] CT[39] D[0] D[1] D[2] D[3] D[4] D[5] D[6]
+       D[7] D[8] D[9] D[10] D[11] D[12] D[13] D[14] D[15] D[16] D[17] D[18]
+       D[19] D[20] D[21] D[22] D[23] D[24] D[25] D[26] D[27] D[28] D[29] D[30]
+       D[31] D[32] D[33] D[34] D[35] D[36] D[37] D[38] D[39] D[40] D[41] D[42]
+       D[43] D[44] D[45] D[46] D[47] D[48] D[49] D[50] D[51] D[52] D[53] D[54]
+       D[55] D[56] D[57] D[58] D[59] D[60] D[61] D[62] D[63] D[64] D[65] D[66]
+       D[67] D[68] D[69] D[70] D[71] D[72] D[73] D[74] D[75] D[76] D[77] D[78]
+       D[79] DEF1_RD DEF1_WR DFTBIO[0] DFTBIO[1] DFTBIO[2] DFTBIO[3] DFTBIO[4]
+       DFTBIO[5] DFTBIO[6] DFTBIO[7] DFTBIO[8] DFTBIO[9] DFTBIO[10] DFTBIO[11]
+       DFTBIO[12] DFTBIO[13] DFTBIO[14] DFTBIO[15] DFTBIO[16] DFTBIO[17]
+       DFTBIO[18] DFTBIO[19] DFTBIO[20] DFTBIO[21] DFTBIO[22] DFTBIO[23]
+       DFTBIO[24] DFTBIO[25] DFTBIO[26] DFTBIO[27] DFTBIO[28] DFTBIO[29]
+       DFTBIO[30] DFTBIO[31] DFTBIO[32] DFTBIO[33] DFTBIO[34] DFTBIO[35]
+       DFTBIO[36] DFTBIO[37] DFTBIO[38] DFTBIO[39] DFTBIOB[0] DFTBIOB[1]
+       DFTBIOB[2] DFTBIOB[3] DFTBIOB[4] DFTBIOB[5] DFTBIOB[6] DFTBIOB[7]
+       DFTBIOB[8] DFTBIOB[9] DFTBIOB[10] DFTBIOB[11] DFTBIOB[12] DFTBIOB[13]
+       DFTBIOB[14] DFTBIOB[15] DFTBIOB[16] DFTBIOB[17] DFTBIOB[18] DFTBIOB[19]
+       DFTBIOB[20] DFTBIOB[21] DFTBIOB[22] DFTBIOB[23] DFTBIOB[24] DFTBIOB[25]
+       DFTBIOB[26] DFTBIOB[27] DFTBIOB[28] DFTBIOB[29] DFTBIOB[30] DFTBIOB[31]
+       DFTBIOB[32] DFTBIOB[33] DFTBIOB[34] DFTBIOB[35] DFTBIOB[36] DFTBIOB[37]
+       DFTBIOB[38] DFTBIOB[39] DFTCKRD DFTCKWR DFT_OR_SERD DFT_OR_SEWR
+       DIB_LT[0] DIB_LT[1] DIB_LT[2] DIB_LT[3] DIB_LT[4] DIB_LT[5] DIB_LT[6]
+       DIB_LT[7] DIB_LT[8] DIB_LT[9] DIB_LT[10] DIB_LT[11] DIB_LT[12]
+       DIB_LT[13] DIB_LT[14] DIB_LT[15] DIB_LT[16] DIB_LT[17] DIB_LT[18]
+       DIB_LT[19] DIB_LT[20] DIB_LT[21] DIB_LT[22] DIB_LT[23] DIB_LT[24]
+       DIB_LT[25] DIB_LT[26] DIB_LT[27] DIB_LT[28] DIB_LT[29] DIB_LT[30]
+       DIB_LT[31] DIB_LT[32] DIB_LT[33] DIB_LT[34] DIB_LT[35] DIB_LT[36]
+       DIB_LT[37] DIB_LT[38] DIB_LT[39] DIB_LT[40] DIB_LT[41] DIB_LT[42]
+       DIB_LT[43] DIB_LT[44] DIB_LT[45] DIB_LT[46] DIB_LT[47] DIB_LT[48]
+       DIB_LT[49] DIB_LT[50] DIB_LT[51] DIB_LT[52] DIB_LT[53] DIB_LT[54]
+       DIB_LT[55] DIB_LT[56] DIB_LT[57] DIB_LT[58] DIB_LT[59] DIB_LT[60]
+       DIB_LT[61] DIB_LT[62] DIB_LT[63] DIB_LT[64] DIB_LT[65] DIB_LT[66]
+       DIB_LT[67] DIB_LT[68] DIB_LT[69] DIB_LT[70] DIB_LT[71] DIB_LT[72]
+       DIB_LT[73] DIB_LT[74] DIB_LT[75] DIB_LT[76] DIB_LT[77] DIB_LT[78]
+       DIB_LT[79] DINB[0] DINB[1] DINB[2] DINB[3] DINB[4] DINB[5] DINB[6]
+       DINB[7] DINB[8] DINB[9] DINB[10] DINB[11] DINB[12] DINB[13] DINB[14]
+       DINB[15] DINB[16] DINB[17] DINB[18] DINB[19] DINB[20] DINB[21] DINB[22]
+       DINB[23] DINB[24] DINB[25] DINB[26] DINB[27] DINB[28] DINB[29] DINB[30]
+       DINB[31] DINB[32] DINB[33] DINB[34] DINB[35] DINB[36] DINB[37] DINB[38]
+       DINB[39] DINB[40] DINB[41] DINB[42] DINB[43] DINB[44] DINB[45] DINB[46]
+       DINB[47] DINB[48] DINB[49] DINB[50] DINB[51] DINB[52] DINB[53] DINB[54]
+       DINB[55] DINB[56] DINB[57] DINB[58] DINB[59] DINB[60] DINB[61] DINB[62]
+       DINB[63] DINB[64] DINB[65] DINB[66] DINB[67] DINB[68] DINB[69] DINB[70]
+       DINB[71] DINB[72] DINB[73] DINB[74] DINB[75] DINB[76] DINB[77] DINB[78]
+       DINB[79] DLYPDB DLYPW DSORSD FAST1_RD FAST1_WR FAST2_RD FAST2_WR FISO
+       LCLKRDB LCLKRDT LCLKWRB LCLKWRT LDIB[0] LDIB[1] LDIB[2] LDIB[3] LDIB[4]
+       LDIB[5] LDIB[6] LDIB[7] LDIB[8] LDIB[9] LDIB[10] LDIB[11] LDIB[12]
+       LDIB[13] LDIB[14] LDIB[15] LDIB[16] LDIB[17] LDIB[18] LDIB[19] LDIB[20]
+       LDIB[21] LDIB[22] LDIB[23] LDIB[24] LDIB[25] LDIB[26] LDIB[27] LDIB[28]
+       LDIB[29] LDIB[30] LDIB[31] LDIB[32] LDIB[33] LDIB[34] LDIB[35] LDIB[36]
+       LDIB[37] LDIB[38] LDIB[39] LDIB[40] LDIB[41] LDIB[42] LDIB[43] LDIB[44]
+       LDIB[45] LDIB[46] LDIB[47] LDIB[48] LDIB[49] LDIB[50] LDIB[51] LDIB[52]
+       LDIB[53] LDIB[54] LDIB[55] LDIB[56] LDIB[57] LDIB[58] LDIB[59] LDIB[60]
+       LDIB[61] LDIB[62] LDIB[63] LDIB[64] LDIB[65] LDIB[66] LDIB[67] LDIB[68]
+       LDIB[69] LDIB[70] LDIB[71] LDIB[72] LDIB[73] LDIB[74] LDIB[75] LDIB[76]
+       LDIB[77] LDIB[78] LDIB[79] LITESLP LMERD LMEWR LME_GATING_RD
+       LME_GATING_WR LOG0 LOG1 LOG1RMRD_VDDPI LOG1RMWR_VDDPI LOG1_RMRD
+       LOG1_RMWR LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7] LQB[8]
+       LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16] LQB[17]
+       LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25] LQB[26]
+       LQB[27] LQB[28] LQB[29] LQB[30] LQB[31] LQB[32] LQB[33] LQB[34] LQB[35]
+       LQB[36] LQB[37] LQB[38] LQB[39] LQB[40] LQB[41] LQB[42] LQB[43] LQB[44]
+       LQB[45] LQB[46] LQB[47] LQB[48] LQB[49] LQB[50] LQB[51] LQB[52] LQB[53]
+       LQB[54] LQB[55] LQB[56] LQB[57] LQB[58] LQB[59] LQB[60] LQB[61] LQB[62]
+       LQB[63] LQB[64] LQB[65] LQB[66] LQB[67] LQB[68] LQB[69] LQB[70] LQB[71]
+       LQB[72] LQB[73] LQB[74] LQB[75] LQB[76] LQB[77] LQB[78] LQB[79] LRWMEB
+       LS LWE LXADRBRD[0] LXADRBRD[1] LXADRBRD[2] LXADRBRD[3] LXADRBRD[4]
+       LXADRBRD[5] LXADRBRD[6] LXADRBRD[7] LXADRBWR[0] LXADRBWR[1] LXADRBWR[2]
+       LXADRBWR[3] LXADRBWR[4] LXADRBWR[5] LXADRBWR[6] LXADRBWR[7] LXADRRD[0]
+       LXADRRD[1] LXADRRD[2] LXADRRD[3] LXADRRD[4] LXADRRD[5] LXADRRD[6]
+       LXADRRD[7] LXADRWR[0] LXADRWR[1] LXADRWR[2] LXADRWR[3] LXADRWR[4]
+       LXADRWR[5] LXADRWR[6] LXADRWR[7] LYADRBRD[0] LYADRBRD[1] LYADRBWR[0]
+       LYADRBWR[1] LYADRRD[0] LYADRRD[1] LYADRWR[0] LYADRWR[1] MCLKRDB MCLKRDT
+       MCLKWRB MCLKWRT MERD MEWR PROCOM[0] PROCOM[1] PWDO Q[0] Q[1] Q[2] Q[3]
+       Q[4] Q[5] Q[6] Q[7] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13] Q[14] Q[15] Q[16]
+       Q[17] Q[18] Q[19] Q[20] Q[21] Q[22] Q[23] Q[24] Q[25] Q[26] Q[27] Q[28]
+       Q[29] Q[30] Q[31] Q[32] Q[33] Q[34] Q[35] Q[36] Q[37] Q[38] Q[39] Q[40]
+       Q[41] Q[42] Q[43] Q[44] Q[45] Q[46] Q[47] Q[48] Q[49] Q[50] Q[51] Q[52]
+       Q[53] Q[54] Q[55] Q[56] Q[57] Q[58] Q[59] Q[60] Q[61] Q[62] Q[63] Q[64]
+       Q[65] Q[66] Q[67] Q[68] Q[69] Q[70] Q[71] Q[72] Q[73] Q[74] Q[75] Q[76]
+       Q[77] Q[78] Q[79] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8]
+       QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17] QT[18]
+       QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28]
+       QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38]
+       QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48]
+       QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+       QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68]
+       QT[69] QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78]
+       QT[79] QT[80] QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88]
+       QT[89] QT[90] QT[91] QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98]
+       QT[99] QT[100] QT[101] QT[102] QT[103] QT[104] QT[105] QT[106] QT[107]
+       QT[108] QT[109] QT[110] QT[111] QT[112] QT[113] QT[114] QT[115] QT[116]
+       QT[117] QT[118] QT[119] QT[120] QT[121] QT[122] QT[123] QT[124] QT[125]
+       QT[126] QT[127] QT[128] QT[129] QT[130] QT[131] QT[132] QT[133] QT[134]
+       QT[135] QT[136] QT[137] QT[138] QT[139] QT[140] QT[141] QT[142] QT[143]
+       QT[144] QT[145] QT[146] QT[147] QT[148] QT[149] QT[150] QT[151] QT[152]
+       QT[153] QT[154] QT[155] QT[156] QT[157] QT[158] QT[159] RA[0] RA[1]
+       RASSB_H[0] RASSB_H[1] RERASSB[0] RERASSB[1] RFLOAT RFLT_RET
+       RMDEF12_RD_PROCOM00[0] RMDEF12_RD_PROCOM00[1] RMDEF12_RD_PROCOM00[2]
+       RMDEF12_RD_PROCOM00[3] RMDEF12_RD_PROCOM01[0] RMDEF12_RD_PROCOM01[1]
+       RMDEF12_RD_PROCOM01[2] RMDEF12_RD_PROCOM01[3] RMDEF12_WR_PROCOM00[0]
+       RMDEF12_WR_PROCOM00[1] RMDEF12_WR_PROCOM00[2] RMDEF12_WR_PROCOM00[3]
+       RMDEF12_WR_PROCOM01[0] RMDEF12_WR_PROCOM01[1] RMDEF12_WR_PROCOM01[2]
+       RMDEF12_WR_PROCOM01[3] RMERD RMEWR RMRD[0] RMRD[1] RMRD[2] RMRD[3]
+       RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3]
+       RMWR[0] RMWR[1] RMWR[2] RMWR[3] RSCEN RSCIN RSCLK RSCOUT RSCRST RWLCKB
+       SEDB SEDT STRSB T1TRD T1TWR TEST1RD TEST1WR TEST_RNM TKEEPB VBN[0]
+       VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10]
+       VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19]
+       VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28]
+       VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35] VBN[36] VBN[37]
+       VBN[38] VBN[39] VBN[40] VBN[41] VBN[42] VBP[0] VBP[1] VBP[2] VBP[3]
+       VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+       VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21]
+       VBP[22] VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30]
+       VBP[31] VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39]
+       VBP[40] VBP[41] VBP[42] VDDA[0] VDDA[1] VDDA[2] VDDP[0] VDDP[1] VDDP[2]
+       VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+       VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+       VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+       VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+       VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDP[42]
+       VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+       VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+       VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21]
+       VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28]
+       VDDPI[29] VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35]
+       VDDPI[36] VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDPI[42]
+       VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+       VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17]
+       VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26]
+       VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34] VSS[35]
+       VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] VSS[42] WA[0] WA[1]
+       WABUF[0] WABUF[1] WABUF[2] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5]
+       WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14]
+       WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23]
+       WBI[24] WBI[25] WBI[26] WBI[27] WBI[28] WBI[29] WBI[30] WBI[31] WBI[32]
+       WBI[33] WBI[34] WBI[35] WBI[36] WBI[37] WBI[38] WBI[39] WBI[40] WBI[41]
+       WBI[42] WBI[43] WBI[44] WBI[45] WBI[46] WBI[47] WBI[48] WBI[49] WBI[50]
+       WBI[51] WBI[52] WBI[53] WBI[54] WBI[55] WBI[56] WBI[57] WBI[58] WBI[59]
+       WBI[60] WBI[61] WBI[62] WBI[63] WBI[64] WBI[65] WBI[66] WBI[67] WBI[68]
+       WBI[69] WBI[70] WBI[71] WBI[72] WBI[73] WBI[74] WBI[75] WBI[76] WBI[77]
+       WBI[78] WBI[79] WE WEM[0] WEM[1] WEM[2] WEM[3] WEM[4] WEM[5] WEM[6]
+       WEM[7] WEM[8] WEM[9] WEM[10] WEM[11] WEM[12] WEM[13] WEM[14] WEM[15]
+       WEM[16] WEM[17] WEM[18] WEM[19] WEM[20] WEM[21] WEM[22] WEM[23] WEM[24]
+       WEM[25] WEM[26] WEM[27] WEM[28] WEM[29] WEM[30] WEM[31] WEM[32] WEM[33]
+       WEM[34] WEM[35] WEM[36] WEM[37] WEM[38] WEM[39] WEM[40] WEM[41] WEM[42]
+       WEM[43] WEM[44] WEM[45] WEM[46] WEM[47] WEM[48] WEM[49] WEM[50] WEM[51]
+       WEM[52] WEM[53] WEM[54] WEM[55] WEM[56] WEM[57] WEM[58] WEM[59] WEM[60]
+       WEM[61] WEM[62] WEM[63] WEM[64] WEM[65] WEM[66] WEM[67] WEM[68] WEM[69]
+       WEM[70] WEM[71] WEM[72] WEM[73] WEM[74] WEM[75] WEM[76] WEM[77] WEM[78]
+       WEM[79] WEMB[0] WEMB[1] WEMB[2] WEMB[3] WEMB[4] WEMB[5] WEMB[6] WEMB[7]
+       WEMB[8] WEMB[9] WEMB[10] WEMB[11] WEMB[12] WEMB[13] WEMB[14] WEMB[15]
+       WEMB[16] WEMB[17] WEMB[18] WEMB[19] WEMB[20] WEMB[21] WEMB[22] WEMB[23]
+       WEMB[24] WEMB[25] WEMB[26] WEMB[27] WEMB[28] WEMB[29] WEMB[30] WEMB[31]
+       WEMB[32] WEMB[33] WEMB[34] WEMB[35] WEMB[36] WEMB[37] WEMB[38] WEMB[39]
+       WEMB[40] WEMB[41] WEMB[42] WEMB[43] WEMB[44] WEMB[45] WEMB[46] WEMB[47]
+       WEMB[48] WEMB[49] WEMB[50] WEMB[51] WEMB[52] WEMB[53] WEMB[54] WEMB[55]
+       WEMB[56] WEMB[57] WEMB[58] WEMB[59] WEMB[60] WEMB[61] WEMB[62] WEMB[63]
+       WEMB[64] WEMB[65] WEMB[66] WEMB[67] WEMB[68] WEMB[69] WEMB[70] WEMB[71]
+       WEMB[72] WEMB[73] WEMB[74] WEMB[75] WEMB[76] WEMB[77] WEMB[78] WEMB[79]
+       WFLOAT WFLT_RET WP[0] WP[1] WP[2] WPBUF[0] WPBUF[1] WPBUF[2] WTI[0]
+       WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10]
+       WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19]
+       WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27] WTI[28]
+       WTI[29] WTI[30] WTI[31] WTI[32] WTI[33] WTI[34] WTI[35] WTI[36] WTI[37]
+       WTI[38] WTI[39] WTI[40] WTI[41] WTI[42] WTI[43] WTI[44] WTI[45] WTI[46]
+       WTI[47] WTI[48] WTI[49] WTI[50] WTI[51] WTI[52] WTI[53] WTI[54] WTI[55]
+       WTI[56] WTI[57] WTI[58] WTI[59] WTI[60] WTI[61] WTI[62] WTI[63] WTI[64]
+       WTI[65] WTI[66] WTI[67] WTI[68] WTI[69] WTI[70] WTI[71] WTI[72] WTI[73]
+       WTI[74] WTI[75] WTI[76] WTI[77] WTI[78] WTI[79] XADRRD[0] XADRRD[1]
+       XADRRD[2] XADRRD[3] XADRRD[4] XADRRD[5] XADRRD[6] XADRRD[7] XADRWR[0]
+       XADRWR[1] XADRWR[2] XADRWR[3] XADRWR[4] XADRWR[5] XADRWR[6] XADRWR[7]
+       YADRRD[0] YADRRD[1] YADRWR[0] YADRWR[1] YCOLRD[0] YCOLRD[1] YCOLRD[2]
+       YCOLRD[3] YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]
X_gio_cnt ARYSD CENDP CKGATE_RD CLKRD CLKWR DCLKT_H DEF1_RD DEF1_WR DFTCKRD
+   DFTCKWR DFT_OR_SERD DFT_OR_SEWR DLYPDB DLYPW DSORSD FAST1_RD FAST1_WR
+   FAST2_RD FAST2_WR FISO LCLKRDB LCLKRDT LCLKWRB LCLKWRT LITESLP LMERD LMEWR
+   LME_GATING_RD LME_GATING_WR LOG0 LOG1 LOG1RMRD_VDDPI LOG1RMWR_VDDPI
+   LOG1_RMRD LOG1_RMWR LRWMEB LS LWE LXADRBRD[0] LXADRBRD[1] LXADRBRD[2]
+   LXADRBRD[3] LXADRBRD[4] LXADRBRD[5] LXADRBRD[6] LXADRBRD[7] LXADRBWR[0]
+   LXADRBWR[1] LXADRBWR[2] LXADRBWR[3] LXADRBWR[4] LXADRBWR[5] LXADRBWR[6]
+   LXADRBWR[7] LXADRRD[0] LXADRRD[1] LXADRRD[2] LXADRRD[3] LXADRRD[4]
+   LXADRRD[5] LXADRRD[6] LXADRRD[7] LXADRWR[0] LXADRWR[1] LXADRWR[2] LXADRWR[3]
+   LXADRWR[4] LXADRWR[5] LXADRWR[6] LXADRWR[7] LYADRBRD[0] LYADRBRD[1]
+   LYADRBWR[0] LYADRBWR[1] LYADRRD[0] LYADRRD[1] LYADRWR[0] LYADRWR[1] MCLKRDB
+   MCLKRDT MCLKWRB MCLKWRT MERD MEWR PROCOM[0] PROCOM[1] RA[0] RA[1] RASSB_H[0]
+   RASSB_H[1] RFLOAT RFLT_RET RMDEF12_RD_PROCOM00[0] RMDEF12_RD_PROCOM00[1]
+   RMDEF12_RD_PROCOM00[2] RMDEF12_RD_PROCOM00[3] RMDEF12_RD_PROCOM01[0]
+   RMDEF12_RD_PROCOM01[1] RMDEF12_RD_PROCOM01[2] RMDEF12_RD_PROCOM01[3]
+   RMDEF12_WR_PROCOM00[0] RMDEF12_WR_PROCOM00[1] RMDEF12_WR_PROCOM00[2]
+   RMDEF12_WR_PROCOM00[3] RMDEF12_WR_PROCOM01[0] RMDEF12_WR_PROCOM01[1]
+   RMDEF12_WR_PROCOM01[2] RMDEF12_WR_PROCOM01[3] RMERD RMEWR RMRD[0] RMRD[1]
+   RMRD[2] RMRD[3] RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1]
+   RMTWR[2] RMTWR[3] RMWR[0] RMWR[1] RMWR[2] RMWR[3] RSCEN RSCIN RSCLK RSCOUT
+   RSCRST RWLCKB SEDB SEDT SE_DB SE_DT STRSB T1TRD T1TWR TEST1RD TEST1WR
+   TEST_RNM TKEEPB VBN[0] VBP[0] VDDA[0] VDDP[0] VDDPI[0] VSS[0] WA[0] WA[1]
+   WABUF[0] WABUF[1] WABUF[2] WE WFLOAT WFLT_RET WP[0] WP[1] WP[2] WPBUF[0]
+   WPBUF[1] WPBUF[2] XADRRD[0] XADRRD[1] XADRRD[2] XADRRD[3] XADRRD[4]
+   XADRRD[5] XADRRD[6] XADRRD[7] XADRWR[0] XADRWR[1] XADRWR[2] XADRWR[3]
+   XADRWR[4] XADRWR[5] XADRWR[6] XADRWR[7] YADRRD[0] YADRRD[1] YADRWR[0]
+   YADRWR[1] YCOLRD[0] YCOLRD[1] YCOLRD[2] YCOLRD[3] YSELB_H[0] YSELB_H[1]
+   YSELB_H[2] YSELB_H[3] YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]
+   SNPS_RF_DP_UHD_512x80_gio_cnt
X_gio_rt CB[0] CB[1] CB[2] CB[3] CB[4] CB[5] CB[6] CB[7] CB[8] CB[9] CB[10]
+   CB[11] CB[12] CB[13] CB[14] CB[15] CB[16] CB[17] CB[18] CB[19] CB[20] CB[21]
+   CB[22] CB[23] CB[24] CB[25] CB[26] CB[27] CB[28] CB[29] CB[30] CB[31] CB[32]
+   CB[33] CB[34] CB[35] CB[36] CB[37] CB[38] CB[39] CT[0] CT[1] CT[2] CT[3]
+   CT[4] CT[5] CT[6] CT[7] CT[8] CT[9] CT[10] CT[11] CT[12] CT[13] CT[14]
+   CT[15] CT[16] CT[17] CT[18] CT[19] CT[20] CT[21] CT[22] CT[23] CT[24] CT[25]
+   CT[26] CT[27] CT[28] CT[29] CT[30] CT[31] CT[32] CT[33] CT[34] CT[35] CT[36]
+   CT[37] CT[38] CT[39] D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] D[8] D[9] D[10]
+   D[11] D[12] D[13] D[14] D[15] D[16] D[17] D[18] D[19] D[20] D[21] D[22]
+   D[23] D[24] D[25] D[26] D[27] D[28] D[29] D[30] D[31] D[32] D[33] D[34]
+   D[35] D[36] D[37] D[38] D[39] D[40] D[41] D[42] D[43] D[44] D[45] D[46]
+   D[47] D[48] D[49] D[50] D[51] D[52] D[53] D[54] D[55] D[56] D[57] D[58]
+   D[59] D[60] D[61] D[62] D[63] D[64] D[65] D[66] D[67] D[68] D[69] D[70]
+   D[71] D[72] D[73] D[74] D[75] D[76] D[77] D[78] D[79] DCLKT_H DFTBIO[0]
+   DFTBIO[1] DFTBIO[2] DFTBIO[3] DFTBIO[4] DFTBIO[5] DFTBIO[6] DFTBIO[7]
+   DFTBIO[8] DFTBIO[9] DFTBIO[10] DFTBIO[11] DFTBIO[12] DFTBIO[13] DFTBIO[14]
+   DFTBIO[15] DFTBIO[16] DFTBIO[17] DFTBIO[18] DFTBIO[19] DFTBIO[20] DFTBIO[21]
+   DFTBIO[22] DFTBIO[23] DFTBIO[24] DFTBIO[25] DFTBIO[26] DFTBIO[27] DFTBIO[28]
+   DFTBIO[29] DFTBIO[30] DFTBIO[31] DFTBIO[32] DFTBIO[33] DFTBIO[34] DFTBIO[35]
+   DFTBIO[36] DFTBIO[37] DFTBIO[38] DFTBIO[39] DFTBIOB[0] DFTBIOB[1] DFTBIOB[2]
+   DFTBIOB[3] DFTBIOB[4] DFTBIOB[5] DFTBIOB[6] DFTBIOB[7] DFTBIOB[8] DFTBIOB[9]
+   DFTBIOB[10] DFTBIOB[11] DFTBIOB[12] DFTBIOB[13] DFTBIOB[14] DFTBIOB[15]
+   DFTBIOB[16] DFTBIOB[17] DFTBIOB[18] DFTBIOB[19] DFTBIOB[20] DFTBIOB[21]
+   DFTBIOB[22] DFTBIOB[23] DFTBIOB[24] DFTBIOB[25] DFTBIOB[26] DFTBIOB[27]
+   DFTBIOB[28] DFTBIOB[29] DFTBIOB[30] DFTBIOB[31] DFTBIOB[32] DFTBIOB[33]
+   DFTBIOB[34] DFTBIOB[35] DFTBIOB[36] DFTBIOB[37] DFTBIOB[38] DFTBIOB[39]
+   DIB_LT[0] DIB_LT[1] DIB_LT[2] DIB_LT[3] DIB_LT[4] DIB_LT[5] DIB_LT[6]
+   DIB_LT[7] DIB_LT[8] DIB_LT[9] DIB_LT[10] DIB_LT[11] DIB_LT[12] DIB_LT[13]
+   DIB_LT[14] DIB_LT[15] DIB_LT[16] DIB_LT[17] DIB_LT[18] DIB_LT[19] DIB_LT[20]
+   DIB_LT[21] DIB_LT[22] DIB_LT[23] DIB_LT[24] DIB_LT[25] DIB_LT[26] DIB_LT[27]
+   DIB_LT[28] DIB_LT[29] DIB_LT[30] DIB_LT[31] DIB_LT[32] DIB_LT[33] DIB_LT[34]
+   DIB_LT[35] DIB_LT[36] DIB_LT[37] DIB_LT[38] DIB_LT[39] DIB_LT[40] DIB_LT[41]
+   DIB_LT[42] DIB_LT[43] DIB_LT[44] DIB_LT[45] DIB_LT[46] DIB_LT[47] DIB_LT[48]
+   DIB_LT[49] DIB_LT[50] DIB_LT[51] DIB_LT[52] DIB_LT[53] DIB_LT[54] DIB_LT[55]
+   DIB_LT[56] DIB_LT[57] DIB_LT[58] DIB_LT[59] DIB_LT[60] DIB_LT[61] DIB_LT[62]
+   DIB_LT[63] DIB_LT[64] DIB_LT[65] DIB_LT[66] DIB_LT[67] DIB_LT[68] DIB_LT[69]
+   DIB_LT[70] DIB_LT[71] DIB_LT[72] DIB_LT[73] DIB_LT[74] DIB_LT[75] DIB_LT[76]
+   DIB_LT[77] DIB_LT[78] DIB_LT[79] DINB[0] DINB[1] DINB[2] DINB[3] DINB[4]
+   DINB[5] DINB[6] DINB[7] DINB[8] DINB[9] DINB[10] DINB[11] DINB[12] DINB[13]
+   DINB[14] DINB[15] DINB[16] DINB[17] DINB[18] DINB[19] DINB[20] DINB[21]
+   DINB[22] DINB[23] DINB[24] DINB[25] DINB[26] DINB[27] DINB[28] DINB[29]
+   DINB[30] DINB[31] DINB[32] DINB[33] DINB[34] DINB[35] DINB[36] DINB[37]
+   DINB[38] DINB[39] DINB[40] DINB[41] DINB[42] DINB[43] DINB[44] DINB[45]
+   DINB[46] DINB[47] DINB[48] DINB[49] DINB[50] DINB[51] DINB[52] DINB[53]
+   DINB[54] DINB[55] DINB[56] DINB[57] DINB[58] DINB[59] DINB[60] DINB[61]
+   DINB[62] DINB[63] DINB[64] DINB[65] DINB[66] DINB[67] DINB[68] DINB[69]
+   DINB[70] DINB[71] DINB[72] DINB[73] DINB[74] DINB[75] DINB[76] DINB[77]
+   DINB[78] DINB[79] LDIB[0] LDIB[1] LDIB[2] LDIB[3] LDIB[4] LDIB[5] LDIB[6]
+   LDIB[7] LDIB[8] LDIB[9] LDIB[10] LDIB[11] LDIB[12] LDIB[13] LDIB[14]
+   LDIB[15] LDIB[16] LDIB[17] LDIB[18] LDIB[19] LDIB[20] LDIB[21] LDIB[22]
+   LDIB[23] LDIB[24] LDIB[25] LDIB[26] LDIB[27] LDIB[28] LDIB[29] LDIB[30]
+   LDIB[31] LDIB[32] LDIB[33] LDIB[34] LDIB[35] LDIB[36] LDIB[37] LDIB[38]
+   LDIB[39] LDIB[40] LDIB[41] LDIB[42] LDIB[43] LDIB[44] LDIB[45] LDIB[46]
+   LDIB[47] LDIB[48] LDIB[49] LDIB[50] LDIB[51] LDIB[52] LDIB[53] LDIB[54]
+   LDIB[55] LDIB[56] LDIB[57] LDIB[58] LDIB[59] LDIB[60] LDIB[61] LDIB[62]
+   LDIB[63] LDIB[64] LDIB[65] LDIB[66] LDIB[67] LDIB[68] LDIB[69] LDIB[70]
+   LDIB[71] LDIB[72] LDIB[73] LDIB[74] LDIB[75] LDIB[76] LDIB[77] LDIB[78]
+   LDIB[79] LOG0 LOG1 LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6] LQB[7]
+   LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13] LQB[14] LQB[15] LQB[16]
+   LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22] LQB[23] LQB[24] LQB[25]
+   LQB[26] LQB[27] LQB[28] LQB[29] LQB[30] LQB[31] LQB[32] LQB[33] LQB[34]
+   LQB[35] LQB[36] LQB[37] LQB[38] LQB[39] LQB[40] LQB[41] LQB[42] LQB[43]
+   LQB[44] LQB[45] LQB[46] LQB[47] LQB[48] LQB[49] LQB[50] LQB[51] LQB[52]
+   LQB[53] LQB[54] LQB[55] LQB[56] LQB[57] LQB[58] LQB[59] LQB[60] LQB[61]
+   LQB[62] LQB[63] LQB[64] LQB[65] LQB[66] LQB[67] LQB[68] LQB[69] LQB[70]
+   LQB[71] LQB[72] LQB[73] LQB[74] LQB[75] LQB[76] LQB[77] LQB[78] LQB[79] PWDO
+   Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13]
+   Q[14] Q[15] Q[16] Q[17] Q[18] Q[19] Q[20] Q[21] Q[22] Q[23] Q[24] Q[25]
+   Q[26] Q[27] Q[28] Q[29] Q[30] Q[31] Q[32] Q[33] Q[34] Q[35] Q[36] Q[37]
+   Q[38] Q[39] Q[40] Q[41] Q[42] Q[43] Q[44] Q[45] Q[46] Q[47] Q[48] Q[49]
+   Q[50] Q[51] Q[52] Q[53] Q[54] Q[55] Q[56] Q[57] Q[58] Q[59] Q[60] Q[61]
+   Q[62] Q[63] Q[64] Q[65] Q[66] Q[67] Q[68] Q[69] Q[70] Q[71] Q[72] Q[73]
+   Q[74] Q[75] Q[76] Q[77] Q[78] Q[79] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5]
+   QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16]
+   QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27]
+   QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38]
+   QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49]
+   QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60]
+   QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70] QT[71]
+   QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80] QT[81] QT[82]
+   QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91] QT[92] QT[93]
+   QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101] QT[102] QT[103]
+   QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110] QT[111] QT[112]
+   QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119] QT[120] QT[121]
+   QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128] QT[129] QT[130]
+   QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137] QT[138] QT[139]
+   QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146] QT[147] QT[148]
+   QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155] QT[156] QT[157]
+   QT[158] QT[159] RASSB_H[0] RASSB_H[1] RERASSB[0] RERASSB[1] SE_DB SE_DT
+   VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10]
+   VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19]
+   VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28]
+   VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35] VBN[36] VBN[37]
+   VBN[38] VBN[39] VBN[40] VBN[41] VBN[42] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5]
+   VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15]
+   VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24]
+   VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32] VBP[33]
+   VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40] VBP[41] VBP[42]
+   VDDA[1] VDDA[2] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7]
+   VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15]
+   VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23]
+   VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31]
+   VDDP[32] VDDP[33] VDDP[34] VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39]
+   VDDP[40] VDDP[41] VDDP[42] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5]
+   VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13]
+   VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20]
+   VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27]
+   VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34]
+   VDDPI[35] VDDPI[36] VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41]
+   VDDPI[42] VEDGE VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+   VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17]
+   VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26]
+   VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34] VSS[35]
+   VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] VSS[42] WBI[0] WBI[1] WBI[2]
+   WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12]
+   WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21]
+   WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27] WBI[28] WBI[29] WBI[30]
+   WBI[31] WBI[32] WBI[33] WBI[34] WBI[35] WBI[36] WBI[37] WBI[38] WBI[39]
+   WBI[40] WBI[41] WBI[42] WBI[43] WBI[44] WBI[45] WBI[46] WBI[47] WBI[48]
+   WBI[49] WBI[50] WBI[51] WBI[52] WBI[53] WBI[54] WBI[55] WBI[56] WBI[57]
+   WBI[58] WBI[59] WBI[60] WBI[61] WBI[62] WBI[63] WBI[64] WBI[65] WBI[66]
+   WBI[67] WBI[68] WBI[69] WBI[70] WBI[71] WBI[72] WBI[73] WBI[74] WBI[75]
+   WBI[76] WBI[77] WBI[78] WBI[79] WEM[0] WEM[1] WEM[2] WEM[3] WEM[4] WEM[5]
+   WEM[6] WEM[7] WEM[8] WEM[9] WEM[10] WEM[11] WEM[12] WEM[13] WEM[14] WEM[15]
+   WEM[16] WEM[17] WEM[18] WEM[19] WEM[20] WEM[21] WEM[22] WEM[23] WEM[24]
+   WEM[25] WEM[26] WEM[27] WEM[28] WEM[29] WEM[30] WEM[31] WEM[32] WEM[33]
+   WEM[34] WEM[35] WEM[36] WEM[37] WEM[38] WEM[39] WEM[40] WEM[41] WEM[42]
+   WEM[43] WEM[44] WEM[45] WEM[46] WEM[47] WEM[48] WEM[49] WEM[50] WEM[51]
+   WEM[52] WEM[53] WEM[54] WEM[55] WEM[56] WEM[57] WEM[58] WEM[59] WEM[60]
+   WEM[61] WEM[62] WEM[63] WEM[64] WEM[65] WEM[66] WEM[67] WEM[68] WEM[69]
+   WEM[70] WEM[71] WEM[72] WEM[73] WEM[74] WEM[75] WEM[76] WEM[77] WEM[78]
+   WEM[79] WEMB[0] WEMB[1] WEMB[2] WEMB[3] WEMB[4] WEMB[5] WEMB[6] WEMB[7]
+   WEMB[8] WEMB[9] WEMB[10] WEMB[11] WEMB[12] WEMB[13] WEMB[14] WEMB[15]
+   WEMB[16] WEMB[17] WEMB[18] WEMB[19] WEMB[20] WEMB[21] WEMB[22] WEMB[23]
+   WEMB[24] WEMB[25] WEMB[26] WEMB[27] WEMB[28] WEMB[29] WEMB[30] WEMB[31]
+   WEMB[32] WEMB[33] WEMB[34] WEMB[35] WEMB[36] WEMB[37] WEMB[38] WEMB[39]
+   WEMB[40] WEMB[41] WEMB[42] WEMB[43] WEMB[44] WEMB[45] WEMB[46] WEMB[47]
+   WEMB[48] WEMB[49] WEMB[50] WEMB[51] WEMB[52] WEMB[53] WEMB[54] WEMB[55]
+   WEMB[56] WEMB[57] WEMB[58] WEMB[59] WEMB[60] WEMB[61] WEMB[62] WEMB[63]
+   WEMB[64] WEMB[65] WEMB[66] WEMB[67] WEMB[68] WEMB[69] WEMB[70] WEMB[71]
+   WEMB[72] WEMB[73] WEMB[74] WEMB[75] WEMB[76] WEMB[77] WEMB[78] WEMB[79]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9]
+   WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18]
+   WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27]
+   WTI[28] WTI[29] WTI[30] WTI[31] WTI[32] WTI[33] WTI[34] WTI[35] WTI[36]
+   WTI[37] WTI[38] WTI[39] WTI[40] WTI[41] WTI[42] WTI[43] WTI[44] WTI[45]
+   WTI[46] WTI[47] WTI[48] WTI[49] WTI[50] WTI[51] WTI[52] WTI[53] WTI[54]
+   WTI[55] WTI[56] WTI[57] WTI[58] WTI[59] WTI[60] WTI[61] WTI[62] WTI[63]
+   WTI[64] WTI[65] WTI[66] WTI[67] WTI[68] WTI[69] WTI[70] WTI[71] WTI[72]
+   WTI[73] WTI[74] WTI[75] WTI[76] WTI[77] WTI[78] WTI[79] YSELB_H[0]
+   YSELB_H[1] YSELB_H[2] YSELB_H[3] SNPS_RF_DP_UHD_512x80_gio_rt
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_was_cnt ARYSD CENDP CKGATE_RD DEF1_RD DEF1_WR
+       FAST1_RD FAST1_WR FAST2_RD FAST2_WR LIOPD LITESLP LOG0[0] LOG0[1] LOG1
+       LRWMEB LXADRBRD[0] LXADRBRD[1] LXADRBRD[2] LXADRBRD[3] LXADRBRD[4]
+       LXADRBRD[5] LXADRBRD[6] LXADRBRD[7] LXADRBWR[0] LXADRBWR[1] LXADRBWR[2]
+       LXADRBWR[3] LXADRBWR[4] LXADRBWR[5] LXADRBWR[6] LXADRBWR[7] LXADRRD[0]
+       LXADRRD[1] LXADRRD[2] LXADRRD[3] LXADRRD[4] LXADRRD[5] LXADRRD[6]
+       LXADRRD[7] LXADRWR[0] LXADRWR[1] LXADRWR[2] LXADRWR[3] LXADRWR[4]
+       LXADRWR[5] LXADRWR[6] LXADRWR[7] LYADRBRD[0] LYADRBRD[1] LYADRBWR[0]
+       LYADRBWR[1] LYADRRD[0] LYADRRD[1] LYADRWR[0] LYADRWR[1] PAARD[0]
+       PAARD[1] PAARD[2] PAARD[3] PAAWR[0] PAAWR[1] PAAWR[2] PAAWR[3] PAWR[0]
+       PAWR[1] PAWR[2] PAWR[3] PBRD[0] PBRD[1] PBRD[2] PBRD[3] PBWR[0] PBWR[1]
+       PBWR[2] PBWR[3] PCRD[0] PCRD[1] PCRD[2] PCRD[3] PCWR[0] PCWR[1] PCWR[2]
+       PCWR[3] RASSB_H[0] RASSB_H[1] RBLWA RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] STCLK
+       STRSB T1TRD T1TWR TKEEPB VBN[0] VBN[1] VBN[2] VBP[0] VBP[1] VBP[2]
+       VDDA[0] VDDA[1] VDDA[2] VDDF VDDP[0] VDDP[1] VDDP[2] VDDPI[0] VDDPI[1]
+       VDDPI[2] VSS[0] VSS[1] VSS[2] WABUF[0] WABUF[1] WABUF[2] WAB_H[0]
+       WAB_H[1] WAPCLK WAPRCLKB_RET WAPRCLKB_RET_DEL WAPRCLKB_RET_DEL_2
+       WAPRCLKB_RET_DEL_4 WAPRCLKB_RET_LCEN WFLOAT WFLT_RET WPBUF[0] WPBUF[1]
+       WPBUF[2] YCOLRD[0] YCOLRD[1] YCOLRD[2] YCOLRD[3] YCOLWR[0] YCOLWR[1]
+       YCOLWR[2] YCOLWR[3] YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: LIOPD LOG0[1]
* Jumper: PRCKDLY TAP[1]
* Jumper: VDDA[1] VDDF VDDP[1] VDDPI[1]
* Jumper: VDDA[2] VDDP[2] VDDPI[2]
* Jumper: WAPRCLKB_RET_LCEN WAPRCLKB_RET

*X_mm17a04_u_hdrf2p_lcen_wa_edgel_cm2 VDDA[0] VDDP[0] VDDPI[0] VSS[0] VBP[0]
*+  VBN[0] mm17a04_u_hdrf2p_lcen_wa_edgel
X_mm17a04_u_hdrf2p_lcen_wa_cm2 VDDA[1] VDDF VDDP[1] VDDPI[1] VSS[1] VBP[1]
+   VBN[1] TAP[0] PRCKDLY TAP[2] TAP[3] WAPCLKB ARYSD CENDP CKGATE_RD DEF1_RD
+   DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LITESLP LOG0[0] LOG1 LRWMEB
+   LXADRBRD[0] LXADRBRD[1] LXADRBRD[2] LXADRBRD[3] LXADRBRD[4] LXADRBRD[5]
+   LXADRBRD[6] LXADRBRD[7] LXADRBWR[0] LXADRBWR[1] LXADRBWR[2] LXADRBWR[3]
+   LXADRBWR[4] LXADRBWR[5] LXADRBWR[6] LXADRBWR[7] LXADRRD[0] LXADRRD[1]
+   LXADRRD[2] LXADRRD[3] LXADRRD[4] LXADRRD[5] LXADRRD[6] LXADRRD[7] LXADRWR[0]
+   LXADRWR[1] LXADRWR[2] LXADRWR[3] LXADRWR[4] LXADRWR[5] LXADRWR[6] LXADRWR[7]
+   LYADRBRD[0] LYADRBRD[1] LYADRBWR[0] LYADRBWR[1] LYADRRD[0] LYADRRD[1]
+   LYADRWR[0] LYADRWR[1] PAARD[0] PAARD[1] PAARD[2] PAARD[3] PAAWR[0] PAAWR[1]
+   PAAWR[2] PAAWR[3] PAWR[0] PAWR[1] PAWR[2] PAWR[3] PBRD[0] PBRD[1] PBRD[2]
+   PBRD[3] PBWR[0] PBWR[1] PBWR[2] PBWR[3] PCRD[0] PCRD[1] PCRD[2] PCRD[3]
+   PCWR[0] PCWR[1] PCWR[2] PCWR[3] RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1]
+   RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] STRSB T1TRD T1TWR
+   TKEEPB WABUF[0] WABUF[1] WABUF[2] WAPRCLKB_RET WAPRCLKB_RET_DEL
+   WAPRCLKB_RET_DEL_2 WAPRCLKB_RET_DEL_4 WAPRCLKB_RET_LCEN WFLOAT WFLT_RET
+   YCOLRD[0] YCOLRD[1] YCOLRD[2] YCOLRD[3] YCOLWR[0] YCOLWR[1] YCOLWR[2]
+   YCOLWR[3] YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] PRCKDLY RBLWA STCLK
+   WPBUF[0] WPBUF[1] WPBUF[2] mm17a04_u_hdrf2p_lcen_wa
X_mm17a04_u_hdrf2p_lcenbuf_wa_cm2 VDDA[2] VDDP[2] VDDPI[2] VSS[2] VBP[2] VBN[2]
+   WAB_H[0] WAB_H[1] WAPCLK LOG0[1] RASSB_H[0] RASSB_H[1] WAPRCLKB_RET LIOPD
+   WABUF[0] WABUF[1] WAPCLKB mm17a04_u_hdrf2p_lcenbuf_wa
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_was_rt_seg1 BADB[0] BADB[1] BADB[2] BADB[3]
+       BADB[4] BADB[5] BADB[6] BADB[7] BADB[8] BADB[9] BADB[10] BADB[11]
+       BADB[12] BADB[13] BADB[14] BADB[15] BADB[16] BADB[17] BADB[18] BADB[19]
+       QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10]
+       QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17] QT[18] QT[19] QT[20]
+       QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28] QT[29] QT[30]
+       QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38] QT[39] QT[40]
+       QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49] QT[50]
+       QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60]
+       QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70]
+       QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] VBN[0]
+       VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10]
+       VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19]
+       VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9]
+       VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18]
+       VBP[19] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+       VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+       VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDAI[0] VDDAI[1] VDDAI[2] VDDAI[3]
+       VDDAI[4] VDDAI[5] VDDAI[6] VDDAI[7] VDDAI[8] VDDAI[9] VDDAI[10]
+       VDDAI[11] VDDAI[12] VDDAI[13] VDDAI[14] VDDAI[15] VDDAI[16] VDDAI[17]
+       VDDAI[18] VDDAI[19] VDDAI_SAC[0] VDDAI_SAC[1] VDDAI_SAC[2] VDDAI_SAC[3]
+       VDDAI_SAC[4] VDDAI_SAC[5] VDDAI_SAC[6] VDDAI_SAC[7] VDDAI_SAC[8]
+       VDDAI_SAC[9] VDDAI_SAC[10] VDDAI_SAC[11] VDDAI_SAC[12] VDDAI_SAC[13]
+       VDDAI_SAC[14] VDDAI_SAC[15] VDDAI_SAC[16] VDDAI_SAC[17] VDDAI_SAC[18]
+       VDDAI_SAC[19] VDDP VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5]
+       VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+       VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19]
+       VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9]
+       VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18]
+       VSS[19] WAB[0] WAB[1] WACKB WAGND[0] WAGND[1] WAGND[2] WAGND[3] WAGND[4]
+       WAGND[5] WAGND[6] WAGND[7] WAGND[8] WAGND[9] WAGND[10] WAGND[11]
+       WAGND[12] WAGND[13] WAGND[14] WAGND[15] WAGND[16] WAGND[17] WAGND[18]
+       WAGND[19] WAGND[20] WAGND[21] WAGND[22] WAGND[23] WAGND[24] WAGND[25]
+       WAGND[26] WAGND[27] WAGND[28] WAGND[29] WAGND[30] WAGND[31] WAGND[32]
+       WAGND[33] WAGND[34] WAGND[35] WAGND[36] WAGND[37] WAGND[38] WAGND[39]
+       WAPCLK WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8]
+       WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17]
+       WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26]
+       WBI[27] WBI[28] WBI[29] WBI[30] WBI[31] WBI[32] WBI[33] WBI[34] WBI[35]
+       WBI[36] WBI[37] WBI[38] WBI[39] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4]
+       WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13]
+       WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22]
+       WTI[23] WTI[24] WTI[25] WTI[26] WTI[27] WTI[28] WTI[29] WTI[30] WTI[31]
+       WTI[32] WTI[33] WTI[34] WTI[35] WTI[36] WTI[37] WTI[38] WTI[39]

*** Jumper Report ***
* Jumper: VDDP VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19]

X_mm17a04_u_hdrf2p_cmux2x2_wa_128_S0 VDDA[0] VDDAI[0] VDDAI_SAC[0] VDDP VDDPI[0]
+   VSS[0] VBP[0] VBN[0] BADB[0] QT[0] QT[1] QT[2] QT[3] WAB[0] WAB[1] WACKB
+   WAGND[0] WAGND[1] WAPCLK WBI[0] WBI[1] WTI[0] WTI[1]
+   mm17a04_u_hdrf2p_cmux2x2_wa_128
X_mm17a04_u_hdrf2p_cmux2x2_wa_128_S1 VDDA[1] VDDAI[1] VDDAI_SAC[1] VDDP VDDPI[1]
+   VSS[1] VBP[1] VBN[1] BADB[1] QT[4] QT[5] QT[6] QT[7] WAB[0] WAB[1] WACKB
+   WAGND[2] WAGND[3] WAPCLK WBI[2] WBI[3] WTI[2] WTI[3]
+   mm17a04_u_hdrf2p_cmux2x2_wa_128
X_mm17a04_u_hdrf2p_cmux2x2_wa_128_S2 VDDA[2] VDDAI[2] VDDAI_SAC[2] VDDP VDDPI[2]
+   VSS[2] VBP[2] VBN[2] BADB[2] QT[8] QT[9] QT[10] QT[11] WAB[0] WAB[1] WACKB
+   WAGND[4] WAGND[5] WAPCLK WBI[4] WBI[5] WTI[4] WTI[5]
+   mm17a04_u_hdrf2p_cmux2x2_wa_128
X_mm17a04_u_hdrf2p_cmux2x2_wa_128_S3 VDDA[3] VDDAI[3] VDDAI_SAC[3] VDDP VDDPI[3]
+   VSS[3] VBP[3] VBN[3] BADB[3] QT[12] QT[13] QT[14] QT[15] WAB[0] WAB[1] WACKB
+   WAGND[6] WAGND[7] WAPCLK WBI[6] WBI[7] WTI[6] WTI[7]
+   mm17a04_u_hdrf2p_cmux2x2_wa_128
X_mm17a04_u_hdrf2p_cmux2x2_wa_128_S4 VDDA[4] VDDAI[4] VDDAI_SAC[4] VDDP VDDPI[4]
+   VSS[4] VBP[4] VBN[4] BADB[4] QT[16] QT[17] QT[18] QT[19] WAB[0] WAB[1] WACKB
+   WAGND[8] WAGND[9] WAPCLK WBI[8] WBI[9] WTI[8] WTI[9]
+   mm17a04_u_hdrf2p_cmux2x2_wa_128
X_mm17a04_u_hdrf2p_cmux2x2_wa_128_S5 VDDA[5] VDDAI[5] VDDAI_SAC[5] VDDP VDDPI[5]
+   VSS[5] VBP[5] VBN[5] BADB[5] QT[20] QT[21] QT[22] QT[23] WAB[0] WAB[1] WACKB
+   WAGND[10] WAGND[11] WAPCLK WBI[10] WBI[11] WTI[10] WTI[11]
+   mm17a04_u_hdrf2p_cmux2x2_wa_128
X_mm17a04_u_hdrf2p_cmux2x2_wa_128_S6 VDDA[6] VDDAI[6] VDDAI_SAC[6] VDDP VDDPI[6]
+   VSS[6] VBP[6] VBN[6] BADB[6] QT[24] QT[25] QT[26] QT[27] WAB[0] WAB[1] WACKB
+   WAGND[12] WAGND[13] WAPCLK WBI[12] WBI[13] WTI[12] WTI[13]
+   mm17a04_u_hdrf2p_cmux2x2_wa_128
X_mm17a04_u_hdrf2p_cmux2x2_wa_128_S7 VDDA[7] VDDAI[7] VDDAI_SAC[7] VDDP VDDPI[7]
+   VSS[7] VBP[7] VBN[7] BADB[7] QT[28] QT[29] QT[30] QT[31] WAB[0] WAB[1] WACKB
+   WAGND[14] WAGND[15] WAPCLK WBI[14] WBI[15] WTI[14] WTI[15]
+   mm17a04_u_hdrf2p_cmux2x2_wa_128
X_mm17a04_u_hdrf2p_cmux2x2_wa_128_S8 VDDA[8] VDDAI[8] VDDAI_SAC[8] VDDP VDDPI[8]
+   VSS[8] VBP[8] VBN[8] BADB[8] QT[32] QT[33] QT[34] QT[35] WAB[0] WAB[1] WACKB
+   WAGND[16] WAGND[17] WAPCLK WBI[16] WBI[17] WTI[16] WTI[17]
+   mm17a04_u_hdrf2p_cmux2x2_wa_128
X_mm17a04_u_hdrf2p_cmux2x2_wa_128_S9 VDDA[9] VDDAI[9] VDDAI_SAC[9] VDDP VDDPI[9]
+   VSS[9] VBP[9] VBN[9] BADB[9] QT[36] QT[37] QT[38] QT[39] WAB[0] WAB[1] WACKB
+   WAGND[18] WAGND[19] WAPCLK WBI[18] WBI[19] WTI[18] WTI[19]
+   mm17a04_u_hdrf2p_cmux2x2_wa_128
X_mm17a04_u_hdrf2p_cmux2x2_wa_128_F9 VDDA[10] VDDAI[10] VDDAI_SAC[10] VDDP
+   VDDPI[10] VSS[10] VBP[10] VBN[10] BADB[10] QT[40] QT[41] QT[42] QT[43]
+   WAB[0] WAB[1] WACKB WAGND[20] WAGND[21] WAPCLK WBI[20] WBI[21] WTI[20]
+   WTI[21] mm17a04_u_hdrf2p_cmux2x2_wa_128
X_mm17a04_u_hdrf2p_cmux2x2_wa_128_F8 VDDA[11] VDDAI[11] VDDAI_SAC[11] VDDP
+   VDDPI[11] VSS[11] VBP[11] VBN[11] BADB[11] QT[44] QT[45] QT[46] QT[47]
+   WAB[0] WAB[1] WACKB WAGND[22] WAGND[23] WAPCLK WBI[22] WBI[23] WTI[22]
+   WTI[23] mm17a04_u_hdrf2p_cmux2x2_wa_128
X_mm17a04_u_hdrf2p_cmux2x2_wa_128_F7 VDDA[12] VDDAI[12] VDDAI_SAC[12] VDDP
+   VDDPI[12] VSS[12] VBP[12] VBN[12] BADB[12] QT[48] QT[49] QT[50] QT[51]
+   WAB[0] WAB[1] WACKB WAGND[24] WAGND[25] WAPCLK WBI[24] WBI[25] WTI[24]
+   WTI[25] mm17a04_u_hdrf2p_cmux2x2_wa_128
X_mm17a04_u_hdrf2p_cmux2x2_wa_128_F6 VDDA[13] VDDAI[13] VDDAI_SAC[13] VDDP
+   VDDPI[13] VSS[13] VBP[13] VBN[13] BADB[13] QT[52] QT[53] QT[54] QT[55]
+   WAB[0] WAB[1] WACKB WAGND[26] WAGND[27] WAPCLK WBI[26] WBI[27] WTI[26]
+   WTI[27] mm17a04_u_hdrf2p_cmux2x2_wa_128
X_mm17a04_u_hdrf2p_cmux2x2_wa_128_F5 VDDA[14] VDDAI[14] VDDAI_SAC[14] VDDP
+   VDDPI[14] VSS[14] VBP[14] VBN[14] BADB[14] QT[56] QT[57] QT[58] QT[59]
+   WAB[0] WAB[1] WACKB WAGND[28] WAGND[29] WAPCLK WBI[28] WBI[29] WTI[28]
+   WTI[29] mm17a04_u_hdrf2p_cmux2x2_wa_128
X_mm17a04_u_hdrf2p_cmux2x2_wa_128_F4 VDDA[15] VDDAI[15] VDDAI_SAC[15] VDDP
+   VDDPI[15] VSS[15] VBP[15] VBN[15] BADB[15] QT[60] QT[61] QT[62] QT[63]
+   WAB[0] WAB[1] WACKB WAGND[30] WAGND[31] WAPCLK WBI[30] WBI[31] WTI[30]
+   WTI[31] mm17a04_u_hdrf2p_cmux2x2_wa_128
X_mm17a04_u_hdrf2p_cmux2x2_wa_128_F3 VDDA[16] VDDAI[16] VDDAI_SAC[16] VDDP
+   VDDPI[16] VSS[16] VBP[16] VBN[16] BADB[16] QT[64] QT[65] QT[66] QT[67]
+   WAB[0] WAB[1] WACKB WAGND[32] WAGND[33] WAPCLK WBI[32] WBI[33] WTI[32]
+   WTI[33] mm17a04_u_hdrf2p_cmux2x2_wa_128
X_mm17a04_u_hdrf2p_cmux2x2_wa_128_F2 VDDA[17] VDDAI[17] VDDAI_SAC[17] VDDP
+   VDDPI[17] VSS[17] VBP[17] VBN[17] BADB[17] QT[68] QT[69] QT[70] QT[71]
+   WAB[0] WAB[1] WACKB WAGND[34] WAGND[35] WAPCLK WBI[34] WBI[35] WTI[34]
+   WTI[35] mm17a04_u_hdrf2p_cmux2x2_wa_128
X_mm17a04_u_hdrf2p_cmux2x2_wa_128_F1 VDDA[18] VDDAI[18] VDDAI_SAC[18] VDDP
+   VDDPI[18] VSS[18] VBP[18] VBN[18] BADB[18] QT[72] QT[73] QT[74] QT[75]
+   WAB[0] WAB[1] WACKB WAGND[36] WAGND[37] WAPCLK WBI[36] WBI[37] WTI[36]
+   WTI[37] mm17a04_u_hdrf2p_cmux2x2_wa_128
X_mm17a04_u_hdrf2p_cmux2x2_wa_128_F0 VDDA[19] VDDAI[19] VDDAI_SAC[19] VDDP
+   VDDPI[19] VSS[19] VBP[19] VBN[19] BADB[19] QT[76] QT[77] QT[78] QT[79]
+   WAB[0] WAB[1] WACKB WAGND[38] WAGND[39] WAPCLK WBI[38] WBI[39] WTI[38]
+   WTI[39] mm17a04_u_hdrf2p_cmux2x2_wa_128
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_was_rt BADB[0] BADB[1] BADB[2] BADB[3] BADB[4]
+       BADB[5] BADB[6] BADB[7] BADB[8] BADB[9] BADB[10] BADB[11] BADB[12]
+       BADB[13] BADB[14] BADB[15] BADB[16] BADB[17] BADB[18] BADB[19] BADB[20]
+       BADB[21] BADB[22] BADB[23] BADB[24] BADB[25] BADB[26] BADB[27] BADB[28]
+       BADB[29] BADB[30] BADB[31] BADB[32] BADB[33] BADB[34] BADB[35] BADB[36]
+       BADB[37] BADB[38] BADB[39] LIOPD LOG0[0] LOG0[1] LOG1[1] PGIOI QT[0]
+       QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11]
+       QT[12] QT[13] QT[14] QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21]
+       QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28] QT[29] QT[30] QT[31]
+       QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38] QT[39] QT[40] QT[41]
+       QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49] QT[50] QT[51]
+       QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60] QT[61]
+       QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70] QT[71]
+       QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80] QT[81]
+       QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91]
+       QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101]
+       QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110]
+       QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119]
+       QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128]
+       QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137]
+       QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146]
+       QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155]
+       QT[156] QT[157] QT[158] QT[159] RERASSB[0] RERASSB[1] VBN[0] VBN[1]
+       VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11]
+       VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20]
+       VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28] VBN[29]
+       VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35] VBN[36] VBN[37] VBN[38]
+       VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+       VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15]
+       VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24]
+       VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32] VBP[33]
+       VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40] VBP[41] VDDA[0]
+       VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9]
+       VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17]
+       VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24] VDDA[25]
+       VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31] VDDA[32] VDDA[33]
+       VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39] VDDA[40] VDDAIR1
+       VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+       VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+       VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+       VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+       VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+       VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VEDGE VSS[0] VSS[1]
+       VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11]
+       VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] VSS[20]
+       VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28] VSS[29]
+       VSS[30] VSS[31] VSS[32] VSS[33] VSS[34] VSS[35] VSS[36] VSS[37] VSS[38]
+       VSS[39] VSS[40] VSS[41] WAB[0] WAB[1] WACKB[0] WAGND[0] WAGND[1]
+       WAGND[2] WAGND[3] WAGND[4] WAGND[5] WAGND[6] WAGND[7] WAGND[8] WAGND[9]
+       WAGND[10] WAGND[11] WAGND[12] WAGND[13] WAGND[14] WAGND[15] WAGND[16]
+       WAGND[17] WAGND[18] WAGND[19] WAGND[20] WAGND[21] WAGND[22] WAGND[23]
+       WAGND[24] WAGND[25] WAGND[26] WAGND[27] WAGND[28] WAGND[29] WAGND[30]
+       WAGND[31] WAGND[32] WAGND[33] WAGND[34] WAGND[35] WAGND[36] WAGND[37]
+       WAGND[38] WAGND[39] WAGND[40] WAGND[41] WAGND[42] WAGND[43] WAGND[44]
+       WAGND[45] WAGND[46] WAGND[47] WAGND[48] WAGND[49] WAGND[50] WAGND[51]
+       WAGND[52] WAGND[53] WAGND[54] WAGND[55] WAGND[56] WAGND[57] WAGND[58]
+       WAGND[59] WAGND[60] WAGND[61] WAGND[62] WAGND[63] WAGND[64] WAGND[65]
+       WAGND[66] WAGND[67] WAGND[68] WAGND[69] WAGND[70] WAGND[71] WAGND[72]
+       WAGND[73] WAGND[74] WAGND[75] WAGND[76] WAGND[77] WAGND[78] WAGND[79]
+       WAPCLK WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8]
+       WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17]
+       WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26]
+       WBI[27] WBI[28] WBI[29] WBI[30] WBI[31] WBI[32] WBI[33] WBI[34] WBI[35]
+       WBI[36] WBI[37] WBI[38] WBI[39] WBI[40] WBI[41] WBI[42] WBI[43] WBI[44]
+       WBI[45] WBI[46] WBI[47] WBI[48] WBI[49] WBI[50] WBI[51] WBI[52] WBI[53]
+       WBI[54] WBI[55] WBI[56] WBI[57] WBI[58] WBI[59] WBI[60] WBI[61] WBI[62]
+       WBI[63] WBI[64] WBI[65] WBI[66] WBI[67] WBI[68] WBI[69] WBI[70] WBI[71]
+       WBI[72] WBI[73] WBI[74] WBI[75] WBI[76] WBI[77] WBI[78] WBI[79] WTI[0]
+       WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10]
+       WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19]
+       WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27] WTI[28]
+       WTI[29] WTI[30] WTI[31] WTI[32] WTI[33] WTI[34] WTI[35] WTI[36] WTI[37]
+       WTI[38] WTI[39] WTI[40] WTI[41] WTI[42] WTI[43] WTI[44] WTI[45] WTI[46]
+       WTI[47] WTI[48] WTI[49] WTI[50] WTI[51] WTI[52] WTI[53] WTI[54] WTI[55]
+       WTI[56] WTI[57] WTI[58] WTI[59] WTI[60] WTI[61] WTI[62] WTI[63] WTI[64]
+       WTI[65] WTI[66] WTI[67] WTI[68] WTI[69] WTI[70] WTI[71] WTI[72] WTI[73]
+       WTI[74] WTI[75] WTI[76] WTI[77] WTI[78] WTI[79]

*** Jumper Report ***
* Jumper: LIOPD LOG0[0]
* Jumper: VDDA[20] VDDP[1]
* Jumper: WACKB[0] REWAPCLK
* Jumper: WACKB[1] WAPCLK_RET

X_was_rt_seg1_S0 BADB[0] BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7]
+   BADB[8] BADB[9] BADB[10] BADB[11] BADB[12] BADB[13] BADB[14] BADB[15]
+   BADB[16] BADB[17] BADB[18] BADB[19] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5]
+   QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16]
+   QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27]
+   QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38]
+   QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49]
+   QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60]
+   QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70] QT[71]
+   QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] VBN[0] VBN[1] VBN[2]
+   VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12]
+   VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBP[0] VBP[1] VBP[2]
+   VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+   VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VDDA[0] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10]
+   VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17] VDDA[18]
+   VDDA[19] VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1
+   VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1
+   VDDAIR1 VDDAIR1 VDDAIR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1
+   VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1
+   VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1
+   VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDP[0] VDDPI[0] VDDPI[1]
+   VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9]
+   VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16]
+   VDDPI[17] VDDPI[18] VDDPI[19] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+   VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15]
+   VSS[16] VSS[17] VSS[18] VSS[19] WAB[0] WAB[1] WACKB[0] WAGND[0] WAGND[1]
+   WAGND[2] WAGND[3] WAGND[4] WAGND[5] WAGND[6] WAGND[7] WAGND[8] WAGND[9]
+   WAGND[10] WAGND[11] WAGND[12] WAGND[13] WAGND[14] WAGND[15] WAGND[16]
+   WAGND[17] WAGND[18] WAGND[19] WAGND[20] WAGND[21] WAGND[22] WAGND[23]
+   WAGND[24] WAGND[25] WAGND[26] WAGND[27] WAGND[28] WAGND[29] WAGND[30]
+   WAGND[31] WAGND[32] WAGND[33] WAGND[34] WAGND[35] WAGND[36] WAGND[37]
+   WAGND[38] WAGND[39] WAPCLK WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+   WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16]
+   WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25]
+   WBI[26] WBI[27] WBI[28] WBI[29] WBI[30] WBI[31] WBI[32] WBI[33] WBI[34]
+   WBI[35] WBI[36] WBI[37] WBI[38] WBI[39] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4]
+   WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14]
+   WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23]
+   WTI[24] WTI[25] WTI[26] WTI[27] WTI[28] WTI[29] WTI[30] WTI[31] WTI[32]
+   WTI[33] WTI[34] WTI[35] WTI[36] WTI[37] WTI[38] WTI[39]
+   SNPS_RF_DP_UHD_512x80_was_rt_seg1
X_mm17a04_u_hdrf2p_lcenrebuf_wa_cm2 VDDA[20] VDDP[1] VDDPI[20] VSS[20] VBP[20]
+   VBN[20] REWAB[0] REWAB[1] WACKB[0] WACKB[0] LOG0[0] LOG1[0] RERASSB[0]
+   RERASSB[1] LIOPD WAB[0] WAB[1] WAPCLK mm17a04_u_hdrf2p_lcenrebuf_wa
X_was_rt_seg1_F0 BADB[20] BADB[21] BADB[22] BADB[23] BADB[24] BADB[25] BADB[26]
+   BADB[27] BADB[28] BADB[29] BADB[30] BADB[31] BADB[32] BADB[33] BADB[34]
+   BADB[35] BADB[36] BADB[37] BADB[38] BADB[39] QT[80] QT[81] QT[82] QT[83]
+   QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91] QT[92] QT[93] QT[94]
+   QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101] QT[102] QT[103] QT[104]
+   QT[105] QT[106] QT[107] QT[108] QT[109] QT[110] QT[111] QT[112] QT[113]
+   QT[114] QT[115] QT[116] QT[117] QT[118] QT[119] QT[120] QT[121] QT[122]
+   QT[123] QT[124] QT[125] QT[126] QT[127] QT[128] QT[129] QT[130] QT[131]
+   QT[132] QT[133] QT[134] QT[135] QT[136] QT[137] QT[138] QT[139] QT[140]
+   QT[141] QT[142] QT[143] QT[144] QT[145] QT[146] QT[147] QT[148] QT[149]
+   QT[150] QT[151] QT[152] QT[153] QT[154] QT[155] QT[156] QT[157] QT[158]
+   QT[159] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28]
+   VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35] VBN[36] VBN[37]
+   VBN[38] VBN[39] VBN[40] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25] VBP[26]
+   VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32] VBP[33] VBP[34] VBP[35]
+   VBP[36] VBP[37] VBP[38] VBP[39] VBP[40] VDDA[21] VDDA[22] VDDA[23] VDDA[24]
+   VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31] VDDA[32]
+   VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39] VDDA[40]
+   VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2
+   VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2
+   VDDAIR2 VDDAIR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2
+   VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2
+   VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2
+   VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDP[2] VDDPI[21] VDDPI[22] VDDPI[23]
+   VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30]
+   VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36] VDDPI[37]
+   VDDPI[38] VDDPI[39] VDDPI[40] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+   VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34]
+   VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] REWAB[0] REWAB[1] WACKB[1]
+   WAGND[40] WAGND[41] WAGND[42] WAGND[43] WAGND[44] WAGND[45] WAGND[46]
+   WAGND[47] WAGND[48] WAGND[49] WAGND[50] WAGND[51] WAGND[52] WAGND[53]
+   WAGND[54] WAGND[55] WAGND[56] WAGND[57] WAGND[58] WAGND[59] WAGND[60]
+   WAGND[61] WAGND[62] WAGND[63] WAGND[64] WAGND[65] WAGND[66] WAGND[67]
+   WAGND[68] WAGND[69] WAGND[70] WAGND[71] WAGND[72] WAGND[73] WAGND[74]
+   WAGND[75] WAGND[76] WAGND[77] WAGND[78] WAGND[79] WACKB[0] WBI[40] WBI[41]
+   WBI[42] WBI[43] WBI[44] WBI[45] WBI[46] WBI[47] WBI[48] WBI[49] WBI[50]
+   WBI[51] WBI[52] WBI[53] WBI[54] WBI[55] WBI[56] WBI[57] WBI[58] WBI[59]
+   WBI[60] WBI[61] WBI[62] WBI[63] WBI[64] WBI[65] WBI[66] WBI[67] WBI[68]
+   WBI[69] WBI[70] WBI[71] WBI[72] WBI[73] WBI[74] WBI[75] WBI[76] WBI[77]
+   WBI[78] WBI[79] WTI[40] WTI[41] WTI[42] WTI[43] WTI[44] WTI[45] WTI[46]
+   WTI[47] WTI[48] WTI[49] WTI[50] WTI[51] WTI[52] WTI[53] WTI[54] WTI[55]
+   WTI[56] WTI[57] WTI[58] WTI[59] WTI[60] WTI[61] WTI[62] WTI[63] WTI[64]
+   WTI[65] WTI[66] WTI[67] WTI[68] WTI[69] WTI[70] WTI[71] WTI[72] WTI[73]
+   WTI[74] WTI[75] WTI[76] WTI[77] WTI[78] WTI[79]
+   SNPS_RF_DP_UHD_512x80_was_rt_seg1
X_mm17a04_u_hdrf2p_capmux_wa_cm2 VDDP[3] VDDPI[41] VSS[41] VBP[41] VBN[41]
+   WACKB[1] WACKB[1] LOG0[1] LOG1[1] PGIOI VEDGE WACKB[0]
+   mm17a04_u_hdrf2p_capmux_wa
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_was_row ARYSD BADB[0] BADB[1] BADB[2] BADB[3]
+       BADB[4] BADB[5] BADB[6] BADB[7] BADB[8] BADB[9] BADB[10] BADB[11]
+       BADB[12] BADB[13] BADB[14] BADB[15] BADB[16] BADB[17] BADB[18] BADB[19]
+       BADB[20] BADB[21] BADB[22] BADB[23] BADB[24] BADB[25] BADB[26] BADB[27]
+       BADB[28] BADB[29] BADB[30] BADB[31] BADB[32] BADB[33] BADB[34] BADB[35]
+       BADB[36] BADB[37] BADB[38] BADB[39] CENDP CKGATE_RD DEF1_RD DEF1_WR
+       FAST1_RD FAST1_WR FAST2_RD FAST2_WR LIOPD[0] LIOPD[1] LITESLP LOG0 LOG1
+       LRWMEB LXADRBRD[0] LXADRBRD[1] LXADRBRD[2] LXADRBRD[3] LXADRBRD[4]
+       LXADRBRD[5] LXADRBRD[6] LXADRBRD[7] LXADRBWR[0] LXADRBWR[1] LXADRBWR[2]
+       LXADRBWR[3] LXADRBWR[4] LXADRBWR[5] LXADRBWR[6] LXADRBWR[7] LXADRRD[0]
+       LXADRRD[1] LXADRRD[2] LXADRRD[3] LXADRRD[4] LXADRRD[5] LXADRRD[6]
+       LXADRRD[7] LXADRWR[0] LXADRWR[1] LXADRWR[2] LXADRWR[3] LXADRWR[4]
+       LXADRWR[5] LXADRWR[6] LXADRWR[7] LYADRBRD[0] LYADRBRD[1] LYADRBWR[0]
+       LYADRBWR[1] LYADRRD[0] LYADRRD[1] LYADRWR[0] LYADRWR[1] PAARD[0]
+       PAARD[1] PAARD[2] PAARD[3] PAAWR[0] PAAWR[1] PAAWR[2] PAAWR[3] PAWR[0]
+       PAWR[1] PAWR[2] PAWR[3] PBRD[0] PBRD[1] PBRD[2] PBRD[3] PBWR[0] PBWR[1]
+       PBWR[2] PBWR[3] PCRD[0] PCRD[1] PCRD[2] PCRD[3] PCWR[0] PCWR[1] PCWR[2]
+       PCWR[3] PGIOI QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8]
+       QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17] QT[18]
+       QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28]
+       QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38]
+       QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48]
+       QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+       QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68]
+       QT[69] QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78]
+       QT[79] QT[80] QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88]
+       QT[89] QT[90] QT[91] QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98]
+       QT[99] QT[100] QT[101] QT[102] QT[103] QT[104] QT[105] QT[106] QT[107]
+       QT[108] QT[109] QT[110] QT[111] QT[112] QT[113] QT[114] QT[115] QT[116]
+       QT[117] QT[118] QT[119] QT[120] QT[121] QT[122] QT[123] QT[124] QT[125]
+       QT[126] QT[127] QT[128] QT[129] QT[130] QT[131] QT[132] QT[133] QT[134]
+       QT[135] QT[136] QT[137] QT[138] QT[139] QT[140] QT[141] QT[142] QT[143]
+       QT[144] QT[145] QT[146] QT[147] QT[148] QT[149] QT[150] QT[151] QT[152]
+       QT[153] QT[154] QT[155] QT[156] QT[157] QT[158] QT[159] RASSB_H[0]
+       RASSB_H[1] RBLWA RERASSB[0] RERASSB[1] RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] STCLK
+       STRSB T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAIR1 VDDAIR2 VDDAI_SACR1
+       VDDAI_SACR2 VDDF VDDP VDDPI VEDGE VSS WABUF[0] WABUF[1] WABUF[2]
+       WAGND[0] WAGND[1] WAGND[2] WAGND[3] WAGND[4] WAGND[5] WAGND[6] WAGND[7]
+       WAGND[8] WAGND[9] WAGND[10] WAGND[11] WAGND[12] WAGND[13] WAGND[14]
+       WAGND[15] WAGND[16] WAGND[17] WAGND[18] WAGND[19] WAGND[20] WAGND[21]
+       WAGND[22] WAGND[23] WAGND[24] WAGND[25] WAGND[26] WAGND[27] WAGND[28]
+       WAGND[29] WAGND[30] WAGND[31] WAGND[32] WAGND[33] WAGND[34] WAGND[35]
+       WAGND[36] WAGND[37] WAGND[38] WAGND[39] WAGND[40] WAGND[41] WAGND[42]
+       WAGND[43] WAGND[44] WAGND[45] WAGND[46] WAGND[47] WAGND[48] WAGND[49]
+       WAGND[50] WAGND[51] WAGND[52] WAGND[53] WAGND[54] WAGND[55] WAGND[56]
+       WAGND[57] WAGND[58] WAGND[59] WAGND[60] WAGND[61] WAGND[62] WAGND[63]
+       WAGND[64] WAGND[65] WAGND[66] WAGND[67] WAGND[68] WAGND[69] WAGND[70]
+       WAGND[71] WAGND[72] WAGND[73] WAGND[74] WAGND[75] WAGND[76] WAGND[77]
+       WAGND[78] WAGND[79] WAPRCLKB_RET WAPRCLKB_RET_DEL WAPRCLKB_RET_DEL_2
+       WAPRCLKB_RET_DEL_4 WAPRCLKB_RET_LCEN WBI[0] WBI[1] WBI[2] WBI[3] WBI[4]
+       WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13]
+       WBI[14] WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22]
+       WBI[23] WBI[24] WBI[25] WBI[26] WBI[27] WBI[28] WBI[29] WBI[30] WBI[31]
+       WBI[32] WBI[33] WBI[34] WBI[35] WBI[36] WBI[37] WBI[38] WBI[39] WBI[40]
+       WBI[41] WBI[42] WBI[43] WBI[44] WBI[45] WBI[46] WBI[47] WBI[48] WBI[49]
+       WBI[50] WBI[51] WBI[52] WBI[53] WBI[54] WBI[55] WBI[56] WBI[57] WBI[58]
+       WBI[59] WBI[60] WBI[61] WBI[62] WBI[63] WBI[64] WBI[65] WBI[66] WBI[67]
+       WBI[68] WBI[69] WBI[70] WBI[71] WBI[72] WBI[73] WBI[74] WBI[75] WBI[76]
+       WBI[77] WBI[78] WBI[79] WFLOAT WFLT_RET WPBUF[0] WPBUF[1] WPBUF[2]
+       WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9]
+       WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18]
+       WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27]
+       WTI[28] WTI[29] WTI[30] WTI[31] WTI[32] WTI[33] WTI[34] WTI[35] WTI[36]
+       WTI[37] WTI[38] WTI[39] WTI[40] WTI[41] WTI[42] WTI[43] WTI[44] WTI[45]
+       WTI[46] WTI[47] WTI[48] WTI[49] WTI[50] WTI[51] WTI[52] WTI[53] WTI[54]
+       WTI[55] WTI[56] WTI[57] WTI[58] WTI[59] WTI[60] WTI[61] WTI[62] WTI[63]
+       WTI[64] WTI[65] WTI[66] WTI[67] WTI[68] WTI[69] WTI[70] WTI[71] WTI[72]
+       WTI[73] WTI[74] WTI[75] WTI[76] WTI[77] WTI[78] WTI[79] YCOLRD[0]
+       YCOLRD[1] YCOLRD[2] YCOLRD[3] YCOLWR[0] YCOLWR[1] YCOLWR[2] YCOLWR[3]
+       YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]
X_was_cnt ARYSD CENDP CKGATE_RD DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+   FAST2_WR LIOPD[0] LITESLP LOG0 LOG0 LOG1 LRWMEB LXADRBRD[0] LXADRBRD[1]
+   LXADRBRD[2] LXADRBRD[3] LXADRBRD[4] LXADRBRD[5] LXADRBRD[6] LXADRBRD[7]
+   LXADRBWR[0] LXADRBWR[1] LXADRBWR[2] LXADRBWR[3] LXADRBWR[4] LXADRBWR[5]
+   LXADRBWR[6] LXADRBWR[7] LXADRRD[0] LXADRRD[1] LXADRRD[2] LXADRRD[3]
+   LXADRRD[4] LXADRRD[5] LXADRRD[6] LXADRRD[7] LXADRWR[0] LXADRWR[1] LXADRWR[2]
+   LXADRWR[3] LXADRWR[4] LXADRWR[5] LXADRWR[6] LXADRWR[7] LYADRBRD[0]
+   LYADRBRD[1] LYADRBWR[0] LYADRBWR[1] LYADRRD[0] LYADRRD[1] LYADRWR[0]
+   LYADRWR[1] PAARD[0] PAARD[1] PAARD[2] PAARD[3] PAAWR[0] PAAWR[1] PAAWR[2]
+   PAAWR[3] PAWR[0] PAWR[1] PAWR[2] PAWR[3] PBRD[0] PBRD[1] PBRD[2] PBRD[3]
+   PBWR[0] PBWR[1] PBWR[2] PBWR[3] PCRD[0] PCRD[1] PCRD[2] PCRD[3] PCWR[0]
+   PCWR[1] PCWR[2] PCWR[3] RASSB_H[0] RASSB_H[1] RBLWA RFLOAT RFLT_RET RM3CNT
+   RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3]
+   STCLK STRSB T1TRD T1TWR TKEEPB VBN VBN VBN VBP VBP VBP VDDA VDDA VDDA VDDF
+   VDDP VDDP VDDP VDDPI VDDPI VDDPI VSS VSS VSS WABUF[0] WABUF[1] WABUF[2]
+   WAB_H[0] WAB_H[1] WAPCLK WAPRCLKB_RET WAPRCLKB_RET_DEL WAPRCLKB_RET_DEL_2
+   WAPRCLKB_RET_DEL_4 WAPRCLKB_RET_LCEN WFLOAT WFLT_RET WPBUF[0] WPBUF[1]
+   WPBUF[2] YCOLRD[0] YCOLRD[1] YCOLRD[2] YCOLRD[3] YCOLWR[0] YCOLWR[1]
+   YCOLWR[2] YCOLWR[3] YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]
+   SNPS_RF_DP_UHD_512x80_was_cnt
X_was_rt BADB[0] BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7] BADB[8]
+   BADB[9] BADB[10] BADB[11] BADB[12] BADB[13] BADB[14] BADB[15] BADB[16]
+   BADB[17] BADB[18] BADB[19] BADB[20] BADB[21] BADB[22] BADB[23] BADB[24]
+   BADB[25] BADB[26] BADB[27] BADB[28] BADB[29] BADB[30] BADB[31] BADB[32]
+   BADB[33] BADB[34] BADB[35] BADB[36] BADB[37] BADB[38] BADB[39] LIOPD[1] LOG0
+   LOG0 LOG1 PGIOI QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9]
+   QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17] QT[18] QT[19] QT[20]
+   QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28] QT[29] QT[30] QT[31]
+   QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38] QT[39] QT[40] QT[41] QT[42]
+   QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49] QT[50] QT[51] QT[52] QT[53]
+   QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60] QT[61] QT[62] QT[63] QT[64]
+   QT[65] QT[66] QT[67] QT[68] QT[69] QT[70] QT[71] QT[72] QT[73] QT[74] QT[75]
+   QT[76] QT[77] QT[78] QT[79] QT[80] QT[81] QT[82] QT[83] QT[84] QT[85] QT[86]
+   QT[87] QT[88] QT[89] QT[90] QT[91] QT[92] QT[93] QT[94] QT[95] QT[96] QT[97]
+   QT[98] QT[99] QT[100] QT[101] QT[102] QT[103] QT[104] QT[105] QT[106]
+   QT[107] QT[108] QT[109] QT[110] QT[111] QT[112] QT[113] QT[114] QT[115]
+   QT[116] QT[117] QT[118] QT[119] QT[120] QT[121] QT[122] QT[123] QT[124]
+   QT[125] QT[126] QT[127] QT[128] QT[129] QT[130] QT[131] QT[132] QT[133]
+   QT[134] QT[135] QT[136] QT[137] QT[138] QT[139] QT[140] QT[141] QT[142]
+   QT[143] QT[144] QT[145] QT[146] QT[147] QT[148] QT[149] QT[150] QT[151]
+   QT[152] QT[153] QT[154] QT[155] QT[156] QT[157] QT[158] QT[159] RERASSB[0]
+   RERASSB[1] VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP VDDP
+   VDDP VDDP VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VEDGE VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS WAB_H[0]
+   WAB_H[1] WAPRCLKB_RET WAGND[0] WAGND[1] WAGND[2] WAGND[3] WAGND[4] WAGND[5]
+   WAGND[6] WAGND[7] WAGND[8] WAGND[9] WAGND[10] WAGND[11] WAGND[12] WAGND[13]
+   WAGND[14] WAGND[15] WAGND[16] WAGND[17] WAGND[18] WAGND[19] WAGND[20]
+   WAGND[21] WAGND[22] WAGND[23] WAGND[24] WAGND[25] WAGND[26] WAGND[27]
+   WAGND[28] WAGND[29] WAGND[30] WAGND[31] WAGND[32] WAGND[33] WAGND[34]
+   WAGND[35] WAGND[36] WAGND[37] WAGND[38] WAGND[39] WAGND[40] WAGND[41]
+   WAGND[42] WAGND[43] WAGND[44] WAGND[45] WAGND[46] WAGND[47] WAGND[48]
+   WAGND[49] WAGND[50] WAGND[51] WAGND[52] WAGND[53] WAGND[54] WAGND[55]
+   WAGND[56] WAGND[57] WAGND[58] WAGND[59] WAGND[60] WAGND[61] WAGND[62]
+   WAGND[63] WAGND[64] WAGND[65] WAGND[66] WAGND[67] WAGND[68] WAGND[69]
+   WAGND[70] WAGND[71] WAGND[72] WAGND[73] WAGND[74] WAGND[75] WAGND[76]
+   WAGND[77] WAGND[78] WAGND[79] WAPCLK WBI[0] WBI[1] WBI[2] WBI[3] WBI[4]
+   WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14]
+   WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23]
+   WBI[24] WBI[25] WBI[26] WBI[27] WBI[28] WBI[29] WBI[30] WBI[31] WBI[32]
+   WBI[33] WBI[34] WBI[35] WBI[36] WBI[37] WBI[38] WBI[39] WBI[40] WBI[41]
+   WBI[42] WBI[43] WBI[44] WBI[45] WBI[46] WBI[47] WBI[48] WBI[49] WBI[50]
+   WBI[51] WBI[52] WBI[53] WBI[54] WBI[55] WBI[56] WBI[57] WBI[58] WBI[59]
+   WBI[60] WBI[61] WBI[62] WBI[63] WBI[64] WBI[65] WBI[66] WBI[67] WBI[68]
+   WBI[69] WBI[70] WBI[71] WBI[72] WBI[73] WBI[74] WBI[75] WBI[76] WBI[77]
+   WBI[78] WBI[79] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16]
+   WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25]
+   WTI[26] WTI[27] WTI[28] WTI[29] WTI[30] WTI[31] WTI[32] WTI[33] WTI[34]
+   WTI[35] WTI[36] WTI[37] WTI[38] WTI[39] WTI[40] WTI[41] WTI[42] WTI[43]
+   WTI[44] WTI[45] WTI[46] WTI[47] WTI[48] WTI[49] WTI[50] WTI[51] WTI[52]
+   WTI[53] WTI[54] WTI[55] WTI[56] WTI[57] WTI[58] WTI[59] WTI[60] WTI[61]
+   WTI[62] WTI[63] WTI[64] WTI[65] WTI[66] WTI[67] WTI[68] WTI[69] WTI[70]
+   WTI[71] WTI[72] WTI[73] WTI[74] WTI[75] WTI[76] WTI[77] WTI[78] WTI[79]
+   SNPS_RF_DP_UHD_512x80_was_rt
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_mux_cnt ARYSD CENDP CKGATE_RD CKGATE_RLCEN_PROG
+       CLKWLB_RD CLKWLB_RD_HV CLKWLB_RD_prog CLKWLB_WR_HV CLKWLB_WR_prog
+       DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTHBUF LCGTL LCGTV
+       LITESLP LOG0 LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAARD[0] PAARD[1]
+       PAARD[2] PAARD[3] PAAWR[0] PAAWR[1] PAAWR[2] PAAWR[3] PAWR[0] PAWR[1]
+       PAWR[2] PAWR[3] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3] PBRD[0] PBRD[1]
+       PBRD[2] PBRD[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWR[0] PBWR[1]
+       PBWR[2] PBWR[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3] PCRD[0] PCRD[1]
+       PCRD[2] PCRD[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWR[0] PCWR[1]
+       PCWR[2] PCWR[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3] PRCHRD PRCHWR
+       RASSB_H[0] RASSB_H[1] RBLWA RDBL RFLOAT RFLOAT_RLCEN_PROG RFLT_RET
+       RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2]
+       RMTWR[3] STCLK STCLK_WR_RST_PGM STRSB T1TRD T1TWR TKEEPB VBN[0] VBN[1]
+       VBN[2] VBP[0] VBP[1] VBP[2] VDDA[0] VDDA[1] VDDA[2] VDDAPI VDDF VDDP[0]
+       VDDP[1] VDDP[2] VDDPI[0] VDDPI[1] VDDPI[2] VDDWL_RD VDDWL_WR VSS[0]
+       VSS[1] VSS[2] VSSWL WABUF WAPRCLKB_RET_LCEN WCLKRD[0] WCLKRD[1]
+       WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT
+       WFLT_DEL_A WFLT_DEL_B WFLT_RET WPSGT_H[0] WPSGT_H[1] WPSGT_H[2]
+       WPSGT_H[3] YCOLWR[0] YCOLWR[1] YCOLWR[2] YCOLWR[3] YSELRD[0] YSELRD[1]
+       YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: CKGATE_RLCEN_PROG LOG0
* Jumper: CLKWLB_RD CLKWLB_RD_prog
* Jumper: DLY_WRTIMER DLY_WRTIMER_0
* Jumper: LOG1 RFLOAT_RLCEN_PROG CLPSEBUFB
* Jumper: PAARD[0] PAARD_prog[0]
* Jumper: PAARD[1] PAARD_prog[1]
* Jumper: PAARD[2] PAARD_prog[2]
* Jumper: PAARD[3] PAARD_prog[3]
* Jumper: PAAWR[0] PAAWR_prog[0]
* Jumper: PAAWR[1] PAAWR_prog[1]
* Jumper: PAAWR[2] PAAWR_prog[2]
* Jumper: PAAWR[3] PAAWR_prog[3]
* Jumper: PRCLKWRB_PGM PRCLKWRB_R
* Jumper: RFLT_RET OPT_RET
* Jumper: STCLK_WR_RST_PGM WFLT_DEL_B
* Jumper: VDDA[1] VDDF VDDP[1] VDDPI[1]
* Jumper: VDDA[2] VDDP[2] VDDPI[2]
* Jumper: WFLOAT CLKWLB_WR_prog
* Jumper: YCOLWR[0] OPT_Y[0] OPT_Y[2]
* Jumper: YCOLWR[1] OPT_Y[1] OPT_Y[3]

*X_mm17a04_u_hdrf2p_lcen_edgel VDDA[0] VDDP[0] VDDPI[0] VSS[0] VBP[0] VBN[0]
*+  mm17a04_u_hdrf2p_lcen_edgel
X_mm17a04_u_hdrf2p_lcen VDDA[1] VDDAPI VDDF VDDP[1] VDDPI[1] VSS[1] VSSWL VBP[1]
+   VBN[1] CLKWLB_RD CLKWLB_RD_HV CLKWLB_WR_HV LCGTL RFLT_RET PAWRB[0] PAWRB[1]
+   PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1]
+   PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1]
+   PCWRB[2] PCWRB[3] PRCLKRDB_L PRCLKRDB_R PRCLKWRB_L PRCLKWRB_PGM WCLKRD[0]
+   WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2] WCLKWR[3]
+   WFLT_DEL_A WFLT_DEL_B WFLT_RET STCLK YSELWR_L[0] YSELWR_L[1] YSELWR_L[2]
+   YSELWR_L[3] YSELWR_R[0] YSELWR_R[1] YSELWR_R[2] YSELWR_R[3] ARYSD CENDP LOG1
+   DEF1_RD DEF1_WR DLY_WRTIMER DLY_WRTIMER DLY_WRTIMER_4 FAST1_RD FAST1_WR
+   FAST2_RD FAST2_WR LOG0 LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] RBLWA RDBL
+   RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1]
+   RMTWR[2] RMTWR[3] T1TRD T1TWR TKEEPB WFLOAT YSELRD[0] YSELRD[1] YSELRD[2]
+   YSELRD[3] CKGATE_RD CKGATE_RLCEN_PROG CLKWLB_RD_prog CLKWLB_WR_prog LITESLP
+   YCOLWR[0] YCOLWR[1] YCOLWR[0] YCOLWR[1] PAARD[0] PAARD[1] PAARD[2] PAARD[3]
+   PAARD_HV[0] PAARD_HV[1] PAARD_HV[2] PAARD_HV[3] PAARD[0] PAARD[1] PAARD[2]
+   PAARD[3] PAAWR[0] PAAWR[1] PAAWR[2] PAAWR[3] PAAWR_HV[0] PAAWR_HV[1]
+   PAAWR_HV[2] PAAWR_HV[3] PAAWR[0] PAAWR[1] PAAWR[2] PAAWR[3] PAWR[0] PAWR[1]
+   PAWR[2] PAWR[3] PBRD[0] PBRD[1] PBRD[2] PBRD[3] PBWR[0] PBWR[1] PBWR[2]
+   PBWR[3] PCRD[0] PCRD[1] PCRD[2] PCRD[3] PCWR[0] PCWR[1] PCWR[2] PCWR[3]
+   RFLOAT_RLCEN_PROG STCLK_WR_RST_PGM STRSB WABUF WAPRCLKB_RET_LCEN WDBL
+   YCOLWR[0] YCOLWR[1] YCOLWR[2] YCOLWR[3] mm17a04_u_hdrf2p_lcen
X_mm17a04_u_hdrf2p_lcenbuf VDDA[2] VDDP[2] VDDPI[2] VDDWL_RD VDDWL_WR VSS[2]
+   VBP[2] VBN[2] LCGTHBUF LCGTVB PRCHRD PRCHWR PRCLKWRB_DLY2 PRCLKWRB_DLY4
+   WPSGT_H[0] WPSGT_H[1] WPSGT_H[2] WPSGT_H[3] LCGTV LOG1 RASSB_H[0] RASSB_H[1]
+   LCGTL PRCLKRDB_R PRCLKWRB_PGM PRCLKWRB_PGM YSELWR_R[0] YSELWR_R[1]
+   YSELWR_R[2] YSELWR_R[3] mm17a04_u_hdrf2p_lcenbuf
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_mux_rt_seg1 LCGTHBUF LOG1 PRCHRD PRCHWR QT[0]
+       QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11]
+       QT[12] QT[13] QT[14] QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21]
+       QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28] QT[29] QT[30] QT[31]
+       QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38] QT[39] QT[40] QT[41]
+       QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49] QT[50] QT[51]
+       QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60] QT[61]
+       QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70] QT[71]
+       QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] VBN[0] VBN[1]
+       VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11]
+       VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBP[0]
+       VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10]
+       VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19]
+       VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8]
+       VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16]
+       VDDA[17] VDDA[18] VDDA[19] VDDAI[0] VDDAI[1] VDDAI[2] VDDAI[3] VDDAI[4]
+       VDDAI[5] VDDAI[6] VDDAI[7] VDDAI[8] VDDAI[9] VDDAI[10] VDDAI[11]
+       VDDAI[12] VDDAI[13] VDDAI[14] VDDAI[15] VDDAI[16] VDDAI[17] VDDAI[18]
+       VDDAI[19] VDDAI_SAC[0] VDDAI_SAC[1] VDDAI_SAC[2] VDDAI_SAC[3]
+       VDDAI_SAC[4] VDDAI_SAC[5] VDDAI_SAC[6] VDDAI_SAC[7] VDDAI_SAC[8]
+       VDDAI_SAC[9] VDDAI_SAC[10] VDDAI_SAC[11] VDDAI_SAC[12] VDDAI_SAC[13]
+       VDDAI_SAC[14] VDDAI_SAC[15] VDDAI_SAC[16] VDDAI_SAC[17] VDDAI_SAC[18]
+       VDDAI_SAC[19] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6]
+       VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14]
+       VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDPI[0] VDDPI[1] VDDPI[2]
+       VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+       VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17]
+       VDDPI[18] VDDPI[19] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6]
+       VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15]
+       VSS[16] VSS[17] VSS[18] VSS[19] WAGND[0] WAGND[1] WAGND[2] WAGND[3]
+       WAGND[4] WAGND[5] WAGND[6] WAGND[7] WAGND[8] WAGND[9] WAGND[10]
+       WAGND[11] WAGND[12] WAGND[13] WAGND[14] WAGND[15] WAGND[16] WAGND[17]
+       WAGND[18] WAGND[19] WAGND[20] WAGND[21] WAGND[22] WAGND[23] WAGND[24]
+       WAGND[25] WAGND[26] WAGND[27] WAGND[28] WAGND[29] WAGND[30] WAGND[31]
+       WAGND[32] WAGND[33] WAGND[34] WAGND[35] WAGND[36] WAGND[37] WAGND[38]
+       WAGND[39] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8]
+       WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17]
+       WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26]
+       WBI[27] WBI[28] WBI[29] WBI[30] WBI[31] WBI[32] WBI[33] WBI[34] WBI[35]
+       WBI[36] WBI[37] WBI[38] WBI[39] WBLB[0] WBLB[1] WBLB[2] WBLB[3] WBLB[4]
+       WBLB[5] WBLB[6] WBLB[7] WBLB[8] WBLB[9] WBLB[10] WBLB[11] WBLB[12]
+       WBLB[13] WBLB[14] WBLB[15] WBLB[16] WBLB[17] WBLB[18] WBLB[19] WBLB[20]
+       WBLB[21] WBLB[22] WBLB[23] WBLB[24] WBLB[25] WBLB[26] WBLB[27] WBLB[28]
+       WBLB[29] WBLB[30] WBLB[31] WBLB[32] WBLB[33] WBLB[34] WBLB[35] WBLB[36]
+       WBLB[37] WBLB[38] WBLB[39] WBLB[40] WBLB[41] WBLB[42] WBLB[43] WBLB[44]
+       WBLB[45] WBLB[46] WBLB[47] WBLB[48] WBLB[49] WBLB[50] WBLB[51] WBLB[52]
+       WBLB[53] WBLB[54] WBLB[55] WBLB[56] WBLB[57] WBLB[58] WBLB[59] WBLB[60]
+       WBLB[61] WBLB[62] WBLB[63] WBLB[64] WBLB[65] WBLB[66] WBLB[67] WBLB[68]
+       WBLB[69] WBLB[70] WBLB[71] WBLB[72] WBLB[73] WBLB[74] WBLB[75] WBLB[76]
+       WBLB[77] WBLB[78] WBLB[79] WBLT[0] WBLT[1] WBLT[2] WBLT[3] WBLT[4]
+       WBLT[5] WBLT[6] WBLT[7] WBLT[8] WBLT[9] WBLT[10] WBLT[11] WBLT[12]
+       WBLT[13] WBLT[14] WBLT[15] WBLT[16] WBLT[17] WBLT[18] WBLT[19] WBLT[20]
+       WBLT[21] WBLT[22] WBLT[23] WBLT[24] WBLT[25] WBLT[26] WBLT[27] WBLT[28]
+       WBLT[29] WBLT[30] WBLT[31] WBLT[32] WBLT[33] WBLT[34] WBLT[35] WBLT[36]
+       WBLT[37] WBLT[38] WBLT[39] WBLT[40] WBLT[41] WBLT[42] WBLT[43] WBLT[44]
+       WBLT[45] WBLT[46] WBLT[47] WBLT[48] WBLT[49] WBLT[50] WBLT[51] WBLT[52]
+       WBLT[53] WBLT[54] WBLT[55] WBLT[56] WBLT[57] WBLT[58] WBLT[59] WBLT[60]
+       WBLT[61] WBLT[62] WBLT[63] WBLT[64] WBLT[65] WBLT[66] WBLT[67] WBLT[68]
+       WBLT[69] WBLT[70] WBLT[71] WBLT[72] WBLT[73] WBLT[74] WBLT[75] WBLT[76]
+       WBLT[77] WBLT[78] WBLT[79] WPSGT[0] WPSGT[1] WPSGT[2] WPSGT[3] WTI[0]
+       WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10]
+       WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19]
+       WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27] WTI[28]
+       WTI[29] WTI[30] WTI[31] WTI[32] WTI[33] WTI[34] WTI[35] WTI[36] WTI[37]
+       WTI[38] WTI[39]

*** Jumper Report ***
* Jumper: VDDA[0] VDDP[0] VDDPI[0]
* Jumper: VDDA[1] VDDP[1] VDDPI[1]
* Jumper: VDDA[2] VDDP[2] VDDPI[2]
* Jumper: VDDA[3] VDDP[3] VDDPI[3]
* Jumper: VDDA[4] VDDP[4] VDDPI[4]
* Jumper: VDDA[5] VDDP[5] VDDPI[5]
* Jumper: VDDA[6] VDDP[6] VDDPI[6]
* Jumper: VDDA[7] VDDP[7] VDDPI[7]
* Jumper: VDDA[8] VDDP[8] VDDPI[8]
* Jumper: VDDA[9] VDDP[9] VDDPI[9]
* Jumper: VDDA[10] VDDP[10] VDDPI[10]
* Jumper: VDDA[11] VDDP[11] VDDPI[11]
* Jumper: VDDA[12] VDDP[12] VDDPI[12]
* Jumper: VDDA[13] VDDP[13] VDDPI[13]
* Jumper: VDDA[14] VDDP[14] VDDPI[14]
* Jumper: VDDA[15] VDDP[15] VDDPI[15]
* Jumper: VDDA[16] VDDP[16] VDDPI[16]
* Jumper: VDDA[17] VDDP[17] VDDPI[17]
* Jumper: VDDA[18] VDDP[18] VDDPI[18]
* Jumper: VDDA[19] VDDP[19] VDDPI[19]

X_mm17a04_u_hdrf2p_wr_cmux2x2_S0 VDDA[0] VDDAI[0] VDDAI_SAC[0] VDDP[0] VDDPI[0]
+   VSS[0] VBP[0] VBN[0] BADB[0] LCGTHBUF LOG1 QT[0] QT[1] QT[2] QT[3] WAGND[0]
+   WAGND[1] WBLB[0] WBLB[1] WBLB[2] WBLB[3] WBLT[0] WBLT[1] WBLT[2] WBLT[3]
+   PRCHRD PRCHWR WBI[0] WBI[1] WPSGT[0] WPSGT[1] WPSGT[2] WPSGT[3] WTI[0]
+   WTI[1] mm17a04_u_hdrf2p_wr_cmux2x2
X_mm17a04_u_hdrf2p_wr_cmux2x2_S1 VDDA[1] VDDAI[1] VDDAI_SAC[1] VDDP[1] VDDPI[1]
+   VSS[1] VBP[1] VBN[1] BADB[1] LCGTHBUF LOG1 QT[4] QT[5] QT[6] QT[7] WAGND[2]
+   WAGND[3] WBLB[4] WBLB[5] WBLB[6] WBLB[7] WBLT[4] WBLT[5] WBLT[6] WBLT[7]
+   PRCHRD PRCHWR WBI[2] WBI[3] WPSGT[0] WPSGT[1] WPSGT[2] WPSGT[3] WTI[2]
+   WTI[3] mm17a04_u_hdrf2p_wr_cmux2x2
X_mm17a04_u_hdrf2p_wr_cmux2x2_S2 VDDA[2] VDDAI[2] VDDAI_SAC[2] VDDP[2] VDDPI[2]
+   VSS[2] VBP[2] VBN[2] BADB[2] LCGTHBUF LOG1 QT[8] QT[9] QT[10] QT[11]
+   WAGND[4] WAGND[5] WBLB[8] WBLB[9] WBLB[10] WBLB[11] WBLT[8] WBLT[9] WBLT[10]
+   WBLT[11] PRCHRD PRCHWR WBI[4] WBI[5] WPSGT[0] WPSGT[1] WPSGT[2] WPSGT[3]
+   WTI[4] WTI[5] mm17a04_u_hdrf2p_wr_cmux2x2
X_mm17a04_u_hdrf2p_wr_cmux2x2_S3 VDDA[3] VDDAI[3] VDDAI_SAC[3] VDDP[3] VDDPI[3]
+   VSS[3] VBP[3] VBN[3] BADB[3] LCGTHBUF LOG1 QT[12] QT[13] QT[14] QT[15]
+   WAGND[6] WAGND[7] WBLB[12] WBLB[13] WBLB[14] WBLB[15] WBLT[12] WBLT[13]
+   WBLT[14] WBLT[15] PRCHRD PRCHWR WBI[6] WBI[7] WPSGT[0] WPSGT[1] WPSGT[2]
+   WPSGT[3] WTI[6] WTI[7] mm17a04_u_hdrf2p_wr_cmux2x2
X_mm17a04_u_hdrf2p_wr_cmux2x2_S4 VDDA[4] VDDAI[4] VDDAI_SAC[4] VDDP[4] VDDPI[4]
+   VSS[4] VBP[4] VBN[4] BADB[4] LCGTHBUF LOG1 QT[16] QT[17] QT[18] QT[19]
+   WAGND[8] WAGND[9] WBLB[16] WBLB[17] WBLB[18] WBLB[19] WBLT[16] WBLT[17]
+   WBLT[18] WBLT[19] PRCHRD PRCHWR WBI[8] WBI[9] WPSGT[0] WPSGT[1] WPSGT[2]
+   WPSGT[3] WTI[8] WTI[9] mm17a04_u_hdrf2p_wr_cmux2x2
X_mm17a04_u_hdrf2p_wr_cmux2x2_S5 VDDA[5] VDDAI[5] VDDAI_SAC[5] VDDP[5] VDDPI[5]
+   VSS[5] VBP[5] VBN[5] BADB[5] LCGTHBUF LOG1 QT[20] QT[21] QT[22] QT[23]
+   WAGND[10] WAGND[11] WBLB[20] WBLB[21] WBLB[22] WBLB[23] WBLT[20] WBLT[21]
+   WBLT[22] WBLT[23] PRCHRD PRCHWR WBI[10] WBI[11] WPSGT[0] WPSGT[1] WPSGT[2]
+   WPSGT[3] WTI[10] WTI[11] mm17a04_u_hdrf2p_wr_cmux2x2
X_mm17a04_u_hdrf2p_wr_cmux2x2_S6 VDDA[6] VDDAI[6] VDDAI_SAC[6] VDDP[6] VDDPI[6]
+   VSS[6] VBP[6] VBN[6] BADB[6] LCGTHBUF LOG1 QT[24] QT[25] QT[26] QT[27]
+   WAGND[12] WAGND[13] WBLB[24] WBLB[25] WBLB[26] WBLB[27] WBLT[24] WBLT[25]
+   WBLT[26] WBLT[27] PRCHRD PRCHWR WBI[12] WBI[13] WPSGT[0] WPSGT[1] WPSGT[2]
+   WPSGT[3] WTI[12] WTI[13] mm17a04_u_hdrf2p_wr_cmux2x2
X_mm17a04_u_hdrf2p_wr_cmux2x2_S7 VDDA[7] VDDAI[7] VDDAI_SAC[7] VDDP[7] VDDPI[7]
+   VSS[7] VBP[7] VBN[7] BADB[7] LCGTHBUF LOG1 QT[28] QT[29] QT[30] QT[31]
+   WAGND[14] WAGND[15] WBLB[28] WBLB[29] WBLB[30] WBLB[31] WBLT[28] WBLT[29]
+   WBLT[30] WBLT[31] PRCHRD PRCHWR WBI[14] WBI[15] WPSGT[0] WPSGT[1] WPSGT[2]
+   WPSGT[3] WTI[14] WTI[15] mm17a04_u_hdrf2p_wr_cmux2x2
X_mm17a04_u_hdrf2p_wr_cmux2x2_S8 VDDA[8] VDDAI[8] VDDAI_SAC[8] VDDP[8] VDDPI[8]
+   VSS[8] VBP[8] VBN[8] BADB[8] LCGTHBUF LOG1 QT[32] QT[33] QT[34] QT[35]
+   WAGND[16] WAGND[17] WBLB[32] WBLB[33] WBLB[34] WBLB[35] WBLT[32] WBLT[33]
+   WBLT[34] WBLT[35] PRCHRD PRCHWR WBI[16] WBI[17] WPSGT[0] WPSGT[1] WPSGT[2]
+   WPSGT[3] WTI[16] WTI[17] mm17a04_u_hdrf2p_wr_cmux2x2
X_mm17a04_u_hdrf2p_wr_cmux2x2_S9 VDDA[9] VDDAI[9] VDDAI_SAC[9] VDDP[9] VDDPI[9]
+   VSS[9] VBP[9] VBN[9] BADB[9] LCGTHBUF LOG1 QT[36] QT[37] QT[38] QT[39]
+   WAGND[18] WAGND[19] WBLB[36] WBLB[37] WBLB[38] WBLB[39] WBLT[36] WBLT[37]
+   WBLT[38] WBLT[39] PRCHRD PRCHWR WBI[18] WBI[19] WPSGT[0] WPSGT[1] WPSGT[2]
+   WPSGT[3] WTI[18] WTI[19] mm17a04_u_hdrf2p_wr_cmux2x2
X_mm17a04_u_hdrf2p_wr_cmux2x2_F9 VDDA[10] VDDAI[10] VDDAI_SAC[10] VDDP[10]
+   VDDPI[10] VSS[10] VBP[10] VBN[10] BADB[10] LCGTHBUF LOG1 QT[40] QT[41]
+   QT[42] QT[43] WAGND[20] WAGND[21] WBLB[40] WBLB[41] WBLB[42] WBLB[43]
+   WBLT[40] WBLT[41] WBLT[42] WBLT[43] PRCHRD PRCHWR WBI[20] WBI[21] WPSGT[0]
+   WPSGT[1] WPSGT[2] WPSGT[3] WTI[20] WTI[21] mm17a04_u_hdrf2p_wr_cmux2x2
X_mm17a04_u_hdrf2p_wr_cmux2x2_F8 VDDA[11] VDDAI[11] VDDAI_SAC[11] VDDP[11]
+   VDDPI[11] VSS[11] VBP[11] VBN[11] BADB[11] LCGTHBUF LOG1 QT[44] QT[45]
+   QT[46] QT[47] WAGND[22] WAGND[23] WBLB[44] WBLB[45] WBLB[46] WBLB[47]
+   WBLT[44] WBLT[45] WBLT[46] WBLT[47] PRCHRD PRCHWR WBI[22] WBI[23] WPSGT[0]
+   WPSGT[1] WPSGT[2] WPSGT[3] WTI[22] WTI[23] mm17a04_u_hdrf2p_wr_cmux2x2
X_mm17a04_u_hdrf2p_wr_cmux2x2_F7 VDDA[12] VDDAI[12] VDDAI_SAC[12] VDDP[12]
+   VDDPI[12] VSS[12] VBP[12] VBN[12] BADB[12] LCGTHBUF LOG1 QT[48] QT[49]
+   QT[50] QT[51] WAGND[24] WAGND[25] WBLB[48] WBLB[49] WBLB[50] WBLB[51]
+   WBLT[48] WBLT[49] WBLT[50] WBLT[51] PRCHRD PRCHWR WBI[24] WBI[25] WPSGT[0]
+   WPSGT[1] WPSGT[2] WPSGT[3] WTI[24] WTI[25] mm17a04_u_hdrf2p_wr_cmux2x2
X_mm17a04_u_hdrf2p_wr_cmux2x2_F6 VDDA[13] VDDAI[13] VDDAI_SAC[13] VDDP[13]
+   VDDPI[13] VSS[13] VBP[13] VBN[13] BADB[13] LCGTHBUF LOG1 QT[52] QT[53]
+   QT[54] QT[55] WAGND[26] WAGND[27] WBLB[52] WBLB[53] WBLB[54] WBLB[55]
+   WBLT[52] WBLT[53] WBLT[54] WBLT[55] PRCHRD PRCHWR WBI[26] WBI[27] WPSGT[0]
+   WPSGT[1] WPSGT[2] WPSGT[3] WTI[26] WTI[27] mm17a04_u_hdrf2p_wr_cmux2x2
X_mm17a04_u_hdrf2p_wr_cmux2x2_F5 VDDA[14] VDDAI[14] VDDAI_SAC[14] VDDP[14]
+   VDDPI[14] VSS[14] VBP[14] VBN[14] BADB[14] LCGTHBUF LOG1 QT[56] QT[57]
+   QT[58] QT[59] WAGND[28] WAGND[29] WBLB[56] WBLB[57] WBLB[58] WBLB[59]
+   WBLT[56] WBLT[57] WBLT[58] WBLT[59] PRCHRD PRCHWR WBI[28] WBI[29] WPSGT[0]
+   WPSGT[1] WPSGT[2] WPSGT[3] WTI[28] WTI[29] mm17a04_u_hdrf2p_wr_cmux2x2
X_mm17a04_u_hdrf2p_wr_cmux2x2_F4 VDDA[15] VDDAI[15] VDDAI_SAC[15] VDDP[15]
+   VDDPI[15] VSS[15] VBP[15] VBN[15] BADB[15] LCGTHBUF LOG1 QT[60] QT[61]
+   QT[62] QT[63] WAGND[30] WAGND[31] WBLB[60] WBLB[61] WBLB[62] WBLB[63]
+   WBLT[60] WBLT[61] WBLT[62] WBLT[63] PRCHRD PRCHWR WBI[30] WBI[31] WPSGT[0]
+   WPSGT[1] WPSGT[2] WPSGT[3] WTI[30] WTI[31] mm17a04_u_hdrf2p_wr_cmux2x2
X_mm17a04_u_hdrf2p_wr_cmux2x2_F3 VDDA[16] VDDAI[16] VDDAI_SAC[16] VDDP[16]
+   VDDPI[16] VSS[16] VBP[16] VBN[16] BADB[16] LCGTHBUF LOG1 QT[64] QT[65]
+   QT[66] QT[67] WAGND[32] WAGND[33] WBLB[64] WBLB[65] WBLB[66] WBLB[67]
+   WBLT[64] WBLT[65] WBLT[66] WBLT[67] PRCHRD PRCHWR WBI[32] WBI[33] WPSGT[0]
+   WPSGT[1] WPSGT[2] WPSGT[3] WTI[32] WTI[33] mm17a04_u_hdrf2p_wr_cmux2x2
X_mm17a04_u_hdrf2p_wr_cmux2x2_F2 VDDA[17] VDDAI[17] VDDAI_SAC[17] VDDP[17]
+   VDDPI[17] VSS[17] VBP[17] VBN[17] BADB[17] LCGTHBUF LOG1 QT[68] QT[69]
+   QT[70] QT[71] WAGND[34] WAGND[35] WBLB[68] WBLB[69] WBLB[70] WBLB[71]
+   WBLT[68] WBLT[69] WBLT[70] WBLT[71] PRCHRD PRCHWR WBI[34] WBI[35] WPSGT[0]
+   WPSGT[1] WPSGT[2] WPSGT[3] WTI[34] WTI[35] mm17a04_u_hdrf2p_wr_cmux2x2
X_mm17a04_u_hdrf2p_wr_cmux2x2_F1 VDDA[18] VDDAI[18] VDDAI_SAC[18] VDDP[18]
+   VDDPI[18] VSS[18] VBP[18] VBN[18] BADB[18] LCGTHBUF LOG1 QT[72] QT[73]
+   QT[74] QT[75] WAGND[36] WAGND[37] WBLB[72] WBLB[73] WBLB[74] WBLB[75]
+   WBLT[72] WBLT[73] WBLT[74] WBLT[75] PRCHRD PRCHWR WBI[36] WBI[37] WPSGT[0]
+   WPSGT[1] WPSGT[2] WPSGT[3] WTI[36] WTI[37] mm17a04_u_hdrf2p_wr_cmux2x2
X_mm17a04_u_hdrf2p_wr_cmux2x2_F0 VDDA[19] VDDAI[19] VDDAI_SAC[19] VDDP[19]
+   VDDPI[19] VSS[19] VBP[19] VBN[19] BADB[19] LCGTHBUF LOG1 QT[76] QT[77]
+   QT[78] QT[79] WAGND[38] WAGND[39] WBLB[76] WBLB[77] WBLB[78] WBLB[79]
+   WBLT[76] WBLT[77] WBLT[78] WBLT[79] PRCHRD PRCHWR WBI[38] WBI[39] WPSGT[0]
+   WPSGT[1] WPSGT[2] WPSGT[3] WTI[38] WTI[39] mm17a04_u_hdrf2p_wr_cmux2x2
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_mux_rt LCGTHBUF LCGTV LOG0 LOG1[0] LOG1[1] PGIOI
+       PRCHRD PRCHWR QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8]
+       QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17] QT[18]
+       QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28]
+       QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38]
+       QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48]
+       QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+       QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68]
+       QT[69] QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78]
+       QT[79] QT[80] QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88]
+       QT[89] QT[90] QT[91] QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98]
+       QT[99] QT[100] QT[101] QT[102] QT[103] QT[104] QT[105] QT[106] QT[107]
+       QT[108] QT[109] QT[110] QT[111] QT[112] QT[113] QT[114] QT[115] QT[116]
+       QT[117] QT[118] QT[119] QT[120] QT[121] QT[122] QT[123] QT[124] QT[125]
+       QT[126] QT[127] QT[128] QT[129] QT[130] QT[131] QT[132] QT[133] QT[134]
+       QT[135] QT[136] QT[137] QT[138] QT[139] QT[140] QT[141] QT[142] QT[143]
+       QT[144] QT[145] QT[146] QT[147] QT[148] QT[149] QT[150] QT[151] QT[152]
+       QT[153] QT[154] QT[155] QT[156] QT[157] QT[158] QT[159] RERASSB[0]
+       RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7]
+       VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+       VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25]
+       VBN[26] VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34]
+       VBN[35] VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1]
+       VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+       VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20]
+       VBP[21] VBP[22] VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29]
+       VBP[30] VBP[31] VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38]
+       VBP[39] VBP[40] VBP[41] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5]
+       VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13]
+       VDDA[14] VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21]
+       VDDA[22] VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29]
+       VDDA[30] VDDA[31] VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37]
+       VDDA[38] VDDA[39] VDDA[40] VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1
+       VDDAI_SACR2 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6]
+       VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14]
+       VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21] VDDP[22]
+       VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDP[29] VDDP[30]
+       VDDP[31] VDDP[32] VDDP[33] VDDP[34] VDDP[35] VDDP[36] VDDP[37] VDDP[38]
+       VDDP[39] VDDP[40] VDDP[41] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+       VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+       VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18]
+       VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25]
+       VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31] VDDPI[32]
+       VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36] VDDPI[37] VDDPI[38] VDDPI[39]
+       VDDPI[40] VDDPI[41] VDDWL_RD_REBUF VDDWL_WR_REBUF VEDGE VSS[0] VSS[1]
+       VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11]
+       VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] VSS[20]
+       VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28] VSS[29]
+       VSS[30] VSS[31] VSS[32] VSS[33] VSS[34] VSS[35] VSS[36] VSS[37] VSS[38]
+       VSS[39] VSS[40] VSS[41] WAGND[0] WAGND[1] WAGND[2] WAGND[3] WAGND[4]
+       WAGND[5] WAGND[6] WAGND[7] WAGND[8] WAGND[9] WAGND[10] WAGND[11]
+       WAGND[12] WAGND[13] WAGND[14] WAGND[15] WAGND[16] WAGND[17] WAGND[18]
+       WAGND[19] WAGND[20] WAGND[21] WAGND[22] WAGND[23] WAGND[24] WAGND[25]
+       WAGND[26] WAGND[27] WAGND[28] WAGND[29] WAGND[30] WAGND[31] WAGND[32]
+       WAGND[33] WAGND[34] WAGND[35] WAGND[36] WAGND[37] WAGND[38] WAGND[39]
+       WAGND[40] WAGND[41] WAGND[42] WAGND[43] WAGND[44] WAGND[45] WAGND[46]
+       WAGND[47] WAGND[48] WAGND[49] WAGND[50] WAGND[51] WAGND[52] WAGND[53]
+       WAGND[54] WAGND[55] WAGND[56] WAGND[57] WAGND[58] WAGND[59] WAGND[60]
+       WAGND[61] WAGND[62] WAGND[63] WAGND[64] WAGND[65] WAGND[66] WAGND[67]
+       WAGND[68] WAGND[69] WAGND[70] WAGND[71] WAGND[72] WAGND[73] WAGND[74]
+       WAGND[75] WAGND[76] WAGND[77] WAGND[78] WAGND[79] WBI[0] WBI[1] WBI[2]
+       WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12]
+       WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21]
+       WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27] WBI[28] WBI[29] WBI[30]
+       WBI[31] WBI[32] WBI[33] WBI[34] WBI[35] WBI[36] WBI[37] WBI[38] WBI[39]
+       WBI[40] WBI[41] WBI[42] WBI[43] WBI[44] WBI[45] WBI[46] WBI[47] WBI[48]
+       WBI[49] WBI[50] WBI[51] WBI[52] WBI[53] WBI[54] WBI[55] WBI[56] WBI[57]
+       WBI[58] WBI[59] WBI[60] WBI[61] WBI[62] WBI[63] WBI[64] WBI[65] WBI[66]
+       WBI[67] WBI[68] WBI[69] WBI[70] WBI[71] WBI[72] WBI[73] WBI[74] WBI[75]
+       WBI[76] WBI[77] WBI[78] WBI[79] WBLB[0] WBLB[1] WBLB[2] WBLB[3] WBLB[4]
+       WBLB[5] WBLB[6] WBLB[7] WBLB[8] WBLB[9] WBLB[10] WBLB[11] WBLB[12]
+       WBLB[13] WBLB[14] WBLB[15] WBLB[16] WBLB[17] WBLB[18] WBLB[19] WBLB[20]
+       WBLB[21] WBLB[22] WBLB[23] WBLB[24] WBLB[25] WBLB[26] WBLB[27] WBLB[28]
+       WBLB[29] WBLB[30] WBLB[31] WBLB[32] WBLB[33] WBLB[34] WBLB[35] WBLB[36]
+       WBLB[37] WBLB[38] WBLB[39] WBLB[40] WBLB[41] WBLB[42] WBLB[43] WBLB[44]
+       WBLB[45] WBLB[46] WBLB[47] WBLB[48] WBLB[49] WBLB[50] WBLB[51] WBLB[52]
+       WBLB[53] WBLB[54] WBLB[55] WBLB[56] WBLB[57] WBLB[58] WBLB[59] WBLB[60]
+       WBLB[61] WBLB[62] WBLB[63] WBLB[64] WBLB[65] WBLB[66] WBLB[67] WBLB[68]
+       WBLB[69] WBLB[70] WBLB[71] WBLB[72] WBLB[73] WBLB[74] WBLB[75] WBLB[76]
+       WBLB[77] WBLB[78] WBLB[79] WBLB[80] WBLB[81] WBLB[82] WBLB[83] WBLB[84]
+       WBLB[85] WBLB[86] WBLB[87] WBLB[88] WBLB[89] WBLB[90] WBLB[91] WBLB[92]
+       WBLB[93] WBLB[94] WBLB[95] WBLB[96] WBLB[97] WBLB[98] WBLB[99] WBLB[100]
+       WBLB[101] WBLB[102] WBLB[103] WBLB[104] WBLB[105] WBLB[106] WBLB[107]
+       WBLB[108] WBLB[109] WBLB[110] WBLB[111] WBLB[112] WBLB[113] WBLB[114]
+       WBLB[115] WBLB[116] WBLB[117] WBLB[118] WBLB[119] WBLB[120] WBLB[121]
+       WBLB[122] WBLB[123] WBLB[124] WBLB[125] WBLB[126] WBLB[127] WBLB[128]
+       WBLB[129] WBLB[130] WBLB[131] WBLB[132] WBLB[133] WBLB[134] WBLB[135]
+       WBLB[136] WBLB[137] WBLB[138] WBLB[139] WBLB[140] WBLB[141] WBLB[142]
+       WBLB[143] WBLB[144] WBLB[145] WBLB[146] WBLB[147] WBLB[148] WBLB[149]
+       WBLB[150] WBLB[151] WBLB[152] WBLB[153] WBLB[154] WBLB[155] WBLB[156]
+       WBLB[157] WBLB[158] WBLB[159] WBLT[0] WBLT[1] WBLT[2] WBLT[3] WBLT[4]
+       WBLT[5] WBLT[6] WBLT[7] WBLT[8] WBLT[9] WBLT[10] WBLT[11] WBLT[12]
+       WBLT[13] WBLT[14] WBLT[15] WBLT[16] WBLT[17] WBLT[18] WBLT[19] WBLT[20]
+       WBLT[21] WBLT[22] WBLT[23] WBLT[24] WBLT[25] WBLT[26] WBLT[27] WBLT[28]
+       WBLT[29] WBLT[30] WBLT[31] WBLT[32] WBLT[33] WBLT[34] WBLT[35] WBLT[36]
+       WBLT[37] WBLT[38] WBLT[39] WBLT[40] WBLT[41] WBLT[42] WBLT[43] WBLT[44]
+       WBLT[45] WBLT[46] WBLT[47] WBLT[48] WBLT[49] WBLT[50] WBLT[51] WBLT[52]
+       WBLT[53] WBLT[54] WBLT[55] WBLT[56] WBLT[57] WBLT[58] WBLT[59] WBLT[60]
+       WBLT[61] WBLT[62] WBLT[63] WBLT[64] WBLT[65] WBLT[66] WBLT[67] WBLT[68]
+       WBLT[69] WBLT[70] WBLT[71] WBLT[72] WBLT[73] WBLT[74] WBLT[75] WBLT[76]
+       WBLT[77] WBLT[78] WBLT[79] WBLT[80] WBLT[81] WBLT[82] WBLT[83] WBLT[84]
+       WBLT[85] WBLT[86] WBLT[87] WBLT[88] WBLT[89] WBLT[90] WBLT[91] WBLT[92]
+       WBLT[93] WBLT[94] WBLT[95] WBLT[96] WBLT[97] WBLT[98] WBLT[99] WBLT[100]
+       WBLT[101] WBLT[102] WBLT[103] WBLT[104] WBLT[105] WBLT[106] WBLT[107]
+       WBLT[108] WBLT[109] WBLT[110] WBLT[111] WBLT[112] WBLT[113] WBLT[114]
+       WBLT[115] WBLT[116] WBLT[117] WBLT[118] WBLT[119] WBLT[120] WBLT[121]
+       WBLT[122] WBLT[123] WBLT[124] WBLT[125] WBLT[126] WBLT[127] WBLT[128]
+       WBLT[129] WBLT[130] WBLT[131] WBLT[132] WBLT[133] WBLT[134] WBLT[135]
+       WBLT[136] WBLT[137] WBLT[138] WBLT[139] WBLT[140] WBLT[141] WBLT[142]
+       WBLT[143] WBLT[144] WBLT[145] WBLT[146] WBLT[147] WBLT[148] WBLT[149]
+       WBLT[150] WBLT[151] WBLT[152] WBLT[153] WBLT[154] WBLT[155] WBLT[156]
+       WBLT[157] WBLT[158] WBLT[159] WL_VSS WPSGT[0] WPSGT[1] WPSGT[2] WPSGT[3]
+       WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9]
+       WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18]
+       WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27]
+       WTI[28] WTI[29] WTI[30] WTI[31] WTI[32] WTI[33] WTI[34] WTI[35] WTI[36]
+       WTI[37] WTI[38] WTI[39] WTI[40] WTI[41] WTI[42] WTI[43] WTI[44] WTI[45]
+       WTI[46] WTI[47] WTI[48] WTI[49] WTI[50] WTI[51] WTI[52] WTI[53] WTI[54]
+       WTI[55] WTI[56] WTI[57] WTI[58] WTI[59] WTI[60] WTI[61] WTI[62] WTI[63]
+       WTI[64] WTI[65] WTI[66] WTI[67] WTI[68] WTI[69] WTI[70] WTI[71] WTI[72]
+       WTI[73] WTI[74] WTI[75] WTI[76] WTI[77] WTI[78] WTI[79]
X_mux_rt_seg1_S0 LCGTHBUF LOG1[0] PRCHRD PRCHWR QT[0] QT[1] QT[2] QT[3] QT[4]
+   QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15]
+   QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26]
+   QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37]
+   QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48]
+   QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59]
+   QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70]
+   QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] VBN[0] VBN[1]
+   VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11]
+   VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10]
+   VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19]
+   VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8]
+   VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16]
+   VDDA[17] VDDA[18] VDDA[19] VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1
+   VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1
+   VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1
+   VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1
+   VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1
+   VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6]
+   VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+   VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VSS[0] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] WAGND[0] WAGND[1]
+   WAGND[2] WAGND[3] WAGND[4] WAGND[5] WAGND[6] WAGND[7] WAGND[8] WAGND[9]
+   WAGND[10] WAGND[11] WAGND[12] WAGND[13] WAGND[14] WAGND[15] WAGND[16]
+   WAGND[17] WAGND[18] WAGND[19] WAGND[20] WAGND[21] WAGND[22] WAGND[23]
+   WAGND[24] WAGND[25] WAGND[26] WAGND[27] WAGND[28] WAGND[29] WAGND[30]
+   WAGND[31] WAGND[32] WAGND[33] WAGND[34] WAGND[35] WAGND[36] WAGND[37]
+   WAGND[38] WAGND[39] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7]
+   WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16]
+   WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25]
+   WBI[26] WBI[27] WBI[28] WBI[29] WBI[30] WBI[31] WBI[32] WBI[33] WBI[34]
+   WBI[35] WBI[36] WBI[37] WBI[38] WBI[39] WBLB[0] WBLB[1] WBLB[2] WBLB[3]
+   WBLB[4] WBLB[5] WBLB[6] WBLB[7] WBLB[8] WBLB[9] WBLB[10] WBLB[11] WBLB[12]
+   WBLB[13] WBLB[14] WBLB[15] WBLB[16] WBLB[17] WBLB[18] WBLB[19] WBLB[20]
+   WBLB[21] WBLB[22] WBLB[23] WBLB[24] WBLB[25] WBLB[26] WBLB[27] WBLB[28]
+   WBLB[29] WBLB[30] WBLB[31] WBLB[32] WBLB[33] WBLB[34] WBLB[35] WBLB[36]
+   WBLB[37] WBLB[38] WBLB[39] WBLB[40] WBLB[41] WBLB[42] WBLB[43] WBLB[44]
+   WBLB[45] WBLB[46] WBLB[47] WBLB[48] WBLB[49] WBLB[50] WBLB[51] WBLB[52]
+   WBLB[53] WBLB[54] WBLB[55] WBLB[56] WBLB[57] WBLB[58] WBLB[59] WBLB[60]
+   WBLB[61] WBLB[62] WBLB[63] WBLB[64] WBLB[65] WBLB[66] WBLB[67] WBLB[68]
+   WBLB[69] WBLB[70] WBLB[71] WBLB[72] WBLB[73] WBLB[74] WBLB[75] WBLB[76]
+   WBLB[77] WBLB[78] WBLB[79] WBLT[0] WBLT[1] WBLT[2] WBLT[3] WBLT[4] WBLT[5]
+   WBLT[6] WBLT[7] WBLT[8] WBLT[9] WBLT[10] WBLT[11] WBLT[12] WBLT[13] WBLT[14]
+   WBLT[15] WBLT[16] WBLT[17] WBLT[18] WBLT[19] WBLT[20] WBLT[21] WBLT[22]
+   WBLT[23] WBLT[24] WBLT[25] WBLT[26] WBLT[27] WBLT[28] WBLT[29] WBLT[30]
+   WBLT[31] WBLT[32] WBLT[33] WBLT[34] WBLT[35] WBLT[36] WBLT[37] WBLT[38]
+   WBLT[39] WBLT[40] WBLT[41] WBLT[42] WBLT[43] WBLT[44] WBLT[45] WBLT[46]
+   WBLT[47] WBLT[48] WBLT[49] WBLT[50] WBLT[51] WBLT[52] WBLT[53] WBLT[54]
+   WBLT[55] WBLT[56] WBLT[57] WBLT[58] WBLT[59] WBLT[60] WBLT[61] WBLT[62]
+   WBLT[63] WBLT[64] WBLT[65] WBLT[66] WBLT[67] WBLT[68] WBLT[69] WBLT[70]
+   WBLT[71] WBLT[72] WBLT[73] WBLT[74] WBLT[75] WBLT[76] WBLT[77] WBLT[78]
+   WBLT[79] WPSGT[0] WPSGT[1] WPSGT[2] WPSGT[3] WTI[0] WTI[1] WTI[2] WTI[3]
+   WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13]
+   WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22]
+   WTI[23] WTI[24] WTI[25] WTI[26] WTI[27] WTI[28] WTI[29] WTI[30] WTI[31]
+   WTI[32] WTI[33] WTI[34] WTI[35] WTI[36] WTI[37] WTI[38] WTI[39]
+   SNPS_RF_DP_UHD_512x80_mux_rt_seg1
X_mm17a04_u_hdrf2p_lcenrebuf VDDA[20] VDDP[20] VDDPI[20] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VSS[20] VBP[20] VBN[20] RELCGTH REPRCHRD REPRCHWR REWPSGT[0]
+   REWPSGT[1] REWPSGT[2] REWPSGT[3] LCGTV RERASSB[0] RERASSB[1] WL_VSS LCGTHBUF
+   PRCHRD PRCHWR WPSGT[0] WPSGT[1] WPSGT[2] WPSGT[3] mm17a04_u_hdrf2p_lcenrebuf
X_mux_rt_seg1_F0 RELCGTH LOG1[1] REPRCHRD REPRCHWR QT[80] QT[81] QT[82] QT[83]
+   QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91] QT[92] QT[93] QT[94]
+   QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101] QT[102] QT[103] QT[104]
+   QT[105] QT[106] QT[107] QT[108] QT[109] QT[110] QT[111] QT[112] QT[113]
+   QT[114] QT[115] QT[116] QT[117] QT[118] QT[119] QT[120] QT[121] QT[122]
+   QT[123] QT[124] QT[125] QT[126] QT[127] QT[128] QT[129] QT[130] QT[131]
+   QT[132] QT[133] QT[134] QT[135] QT[136] QT[137] QT[138] QT[139] QT[140]
+   QT[141] QT[142] QT[143] QT[144] QT[145] QT[146] QT[147] QT[148] QT[149]
+   QT[150] QT[151] QT[152] QT[153] QT[154] QT[155] QT[156] QT[157] QT[158]
+   QT[159] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28]
+   VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35] VBN[36] VBN[37]
+   VBN[38] VBN[39] VBN[40] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25] VBP[26]
+   VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32] VBP[33] VBP[34] VBP[35]
+   VBP[36] VBP[37] VBP[38] VBP[39] VBP[40] VDDA[21] VDDA[22] VDDA[23] VDDA[24]
+   VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31] VDDA[32]
+   VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39] VDDA[40]
+   VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2
+   VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2
+   VDDAIR2 VDDAIR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2
+   VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2
+   VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2
+   VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDP[21] VDDP[22] VDDP[23] VDDP[24]
+   VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32]
+   VDDP[33] VDDP[34] VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40]
+   VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27]
+   VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34]
+   VDDPI[35] VDDPI[36] VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VSS[21] VSS[22]
+   VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31]
+   VSS[32] VSS[33] VSS[34] VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40]
+   WAGND[40] WAGND[41] WAGND[42] WAGND[43] WAGND[44] WAGND[45] WAGND[46]
+   WAGND[47] WAGND[48] WAGND[49] WAGND[50] WAGND[51] WAGND[52] WAGND[53]
+   WAGND[54] WAGND[55] WAGND[56] WAGND[57] WAGND[58] WAGND[59] WAGND[60]
+   WAGND[61] WAGND[62] WAGND[63] WAGND[64] WAGND[65] WAGND[66] WAGND[67]
+   WAGND[68] WAGND[69] WAGND[70] WAGND[71] WAGND[72] WAGND[73] WAGND[74]
+   WAGND[75] WAGND[76] WAGND[77] WAGND[78] WAGND[79] WBI[40] WBI[41] WBI[42]
+   WBI[43] WBI[44] WBI[45] WBI[46] WBI[47] WBI[48] WBI[49] WBI[50] WBI[51]
+   WBI[52] WBI[53] WBI[54] WBI[55] WBI[56] WBI[57] WBI[58] WBI[59] WBI[60]
+   WBI[61] WBI[62] WBI[63] WBI[64] WBI[65] WBI[66] WBI[67] WBI[68] WBI[69]
+   WBI[70] WBI[71] WBI[72] WBI[73] WBI[74] WBI[75] WBI[76] WBI[77] WBI[78]
+   WBI[79] WBLB[80] WBLB[81] WBLB[82] WBLB[83] WBLB[84] WBLB[85] WBLB[86]
+   WBLB[87] WBLB[88] WBLB[89] WBLB[90] WBLB[91] WBLB[92] WBLB[93] WBLB[94]
+   WBLB[95] WBLB[96] WBLB[97] WBLB[98] WBLB[99] WBLB[100] WBLB[101] WBLB[102]
+   WBLB[103] WBLB[104] WBLB[105] WBLB[106] WBLB[107] WBLB[108] WBLB[109]
+   WBLB[110] WBLB[111] WBLB[112] WBLB[113] WBLB[114] WBLB[115] WBLB[116]
+   WBLB[117] WBLB[118] WBLB[119] WBLB[120] WBLB[121] WBLB[122] WBLB[123]
+   WBLB[124] WBLB[125] WBLB[126] WBLB[127] WBLB[128] WBLB[129] WBLB[130]
+   WBLB[131] WBLB[132] WBLB[133] WBLB[134] WBLB[135] WBLB[136] WBLB[137]
+   WBLB[138] WBLB[139] WBLB[140] WBLB[141] WBLB[142] WBLB[143] WBLB[144]
+   WBLB[145] WBLB[146] WBLB[147] WBLB[148] WBLB[149] WBLB[150] WBLB[151]
+   WBLB[152] WBLB[153] WBLB[154] WBLB[155] WBLB[156] WBLB[157] WBLB[158]
+   WBLB[159] WBLT[80] WBLT[81] WBLT[82] WBLT[83] WBLT[84] WBLT[85] WBLT[86]
+   WBLT[87] WBLT[88] WBLT[89] WBLT[90] WBLT[91] WBLT[92] WBLT[93] WBLT[94]
+   WBLT[95] WBLT[96] WBLT[97] WBLT[98] WBLT[99] WBLT[100] WBLT[101] WBLT[102]
+   WBLT[103] WBLT[104] WBLT[105] WBLT[106] WBLT[107] WBLT[108] WBLT[109]
+   WBLT[110] WBLT[111] WBLT[112] WBLT[113] WBLT[114] WBLT[115] WBLT[116]
+   WBLT[117] WBLT[118] WBLT[119] WBLT[120] WBLT[121] WBLT[122] WBLT[123]
+   WBLT[124] WBLT[125] WBLT[126] WBLT[127] WBLT[128] WBLT[129] WBLT[130]
+   WBLT[131] WBLT[132] WBLT[133] WBLT[134] WBLT[135] WBLT[136] WBLT[137]
+   WBLT[138] WBLT[139] WBLT[140] WBLT[141] WBLT[142] WBLT[143] WBLT[144]
+   WBLT[145] WBLT[146] WBLT[147] WBLT[148] WBLT[149] WBLT[150] WBLT[151]
+   WBLT[152] WBLT[153] WBLT[154] WBLT[155] WBLT[156] WBLT[157] WBLT[158]
+   WBLT[159] REWPSGT[0] REWPSGT[1] REWPSGT[2] REWPSGT[3] WTI[40] WTI[41]
+   WTI[42] WTI[43] WTI[44] WTI[45] WTI[46] WTI[47] WTI[48] WTI[49] WTI[50]
+   WTI[51] WTI[52] WTI[53] WTI[54] WTI[55] WTI[56] WTI[57] WTI[58] WTI[59]
+   WTI[60] WTI[61] WTI[62] WTI[63] WTI[64] WTI[65] WTI[66] WTI[67] WTI[68]
+   WTI[69] WTI[70] WTI[71] WTI[72] WTI[73] WTI[74] WTI[75] WTI[76] WTI[77]
+   WTI[78] WTI[79] SNPS_RF_DP_UHD_512x80_mux_rt_seg1
*X_mm17a04_u_hdrf2p_capmux VDDA[41] VDDP[41] VDDPI[41] VSS[41] VBP[41] VBN[41]
*+  LOG0 LOG1[1] PGIOI VEDGE mm17a04_u_hdrf2p_capmux
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_mux_row ARYSD CENDP CKGATE_RD CKGATE_RLCEN_PROG
+       CLKWLB_RD CLKWLB_RD_HV CLKWLB_RD_prog CLKWLB_WR_HV CLKWLB_WR_prog
+       DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LCGTV[0]
+       LCGTV[1] LITESLP LOG0[0] LOG0[1] LOG1[0] LOG1[1] LRWMEB LXADRB[0]
+       LXADRB[1] LXADRB[2] PAARD[0] PAARD[1] PAARD[2] PAARD[3] PAAWR[0]
+       PAAWR[1] PAAWR[2] PAAWR[3] PAWR[0] PAWR[1] PAWR[2] PAWR[3] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRD[0] PBRD[1] PBRD[2] PBRD[3] PBRDB[0]
+       PBRDB[1] PBRDB[2] PBRDB[3] PBWR[0] PBWR[1] PBWR[2] PBWR[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRD[0] PCRD[1] PCRD[2] PCRD[3] PCRDB[0]
+       PCRDB[1] PCRDB[2] PCRDB[3] PCWR[0] PCWR[1] PCWR[2] PCWR[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] PGIOI QT[0] QT[1] QT[2] QT[3] QT[4] QT[5]
+       QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16]
+       QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26]
+       QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+       QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46]
+       QT[47] QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56]
+       QT[57] QT[58] QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66]
+       QT[67] QT[68] QT[69] QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76]
+       QT[77] QT[78] QT[79] QT[80] QT[81] QT[82] QT[83] QT[84] QT[85] QT[86]
+       QT[87] QT[88] QT[89] QT[90] QT[91] QT[92] QT[93] QT[94] QT[95] QT[96]
+       QT[97] QT[98] QT[99] QT[100] QT[101] QT[102] QT[103] QT[104] QT[105]
+       QT[106] QT[107] QT[108] QT[109] QT[110] QT[111] QT[112] QT[113] QT[114]
+       QT[115] QT[116] QT[117] QT[118] QT[119] QT[120] QT[121] QT[122] QT[123]
+       QT[124] QT[125] QT[126] QT[127] QT[128] QT[129] QT[130] QT[131] QT[132]
+       QT[133] QT[134] QT[135] QT[136] QT[137] QT[138] QT[139] QT[140] QT[141]
+       QT[142] QT[143] QT[144] QT[145] QT[146] QT[147] QT[148] QT[149] QT[150]
+       QT[151] QT[152] QT[153] QT[154] QT[155] QT[156] QT[157] QT[158] QT[159]
+       RASSB_H[0] RASSB_H[1] RBLWA RDBL RERASSB[0] RERASSB[1] RFLOAT
+       RFLOAT_RLCEN_PROG RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+       RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] STCLK STCLK_WR_RST_PGM STRSB T1TRD
+       T1TWR TKEEPB VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7]
+       VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+       VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25]
+       VBN[26] VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34]
+       VBN[35] VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBN[42] VBN[43]
+       VBN[44] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8]
+       VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VBP[17]
+       VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25] VBP[26]
+       VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32] VBP[33] VBP[34] VBP[35]
+       VBP[36] VBP[37] VBP[38] VBP[39] VBP[40] VBP[41] VBP[42] VBP[43] VBP[44]
+       VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8]
+       VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16]
+       VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24]
+       VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31] VDDA[32]
+       VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39] VDDA[40]
+       VDDA[41] VDDA[42] VDDA[43] VDDA[44] VDDAIR1 VDDAIR2 VDDAI_SACR1
+       VDDAI_SACR2 VDDAPI VDDF VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5]
+       VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+       VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21]
+       VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDP[29]
+       VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34] VDDP[35] VDDP[36] VDDP[37]
+       VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDP[42] VDDP[43] VDDP[44] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+       VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+       VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+       VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+       VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+       VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDPI[42] VDDPI[43]
+       VDDPI[44] VDDWL_RD VDDWL_RD_REBUF VDDWL_WR VDDWL_WR_REBUF VEDGE VSS[0]
+       VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+       VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19]
+       VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28]
+       VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34] VSS[35] VSS[36] VSS[37]
+       VSS[38] VSS[39] VSS[40] VSS[41] VSS[42] VSS[43] VSS[44] VSSWL WABUF
+       WAGND[0] WAGND[1] WAGND[2] WAGND[3] WAGND[4] WAGND[5] WAGND[6] WAGND[7]
+       WAGND[8] WAGND[9] WAGND[10] WAGND[11] WAGND[12] WAGND[13] WAGND[14]
+       WAGND[15] WAGND[16] WAGND[17] WAGND[18] WAGND[19] WAGND[20] WAGND[21]
+       WAGND[22] WAGND[23] WAGND[24] WAGND[25] WAGND[26] WAGND[27] WAGND[28]
+       WAGND[29] WAGND[30] WAGND[31] WAGND[32] WAGND[33] WAGND[34] WAGND[35]
+       WAGND[36] WAGND[37] WAGND[38] WAGND[39] WAGND[40] WAGND[41] WAGND[42]
+       WAGND[43] WAGND[44] WAGND[45] WAGND[46] WAGND[47] WAGND[48] WAGND[49]
+       WAGND[50] WAGND[51] WAGND[52] WAGND[53] WAGND[54] WAGND[55] WAGND[56]
+       WAGND[57] WAGND[58] WAGND[59] WAGND[60] WAGND[61] WAGND[62] WAGND[63]
+       WAGND[64] WAGND[65] WAGND[66] WAGND[67] WAGND[68] WAGND[69] WAGND[70]
+       WAGND[71] WAGND[72] WAGND[73] WAGND[74] WAGND[75] WAGND[76] WAGND[77]
+       WAGND[78] WAGND[79] WAPRCLKB_RET_LCEN WBI[0] WBI[1] WBI[2] WBI[3] WBI[4]
+       WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13]
+       WBI[14] WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22]
+       WBI[23] WBI[24] WBI[25] WBI[26] WBI[27] WBI[28] WBI[29] WBI[30] WBI[31]
+       WBI[32] WBI[33] WBI[34] WBI[35] WBI[36] WBI[37] WBI[38] WBI[39] WBI[40]
+       WBI[41] WBI[42] WBI[43] WBI[44] WBI[45] WBI[46] WBI[47] WBI[48] WBI[49]
+       WBI[50] WBI[51] WBI[52] WBI[53] WBI[54] WBI[55] WBI[56] WBI[57] WBI[58]
+       WBI[59] WBI[60] WBI[61] WBI[62] WBI[63] WBI[64] WBI[65] WBI[66] WBI[67]
+       WBI[68] WBI[69] WBI[70] WBI[71] WBI[72] WBI[73] WBI[74] WBI[75] WBI[76]
+       WBI[77] WBI[78] WBI[79] WBLB[0] WBLB[1] WBLB[2] WBLB[3] WBLB[4] WBLB[5]
+       WBLB[6] WBLB[7] WBLB[8] WBLB[9] WBLB[10] WBLB[11] WBLB[12] WBLB[13]
+       WBLB[14] WBLB[15] WBLB[16] WBLB[17] WBLB[18] WBLB[19] WBLB[20] WBLB[21]
+       WBLB[22] WBLB[23] WBLB[24] WBLB[25] WBLB[26] WBLB[27] WBLB[28] WBLB[29]
+       WBLB[30] WBLB[31] WBLB[32] WBLB[33] WBLB[34] WBLB[35] WBLB[36] WBLB[37]
+       WBLB[38] WBLB[39] WBLB[40] WBLB[41] WBLB[42] WBLB[43] WBLB[44] WBLB[45]
+       WBLB[46] WBLB[47] WBLB[48] WBLB[49] WBLB[50] WBLB[51] WBLB[52] WBLB[53]
+       WBLB[54] WBLB[55] WBLB[56] WBLB[57] WBLB[58] WBLB[59] WBLB[60] WBLB[61]
+       WBLB[62] WBLB[63] WBLB[64] WBLB[65] WBLB[66] WBLB[67] WBLB[68] WBLB[69]
+       WBLB[70] WBLB[71] WBLB[72] WBLB[73] WBLB[74] WBLB[75] WBLB[76] WBLB[77]
+       WBLB[78] WBLB[79] WBLB[80] WBLB[81] WBLB[82] WBLB[83] WBLB[84] WBLB[85]
+       WBLB[86] WBLB[87] WBLB[88] WBLB[89] WBLB[90] WBLB[91] WBLB[92] WBLB[93]
+       WBLB[94] WBLB[95] WBLB[96] WBLB[97] WBLB[98] WBLB[99] WBLB[100]
+       WBLB[101] WBLB[102] WBLB[103] WBLB[104] WBLB[105] WBLB[106] WBLB[107]
+       WBLB[108] WBLB[109] WBLB[110] WBLB[111] WBLB[112] WBLB[113] WBLB[114]
+       WBLB[115] WBLB[116] WBLB[117] WBLB[118] WBLB[119] WBLB[120] WBLB[121]
+       WBLB[122] WBLB[123] WBLB[124] WBLB[125] WBLB[126] WBLB[127] WBLB[128]
+       WBLB[129] WBLB[130] WBLB[131] WBLB[132] WBLB[133] WBLB[134] WBLB[135]
+       WBLB[136] WBLB[137] WBLB[138] WBLB[139] WBLB[140] WBLB[141] WBLB[142]
+       WBLB[143] WBLB[144] WBLB[145] WBLB[146] WBLB[147] WBLB[148] WBLB[149]
+       WBLB[150] WBLB[151] WBLB[152] WBLB[153] WBLB[154] WBLB[155] WBLB[156]
+       WBLB[157] WBLB[158] WBLB[159] WBLT[0] WBLT[1] WBLT[2] WBLT[3] WBLT[4]
+       WBLT[5] WBLT[6] WBLT[7] WBLT[8] WBLT[9] WBLT[10] WBLT[11] WBLT[12]
+       WBLT[13] WBLT[14] WBLT[15] WBLT[16] WBLT[17] WBLT[18] WBLT[19] WBLT[20]
+       WBLT[21] WBLT[22] WBLT[23] WBLT[24] WBLT[25] WBLT[26] WBLT[27] WBLT[28]
+       WBLT[29] WBLT[30] WBLT[31] WBLT[32] WBLT[33] WBLT[34] WBLT[35] WBLT[36]
+       WBLT[37] WBLT[38] WBLT[39] WBLT[40] WBLT[41] WBLT[42] WBLT[43] WBLT[44]
+       WBLT[45] WBLT[46] WBLT[47] WBLT[48] WBLT[49] WBLT[50] WBLT[51] WBLT[52]
+       WBLT[53] WBLT[54] WBLT[55] WBLT[56] WBLT[57] WBLT[58] WBLT[59] WBLT[60]
+       WBLT[61] WBLT[62] WBLT[63] WBLT[64] WBLT[65] WBLT[66] WBLT[67] WBLT[68]
+       WBLT[69] WBLT[70] WBLT[71] WBLT[72] WBLT[73] WBLT[74] WBLT[75] WBLT[76]
+       WBLT[77] WBLT[78] WBLT[79] WBLT[80] WBLT[81] WBLT[82] WBLT[83] WBLT[84]
+       WBLT[85] WBLT[86] WBLT[87] WBLT[88] WBLT[89] WBLT[90] WBLT[91] WBLT[92]
+       WBLT[93] WBLT[94] WBLT[95] WBLT[96] WBLT[97] WBLT[98] WBLT[99] WBLT[100]
+       WBLT[101] WBLT[102] WBLT[103] WBLT[104] WBLT[105] WBLT[106] WBLT[107]
+       WBLT[108] WBLT[109] WBLT[110] WBLT[111] WBLT[112] WBLT[113] WBLT[114]
+       WBLT[115] WBLT[116] WBLT[117] WBLT[118] WBLT[119] WBLT[120] WBLT[121]
+       WBLT[122] WBLT[123] WBLT[124] WBLT[125] WBLT[126] WBLT[127] WBLT[128]
+       WBLT[129] WBLT[130] WBLT[131] WBLT[132] WBLT[133] WBLT[134] WBLT[135]
+       WBLT[136] WBLT[137] WBLT[138] WBLT[139] WBLT[140] WBLT[141] WBLT[142]
+       WBLT[143] WBLT[144] WBLT[145] WBLT[146] WBLT[147] WBLT[148] WBLT[149]
+       WBLT[150] WBLT[151] WBLT[152] WBLT[153] WBLT[154] WBLT[155] WBLT[156]
+       WBLT[157] WBLT[158] WBLT[159] WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3]
+       WCLKWR[0] WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WFLT_DEL_A
+       WFLT_DEL_B WFLT_RET WL_VSS WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+       WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14]
+       WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23]
+       WTI[24] WTI[25] WTI[26] WTI[27] WTI[28] WTI[29] WTI[30] WTI[31] WTI[32]
+       WTI[33] WTI[34] WTI[35] WTI[36] WTI[37] WTI[38] WTI[39] WTI[40] WTI[41]
+       WTI[42] WTI[43] WTI[44] WTI[45] WTI[46] WTI[47] WTI[48] WTI[49] WTI[50]
+       WTI[51] WTI[52] WTI[53] WTI[54] WTI[55] WTI[56] WTI[57] WTI[58] WTI[59]
+       WTI[60] WTI[61] WTI[62] WTI[63] WTI[64] WTI[65] WTI[66] WTI[67] WTI[68]
+       WTI[69] WTI[70] WTI[71] WTI[72] WTI[73] WTI[74] WTI[75] WTI[76] WTI[77]
+       WTI[78] WTI[79] YCOLWR[0] YCOLWR[1] YCOLWR[2] YCOLWR[3] YSELRD[0]
+       YSELRD[1] YSELRD[2] YSELRD[3]
X_mux_cnt ARYSD CENDP CKGATE_RD CKGATE_RLCEN_PROG CLKWLB_RD CLKWLB_RD_HV
+   CLKWLB_RD_prog CLKWLB_WR_HV CLKWLB_WR_prog DEF1_RD DEF1_WR FAST1_RD FAST1_WR
+   FAST2_RD FAST2_WR LCGTHBUF LCGTL LCGTV[0] LITESLP LOG0[0] LOG1[0] LRWMEB
+   LXADRB[0] LXADRB[1] LXADRB[2] PAARD[0] PAARD[1] PAARD[2] PAARD[3] PAAWR[0]
+   PAAWR[1] PAAWR[2] PAAWR[3] PAWR[0] PAWR[1] PAWR[2] PAWR[3] PAWRB[0] PAWRB[1]
+   PAWRB[2] PAWRB[3] PBRD[0] PBRD[1] PBRD[2] PBRD[3] PBRDB[0] PBRDB[1] PBRDB[2]
+   PBRDB[3] PBWR[0] PBWR[1] PBWR[2] PBWR[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRD[0] PCRD[1] PCRD[2] PCRD[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWR[0]
+   PCWR[1] PCWR[2] PCWR[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3] PRCHRD PRCHWR
+   RASSB_H[0] RASSB_H[1] RBLWA RDBL RFLOAT RFLOAT_RLCEN_PROG RFLT_RET RM3CNT
+   RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3]
+   STCLK STCLK_WR_RST_PGM STRSB T1TRD T1TWR TKEEPB VBN[0] VBN[1] VBN[2] VBP[0]
+   VBP[1] VBP[2] VDDA[0] VDDA[1] VDDA[2] VDDAPI VDDF VDDP[0] VDDP[1] VDDP[2]
+   VDDPI[0] VDDPI[1] VDDPI[2] VDDWL_RD VDDWL_WR VSS[0] VSS[1] VSS[2] VSSWL
+   WABUF WAPRCLKB_RET_LCEN WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+   WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WFLT_DEL_A WFLT_DEL_B WFLT_RET
+   WPSGT_H[0] WPSGT_H[1] WPSGT_H[2] WPSGT_H[3] YCOLWR[0] YCOLWR[1] YCOLWR[2]
+   YCOLWR[3] YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]
+   SNPS_RF_DP_UHD_512x80_mux_cnt
X_mux_rt LCGTHBUF LCGTV[1] LOG0[1] LOG1[0] LOG1[1] PGIOI PRCHRD PRCHWR QT[0]
+   QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12]
+   QT[13] QT[14] QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23]
+   QT[24] QT[25] QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34]
+   QT[35] QT[36] QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45]
+   QT[46] QT[47] QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56]
+   QT[57] QT[58] QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67]
+   QT[68] QT[69] QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78]
+   QT[79] QT[80] QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89]
+   QT[90] QT[91] QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99]
+   QT[100] QT[101] QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108]
+   QT[109] QT[110] QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117]
+   QT[118] QT[119] QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126]
+   QT[127] QT[128] QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135]
+   QT[136] QT[137] QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144]
+   QT[145] QT[146] QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153]
+   QT[154] QT[155] QT[156] QT[157] QT[158] QT[159] RERASSB[0] RERASSB[1] VBN[3]
+   VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13]
+   VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22]
+   VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28] VBN[29] VBN[30] VBN[31]
+   VBN[32] VBN[33] VBN[34] VBN[35] VBN[36] VBN[37] VBN[38] VBN[39] VBN[40]
+   VBN[41] VBN[42] VBN[43] VBN[44] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8]
+   VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VBP[17]
+   VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25] VBP[26]
+   VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32] VBP[33] VBP[34] VBP[35]
+   VBP[36] VBP[37] VBP[38] VBP[39] VBP[40] VBP[41] VBP[42] VBP[43] VBP[44]
+   VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11]
+   VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19]
+   VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27]
+   VDDA[28] VDDA[29] VDDA[30] VDDA[31] VDDA[32] VDDA[33] VDDA[34] VDDA[35]
+   VDDA[36] VDDA[37] VDDA[38] VDDA[39] VDDA[40] VDDA[41] VDDA[42] VDDA[43]
+   VDDA[44] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[3] VDDP[4] VDDP[5]
+   VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14]
+   VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21] VDDP[22]
+   VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDP[29] VDDP[30]
+   VDDP[31] VDDP[32] VDDP[33] VDDP[34] VDDP[35] VDDP[36] VDDP[37] VDDP[38]
+   VDDP[39] VDDP[40] VDDP[41] VDDP[42] VDDP[43] VDDP[44] VDDPI[3] VDDPI[4]
+   VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+   VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19]
+   VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26]
+   VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33]
+   VDDPI[34] VDDPI[35] VDDPI[36] VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40]
+   VDDPI[41] VDDPI[42] VDDPI[43] VDDPI[44] VDDWL_RD_REBUF VDDWL_WR_REBUF VEDGE
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+   VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21]
+   VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28] VSS[29] VSS[30]
+   VSS[31] VSS[32] VSS[33] VSS[34] VSS[35] VSS[36] VSS[37] VSS[38] VSS[39]
+   VSS[40] VSS[41] VSS[42] VSS[43] VSS[44] WAGND[0] WAGND[1] WAGND[2] WAGND[3]
+   WAGND[4] WAGND[5] WAGND[6] WAGND[7] WAGND[8] WAGND[9] WAGND[10] WAGND[11]
+   WAGND[12] WAGND[13] WAGND[14] WAGND[15] WAGND[16] WAGND[17] WAGND[18]
+   WAGND[19] WAGND[20] WAGND[21] WAGND[22] WAGND[23] WAGND[24] WAGND[25]
+   WAGND[26] WAGND[27] WAGND[28] WAGND[29] WAGND[30] WAGND[31] WAGND[32]
+   WAGND[33] WAGND[34] WAGND[35] WAGND[36] WAGND[37] WAGND[38] WAGND[39]
+   WAGND[40] WAGND[41] WAGND[42] WAGND[43] WAGND[44] WAGND[45] WAGND[46]
+   WAGND[47] WAGND[48] WAGND[49] WAGND[50] WAGND[51] WAGND[52] WAGND[53]
+   WAGND[54] WAGND[55] WAGND[56] WAGND[57] WAGND[58] WAGND[59] WAGND[60]
+   WAGND[61] WAGND[62] WAGND[63] WAGND[64] WAGND[65] WAGND[66] WAGND[67]
+   WAGND[68] WAGND[69] WAGND[70] WAGND[71] WAGND[72] WAGND[73] WAGND[74]
+   WAGND[75] WAGND[76] WAGND[77] WAGND[78] WAGND[79] WBI[0] WBI[1] WBI[2]
+   WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12]
+   WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21]
+   WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27] WBI[28] WBI[29] WBI[30]
+   WBI[31] WBI[32] WBI[33] WBI[34] WBI[35] WBI[36] WBI[37] WBI[38] WBI[39]
+   WBI[40] WBI[41] WBI[42] WBI[43] WBI[44] WBI[45] WBI[46] WBI[47] WBI[48]
+   WBI[49] WBI[50] WBI[51] WBI[52] WBI[53] WBI[54] WBI[55] WBI[56] WBI[57]
+   WBI[58] WBI[59] WBI[60] WBI[61] WBI[62] WBI[63] WBI[64] WBI[65] WBI[66]
+   WBI[67] WBI[68] WBI[69] WBI[70] WBI[71] WBI[72] WBI[73] WBI[74] WBI[75]
+   WBI[76] WBI[77] WBI[78] WBI[79] WBLB[0] WBLB[1] WBLB[2] WBLB[3] WBLB[4]
+   WBLB[5] WBLB[6] WBLB[7] WBLB[8] WBLB[9] WBLB[10] WBLB[11] WBLB[12] WBLB[13]
+   WBLB[14] WBLB[15] WBLB[16] WBLB[17] WBLB[18] WBLB[19] WBLB[20] WBLB[21]
+   WBLB[22] WBLB[23] WBLB[24] WBLB[25] WBLB[26] WBLB[27] WBLB[28] WBLB[29]
+   WBLB[30] WBLB[31] WBLB[32] WBLB[33] WBLB[34] WBLB[35] WBLB[36] WBLB[37]
+   WBLB[38] WBLB[39] WBLB[40] WBLB[41] WBLB[42] WBLB[43] WBLB[44] WBLB[45]
+   WBLB[46] WBLB[47] WBLB[48] WBLB[49] WBLB[50] WBLB[51] WBLB[52] WBLB[53]
+   WBLB[54] WBLB[55] WBLB[56] WBLB[57] WBLB[58] WBLB[59] WBLB[60] WBLB[61]
+   WBLB[62] WBLB[63] WBLB[64] WBLB[65] WBLB[66] WBLB[67] WBLB[68] WBLB[69]
+   WBLB[70] WBLB[71] WBLB[72] WBLB[73] WBLB[74] WBLB[75] WBLB[76] WBLB[77]
+   WBLB[78] WBLB[79] WBLB[80] WBLB[81] WBLB[82] WBLB[83] WBLB[84] WBLB[85]
+   WBLB[86] WBLB[87] WBLB[88] WBLB[89] WBLB[90] WBLB[91] WBLB[92] WBLB[93]
+   WBLB[94] WBLB[95] WBLB[96] WBLB[97] WBLB[98] WBLB[99] WBLB[100] WBLB[101]
+   WBLB[102] WBLB[103] WBLB[104] WBLB[105] WBLB[106] WBLB[107] WBLB[108]
+   WBLB[109] WBLB[110] WBLB[111] WBLB[112] WBLB[113] WBLB[114] WBLB[115]
+   WBLB[116] WBLB[117] WBLB[118] WBLB[119] WBLB[120] WBLB[121] WBLB[122]
+   WBLB[123] WBLB[124] WBLB[125] WBLB[126] WBLB[127] WBLB[128] WBLB[129]
+   WBLB[130] WBLB[131] WBLB[132] WBLB[133] WBLB[134] WBLB[135] WBLB[136]
+   WBLB[137] WBLB[138] WBLB[139] WBLB[140] WBLB[141] WBLB[142] WBLB[143]
+   WBLB[144] WBLB[145] WBLB[146] WBLB[147] WBLB[148] WBLB[149] WBLB[150]
+   WBLB[151] WBLB[152] WBLB[153] WBLB[154] WBLB[155] WBLB[156] WBLB[157]
+   WBLB[158] WBLB[159] WBLT[0] WBLT[1] WBLT[2] WBLT[3] WBLT[4] WBLT[5] WBLT[6]
+   WBLT[7] WBLT[8] WBLT[9] WBLT[10] WBLT[11] WBLT[12] WBLT[13] WBLT[14]
+   WBLT[15] WBLT[16] WBLT[17] WBLT[18] WBLT[19] WBLT[20] WBLT[21] WBLT[22]
+   WBLT[23] WBLT[24] WBLT[25] WBLT[26] WBLT[27] WBLT[28] WBLT[29] WBLT[30]
+   WBLT[31] WBLT[32] WBLT[33] WBLT[34] WBLT[35] WBLT[36] WBLT[37] WBLT[38]
+   WBLT[39] WBLT[40] WBLT[41] WBLT[42] WBLT[43] WBLT[44] WBLT[45] WBLT[46]
+   WBLT[47] WBLT[48] WBLT[49] WBLT[50] WBLT[51] WBLT[52] WBLT[53] WBLT[54]
+   WBLT[55] WBLT[56] WBLT[57] WBLT[58] WBLT[59] WBLT[60] WBLT[61] WBLT[62]
+   WBLT[63] WBLT[64] WBLT[65] WBLT[66] WBLT[67] WBLT[68] WBLT[69] WBLT[70]
+   WBLT[71] WBLT[72] WBLT[73] WBLT[74] WBLT[75] WBLT[76] WBLT[77] WBLT[78]
+   WBLT[79] WBLT[80] WBLT[81] WBLT[82] WBLT[83] WBLT[84] WBLT[85] WBLT[86]
+   WBLT[87] WBLT[88] WBLT[89] WBLT[90] WBLT[91] WBLT[92] WBLT[93] WBLT[94]
+   WBLT[95] WBLT[96] WBLT[97] WBLT[98] WBLT[99] WBLT[100] WBLT[101] WBLT[102]
+   WBLT[103] WBLT[104] WBLT[105] WBLT[106] WBLT[107] WBLT[108] WBLT[109]
+   WBLT[110] WBLT[111] WBLT[112] WBLT[113] WBLT[114] WBLT[115] WBLT[116]
+   WBLT[117] WBLT[118] WBLT[119] WBLT[120] WBLT[121] WBLT[122] WBLT[123]
+   WBLT[124] WBLT[125] WBLT[126] WBLT[127] WBLT[128] WBLT[129] WBLT[130]
+   WBLT[131] WBLT[132] WBLT[133] WBLT[134] WBLT[135] WBLT[136] WBLT[137]
+   WBLT[138] WBLT[139] WBLT[140] WBLT[141] WBLT[142] WBLT[143] WBLT[144]
+   WBLT[145] WBLT[146] WBLT[147] WBLT[148] WBLT[149] WBLT[150] WBLT[151]
+   WBLT[152] WBLT[153] WBLT[154] WBLT[155] WBLT[156] WBLT[157] WBLT[158]
+   WBLT[159] WL_VSS WPSGT_H[0] WPSGT_H[1] WPSGT_H[2] WPSGT_H[3] WTI[0] WTI[1]
+   WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11]
+   WTI[12] WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20]
+   WTI[21] WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27] WTI[28] WTI[29]
+   WTI[30] WTI[31] WTI[32] WTI[33] WTI[34] WTI[35] WTI[36] WTI[37] WTI[38]
+   WTI[39] WTI[40] WTI[41] WTI[42] WTI[43] WTI[44] WTI[45] WTI[46] WTI[47]
+   WTI[48] WTI[49] WTI[50] WTI[51] WTI[52] WTI[53] WTI[54] WTI[55] WTI[56]
+   WTI[57] WTI[58] WTI[59] WTI[60] WTI[61] WTI[62] WTI[63] WTI[64] WTI[65]
+   WTI[66] WTI[67] WTI[68] WTI[69] WTI[70] WTI[71] WTI[72] WTI[73] WTI[74]
+   WTI[75] WTI[76] WTI[77] WTI[78] WTI[79] SNPS_RF_DP_UHD_512x80_mux_rt
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_sac_cnt ARYSD CENDP DEF1_RD DEF1_WR DMY_EDGE_LT
+       DMY_EDGE_T2_R FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LCGTL_O LCGTV
+       LOG0 LOG1 LRWMEB LXADR[0] LXADR[1] LXADR[2] LXADRB[0] LXADRB[1]
+       LXADRB[2] OPT_RET PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1]
+       PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1]
+       PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3] PLBKADR[0]
+       PLBKADR[1] PLBKADR[2] PLBKADRB PRCHGB_T RASSB_H[0] RASSB_H[1] RBLWA RDBL
+       RFLOAT RFLOAT_H RFLOAT_H_DEL0 RFLOAT_H_DEL2 RFLOAT_H_DEL4 RFLOAT_H_DEL6
+       RFLOAT_H_PGM RFLOAT_PGM RFLT_DEL_A RFLT_DEL_B RFLT_DEL_C RFLT_RET RM3CNT
+       RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3]
+       ROWBKDB ROWBKTB RWLB_RD RWLB_WR STCLK_RD_RST_PGM T1TRD T1TWR TKEEPB
+       TKEEPT_LCGTL VBN[0] VBN[1] VBN[2] VBP[0] VBP[1] VBP[2] VDDA[0] VDDA[1]
+       VDDA[2] VDDAPI VDDF VDDP[0] VDDP[1] VDDP[2] VDDPI[0] VDDPI[1] VDDWL_RD
+       VDDWL_WR VSS[0] VSS[1] VSS[2] VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2]
+       WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WFLOAT_H
+       WFLOAT_H_DEL0 WFLOAT_H_DEL2 WFLOAT_H_DEL4 WFLOAT_H_DEL6 WFLOAT_H_PGM
+       WFLOAT_PGM YSELB_H[0] YSELB_H[1] YSELB_H[2] YSELB_H[3] YSELRD[0]
+       YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: DLY_RDTIMER DLY_RDTIMER_4
* Jumper: LCGTL LCGT_SACTRL_HV
* Jumper: LOG1 CLPSEBUFB
* Jumper: LXADR[0] PLBKADR[0]
* Jumper: LXADRB[0] PLBKADRB
* Jumper: RFLOAT_H_DEL2 RFLOAT_PGM
* Jumper: RFLOAT_H_DEL6 RFLOAT_H_PGM
* Jumper: RFLT_DEL_C STCLK_RD_RST_PGM
* Jumper: VDDA[1] VDDF VDDP[1] VDDPI[0]
* Jumper: VDDA[2] VDDP[2] VDDPI[1]
* Jumper: WFLOAT_H_DEL2 WFLOAT_PGM
* Jumper: WFLOAT_H_DEL4 WFLOAT_H_PGM

*X_mm17a04_u_hdrf2p_sactrl_top_bk1_edgel_rpb128 VDDA[0] VDDP[0] VSS[0] VBP[0]
*+  VBN[0] mm17a04_u_hdrf2p_sactrl_top_bk1_edgel
X_mm17a04_u_hdrf2p_sactrl_top_bk1_rpb128 VDDA[1] VDDAPI VDDF VDDP[1] VDDPI[0]
+   VSS[1] VSSWL VBP[1] VBN[1] LCGTL_O OPT_RET PRCHG_T_L PRCHG_T_R RFLOAT_H
+   RFLOAT_H_DEL0 RFLOAT_H_DEL2 RFLOAT_H_DEL4 RFLOAT_H_DEL6 RFLT_DEL_A
+   RFLT_DEL_B RFLT_DEL_C ROWBKDB ROWBKTB RWLB_RD RWLB_WR WFLOAT_H WFLOAT_H_DEL0
+   WFLOAT_H_DEL2 WFLOAT_H_DEL4 WFLOAT_H_DEL6 YSEL_L[0] YSEL_L[1] YSEL_L[2]
+   YSEL_L[3] YSEL_R[0] YSEL_R[1] YSEL_R[2] YSEL_R[3] ARYSD CENDP DEF1_RD
+   DEF1_WR DLY_RDTIMER DLY_RDTIMER_0 DLY_RDTIMER FAST1_RD FAST1_WR FAST2_RD
+   FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADR[0] LXADR[1] LXADR[2] LXADRB[0]
+   LXADRB[1] LXADRB[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1]
+   PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1]
+   PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT
+   RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1]
+   RMTWR[2] RMTWR[3] T1TRD T1TWR TKEEPB WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3]
+   WCLKWR[0] WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1]
+   YSELRD[2] YSELRD[3] LOG1 LCGTL PLBKADR[0] PLBKADR[1] PLBKADR[2] PLBKADRB
+   RFLOAT_H_PGM RFLOAT_PGM STCLK_RD_RST_PGM WFLOAT_H_PGM WFLOAT_PGM
+   mm17a04_u_hdrf2p_sactrl_top_bk1
X_mm17a04_u_hdrf2p_sacbuf_bk1_rpb128 VDDA[2] VDDP[2] VDDPI[1] VDDWL_RD VDDWL_WR
+   VSS[2] VBP[2] VBN[2] PRCHGB_T TKEEPT_LCGTL YSELB_H[0] YSELB_H[1] YSELB_H[2]
+   YSELB_H[3] DMY_EDGE_LT DMY_EDGE_T2_R LCGTV RASSB_H[0] RASSB_H[1] LCGTL
+   PRCHG_T_R TKEEPB YSEL_R[0] YSEL_R[1] YSEL_R[2] YSEL_R[3]
+   mm17a04_u_hdrf2p_sacbuf_bk1
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_sac_rt_seg1 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4]
+       BAB[5] BAB[6] BAB[7] BAB[8] BAB[9] BAB[10] BAB[11] BAB[12] BAB[13]
+       BAB[14] BAB[15] BAB[16] BAB[17] BAB[18] BAB[19] BAB[20] BAB[21] BAB[22]
+       BAB[23] BAB[24] BAB[25] BAB[26] BAB[27] BAB[28] BAB[29] BAB[30] BAB[31]
+       BAB[32] BAB[33] BAB[34] BAB[35] BAB[36] BAB[37] BAB[38] BAB[39] BAB[40]
+       BAB[41] BAB[42] BAB[43] BAB[44] BAB[45] BAB[46] BAB[47] BAB[48] BAB[49]
+       BAB[50] BAB[51] BAB[52] BAB[53] BAB[54] BAB[55] BAB[56] BAB[57] BAB[58]
+       BAB[59] BAB[60] BAB[61] BAB[62] BAB[63] BAB[64] BAB[65] BAB[66] BAB[67]
+       BAB[68] BAB[69] BAB[70] BAB[71] BAB[72] BAB[73] BAB[74] BAB[75] BAB[76]
+       BAB[77] BAB[78] BAB[79] BAT[0] BAT[1] BAT[2] BAT[3] BAT[4] BAT[5] BAT[6]
+       BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13] BAT[14] BAT[15]
+       BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22] BAT[23] BAT[24]
+       BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31] BAT[32] BAT[33]
+       BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40] BAT[41] BAT[42]
+       BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49] BAT[50] BAT[51]
+       BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58] BAT[59] BAT[60]
+       BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67] BAT[68] BAT[69]
+       BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76] BAT[77] BAT[78]
+       BAT[79] DMY_EDGE_T2[1] DMY_EDGE_T2[20] PRCHGB_T QT[0] QT[1] QT[2] QT[3]
+       QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+       QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24]
+       QT[25] QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34]
+       QT[35] QT[36] QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44]
+       QT[45] QT[46] QT[47] QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54]
+       QT[55] QT[56] QT[57] QT[58] QT[59] QT[60] QT[61] QT[62] QT[63] QT[64]
+       QT[65] QT[66] QT[67] QT[68] QT[69] QT[70] QT[71] QT[72] QT[73] QT[74]
+       QT[75] QT[76] QT[77] QT[78] QT[79] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4]
+       RBL[5] RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13]
+       RBL[14] RBL[15] RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22]
+       RBL[23] RBL[24] RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31]
+       RBL[32] RBL[33] RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40]
+       RBL[41] RBL[42] RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49]
+       RBL[50] RBL[51] RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58]
+       RBL[59] RBL[60] RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67]
+       RBL[68] RBL[69] RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76]
+       RBL[77] RBL[78] RBL[79] TKEEPT_LCGTL VBN[0] VBN[1] VBN[2] VBN[3] VBN[4]
+       VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13]
+       VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBP[0] VBP[1] VBP[2]
+       VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+       VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VDDA[0] VDDA[1]
+       VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10]
+       VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17] VDDA[18]
+       VDDA[19] VDDAI[0] VDDAI[1] VDDAI[2] VDDAI[3] VDDAI[4] VDDAI[5] VDDAI[6]
+       VDDAI[7] VDDAI[8] VDDAI[9] VDDAI[10] VDDAI[11] VDDAI[12] VDDAI[13]
+       VDDAI[14] VDDAI[15] VDDAI[16] VDDAI[17] VDDAI[18] VDDAI[19] VDDAI_SAC[0]
+       VDDAI_SAC[1] VDDAI_SAC[2] VDDAI_SAC[3] VDDAI_SAC[4] VDDAI_SAC[5]
+       VDDAI_SAC[6] VDDAI_SAC[7] VDDAI_SAC[8] VDDAI_SAC[9] VDDAI_SAC[10]
+       VDDAI_SAC[11] VDDAI_SAC[12] VDDAI_SAC[13] VDDAI_SAC[14] VDDAI_SAC[15]
+       VDDAI_SAC[16] VDDAI_SAC[17] VDDAI_SAC[18] VDDAI_SAC[19] VDDP[0] VDDP[1]
+       VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+       VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+       VDDP[19] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6]
+       VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13]
+       VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VSS[0]
+       VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+       VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19]
+       YSELB[0] YSELB[1] YSELB[2] YSELB[3]

*** Jumper Report ***
* Jumper: VDDAI[0] VDDAI_SAC[0] VDDP[0]
* Jumper: VDDAI[1] VDDAI_SAC[1] VDDP[1]
* Jumper: VDDAI[2] VDDAI_SAC[2] VDDP[2]
* Jumper: VDDAI[3] VDDAI_SAC[3] VDDP[3]
* Jumper: VDDAI[4] VDDAI_SAC[4] VDDP[4]
* Jumper: VDDAI[5] VDDAI_SAC[5] VDDP[5]
* Jumper: VDDAI[6] VDDAI_SAC[6] VDDP[6]
* Jumper: VDDAI[7] VDDAI_SAC[7] VDDP[7]
* Jumper: VDDAI[8] VDDAI_SAC[8] VDDP[8]
* Jumper: VDDAI[9] VDDAI_SAC[9] VDDP[9]
* Jumper: VDDAI[10] VDDAI_SAC[10] VDDP[10]
* Jumper: VDDAI[11] VDDAI_SAC[11] VDDP[11]
* Jumper: VDDAI[12] VDDAI_SAC[12] VDDP[12]
* Jumper: VDDAI[13] VDDAI_SAC[13] VDDP[13]
* Jumper: VDDAI[14] VDDAI_SAC[14] VDDP[14]
* Jumper: VDDAI[15] VDDAI_SAC[15] VDDP[15]
* Jumper: VDDAI[16] VDDAI_SAC[16] VDDP[16]
* Jumper: VDDAI[17] VDDAI_SAC[17] VDDP[17]
* Jumper: VDDAI[18] VDDAI_SAC[18] VDDP[18]
* Jumper: VDDAI[19] VDDAI_SAC[19] VDDP[19]

X_mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128_S0 VDDA[0] VDDAI[0] VDDAI_SAC[0] VDDP[0]
+   VDDPI[0] VSS[0] VBP[0] VBN[0] DMY_EDGE_T2[1] DMY_EDGE_T2[0] PRCHGB_T QT[0]
+   QT[1] QT[2] QT[3] RBL[0] RBL[1] RBL[2] RBL[3] TKEEPT_LCGTL BAB[0] BAB[1]
+   BAB[2] BAB[3] BAT[0] BAT[1] BAT[2] BAT[3] YSELB[0] YSELB[1] YSELB[2]
+   YSELB[3] mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128
X_mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128_S1 VDDA[1] VDDAI[1] VDDAI_SAC[1] VDDP[1]
+   VDDPI[1] VSS[1] VBP[1] VBN[1] DMY_EDGE_T2[0] DMY_EDGE_T2[2] PRCHGB_T QT[4]
+   QT[5] QT[6] QT[7] RBL[4] RBL[5] RBL[6] RBL[7] TKEEPT_LCGTL BAB[4] BAB[5]
+   BAB[6] BAB[7] BAT[4] BAT[5] BAT[6] BAT[7] YSELB[0] YSELB[1] YSELB[2]
+   YSELB[3] mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128
X_mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128_S2 VDDA[2] VDDAI[2] VDDAI_SAC[2] VDDP[2]
+   VDDPI[2] VSS[2] VBP[2] VBN[2] DMY_EDGE_T2[2] DMY_EDGE_T2[3] PRCHGB_T QT[8]
+   QT[9] QT[10] QT[11] RBL[8] RBL[9] RBL[10] RBL[11] TKEEPT_LCGTL BAB[8] BAB[9]
+   BAB[10] BAB[11] BAT[8] BAT[9] BAT[10] BAT[11] YSELB[0] YSELB[1] YSELB[2]
+   YSELB[3] mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128
X_mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128_S3 VDDA[3] VDDAI[3] VDDAI_SAC[3] VDDP[3]
+   VDDPI[3] VSS[3] VBP[3] VBN[3] DMY_EDGE_T2[3] DMY_EDGE_T2[4] PRCHGB_T QT[12]
+   QT[13] QT[14] QT[15] RBL[12] RBL[13] RBL[14] RBL[15] TKEEPT_LCGTL BAB[12]
+   BAB[13] BAB[14] BAB[15] BAT[12] BAT[13] BAT[14] BAT[15] YSELB[0] YSELB[1]
+   YSELB[2] YSELB[3] mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128
X_mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128_S4 VDDA[4] VDDAI[4] VDDAI_SAC[4] VDDP[4]
+   VDDPI[4] VSS[4] VBP[4] VBN[4] DMY_EDGE_T2[4] DMY_EDGE_T2[5] PRCHGB_T QT[16]
+   QT[17] QT[18] QT[19] RBL[16] RBL[17] RBL[18] RBL[19] TKEEPT_LCGTL BAB[16]
+   BAB[17] BAB[18] BAB[19] BAT[16] BAT[17] BAT[18] BAT[19] YSELB[0] YSELB[1]
+   YSELB[2] YSELB[3] mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128
X_mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128_S5 VDDA[5] VDDAI[5] VDDAI_SAC[5] VDDP[5]
+   VDDPI[5] VSS[5] VBP[5] VBN[5] DMY_EDGE_T2[5] DMY_EDGE_T2[6] PRCHGB_T QT[20]
+   QT[21] QT[22] QT[23] RBL[20] RBL[21] RBL[22] RBL[23] TKEEPT_LCGTL BAB[20]
+   BAB[21] BAB[22] BAB[23] BAT[20] BAT[21] BAT[22] BAT[23] YSELB[0] YSELB[1]
+   YSELB[2] YSELB[3] mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128
X_mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128_S6 VDDA[6] VDDAI[6] VDDAI_SAC[6] VDDP[6]
+   VDDPI[6] VSS[6] VBP[6] VBN[6] DMY_EDGE_T2[6] DMY_EDGE_T2[7] PRCHGB_T QT[24]
+   QT[25] QT[26] QT[27] RBL[24] RBL[25] RBL[26] RBL[27] TKEEPT_LCGTL BAB[24]
+   BAB[25] BAB[26] BAB[27] BAT[24] BAT[25] BAT[26] BAT[27] YSELB[0] YSELB[1]
+   YSELB[2] YSELB[3] mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128
X_mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128_S7 VDDA[7] VDDAI[7] VDDAI_SAC[7] VDDP[7]
+   VDDPI[7] VSS[7] VBP[7] VBN[7] DMY_EDGE_T2[7] DMY_EDGE_T2[8] PRCHGB_T QT[28]
+   QT[29] QT[30] QT[31] RBL[28] RBL[29] RBL[30] RBL[31] TKEEPT_LCGTL BAB[28]
+   BAB[29] BAB[30] BAB[31] BAT[28] BAT[29] BAT[30] BAT[31] YSELB[0] YSELB[1]
+   YSELB[2] YSELB[3] mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128
X_mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128_S8 VDDA[8] VDDAI[8] VDDAI_SAC[8] VDDP[8]
+   VDDPI[8] VSS[8] VBP[8] VBN[8] DMY_EDGE_T2[8] DMY_EDGE_T2[9] PRCHGB_T QT[32]
+   QT[33] QT[34] QT[35] RBL[32] RBL[33] RBL[34] RBL[35] TKEEPT_LCGTL BAB[32]
+   BAB[33] BAB[34] BAB[35] BAT[32] BAT[33] BAT[34] BAT[35] YSELB[0] YSELB[1]
+   YSELB[2] YSELB[3] mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128
X_mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128_S9 VDDA[9] VDDAI[9] VDDAI_SAC[9] VDDP[9]
+   VDDPI[9] VSS[9] VBP[9] VBN[9] DMY_EDGE_T2[9] DMY_EDGE_T2[10] PRCHGB_T QT[36]
+   QT[37] QT[38] QT[39] RBL[36] RBL[37] RBL[38] RBL[39] TKEEPT_LCGTL BAB[36]
+   BAB[37] BAB[38] BAB[39] BAT[36] BAT[37] BAT[38] BAT[39] YSELB[0] YSELB[1]
+   YSELB[2] YSELB[3] mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128
X_mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128_F9 VDDA[10] VDDAI[10] VDDAI_SAC[10]
+   VDDP[10] VDDPI[10] VSS[10] VBP[10] VBN[10] DMY_EDGE_T2[10] DMY_EDGE_T2[11]
+   PRCHGB_T QT[40] QT[41] QT[42] QT[43] RBL[40] RBL[41] RBL[42] RBL[43]
+   TKEEPT_LCGTL BAB[40] BAB[41] BAB[42] BAB[43] BAT[40] BAT[41] BAT[42] BAT[43]
+   YSELB[0] YSELB[1] YSELB[2] YSELB[3] mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128
X_mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128_F8 VDDA[11] VDDAI[11] VDDAI_SAC[11]
+   VDDP[11] VDDPI[11] VSS[11] VBP[11] VBN[11] DMY_EDGE_T2[11] DMY_EDGE_T2[12]
+   PRCHGB_T QT[44] QT[45] QT[46] QT[47] RBL[44] RBL[45] RBL[46] RBL[47]
+   TKEEPT_LCGTL BAB[44] BAB[45] BAB[46] BAB[47] BAT[44] BAT[45] BAT[46] BAT[47]
+   YSELB[0] YSELB[1] YSELB[2] YSELB[3] mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128
X_mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128_F7 VDDA[12] VDDAI[12] VDDAI_SAC[12]
+   VDDP[12] VDDPI[12] VSS[12] VBP[12] VBN[12] DMY_EDGE_T2[12] DMY_EDGE_T2[13]
+   PRCHGB_T QT[48] QT[49] QT[50] QT[51] RBL[48] RBL[49] RBL[50] RBL[51]
+   TKEEPT_LCGTL BAB[48] BAB[49] BAB[50] BAB[51] BAT[48] BAT[49] BAT[50] BAT[51]
+   YSELB[0] YSELB[1] YSELB[2] YSELB[3] mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128
X_mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128_F6 VDDA[13] VDDAI[13] VDDAI_SAC[13]
+   VDDP[13] VDDPI[13] VSS[13] VBP[13] VBN[13] DMY_EDGE_T2[13] DMY_EDGE_T2[14]
+   PRCHGB_T QT[52] QT[53] QT[54] QT[55] RBL[52] RBL[53] RBL[54] RBL[55]
+   TKEEPT_LCGTL BAB[52] BAB[53] BAB[54] BAB[55] BAT[52] BAT[53] BAT[54] BAT[55]
+   YSELB[0] YSELB[1] YSELB[2] YSELB[3] mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128
X_mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128_F5 VDDA[14] VDDAI[14] VDDAI_SAC[14]
+   VDDP[14] VDDPI[14] VSS[14] VBP[14] VBN[14] DMY_EDGE_T2[14] DMY_EDGE_T2[15]
+   PRCHGB_T QT[56] QT[57] QT[58] QT[59] RBL[56] RBL[57] RBL[58] RBL[59]
+   TKEEPT_LCGTL BAB[56] BAB[57] BAB[58] BAB[59] BAT[56] BAT[57] BAT[58] BAT[59]
+   YSELB[0] YSELB[1] YSELB[2] YSELB[3] mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128
X_mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128_F4 VDDA[15] VDDAI[15] VDDAI_SAC[15]
+   VDDP[15] VDDPI[15] VSS[15] VBP[15] VBN[15] DMY_EDGE_T2[15] DMY_EDGE_T2[16]
+   PRCHGB_T QT[60] QT[61] QT[62] QT[63] RBL[60] RBL[61] RBL[62] RBL[63]
+   TKEEPT_LCGTL BAB[60] BAB[61] BAB[62] BAB[63] BAT[60] BAT[61] BAT[62] BAT[63]
+   YSELB[0] YSELB[1] YSELB[2] YSELB[3] mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128
X_mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128_F3 VDDA[16] VDDAI[16] VDDAI_SAC[16]
+   VDDP[16] VDDPI[16] VSS[16] VBP[16] VBN[16] DMY_EDGE_T2[16] DMY_EDGE_T2[17]
+   PRCHGB_T QT[64] QT[65] QT[66] QT[67] RBL[64] RBL[65] RBL[66] RBL[67]
+   TKEEPT_LCGTL BAB[64] BAB[65] BAB[66] BAB[67] BAT[64] BAT[65] BAT[66] BAT[67]
+   YSELB[0] YSELB[1] YSELB[2] YSELB[3] mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128
X_mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128_F2 VDDA[17] VDDAI[17] VDDAI_SAC[17]
+   VDDP[17] VDDPI[17] VSS[17] VBP[17] VBN[17] DMY_EDGE_T2[17] DMY_EDGE_T2[18]
+   PRCHGB_T QT[68] QT[69] QT[70] QT[71] RBL[68] RBL[69] RBL[70] RBL[71]
+   TKEEPT_LCGTL BAB[68] BAB[69] BAB[70] BAB[71] BAT[68] BAT[69] BAT[70] BAT[71]
+   YSELB[0] YSELB[1] YSELB[2] YSELB[3] mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128
X_mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128_F1 VDDA[18] VDDAI[18] VDDAI_SAC[18]
+   VDDP[18] VDDPI[18] VSS[18] VBP[18] VBN[18] DMY_EDGE_T2[18] DMY_EDGE_T2[19]
+   PRCHGB_T QT[72] QT[73] QT[74] QT[75] RBL[72] RBL[73] RBL[74] RBL[75]
+   TKEEPT_LCGTL BAB[72] BAB[73] BAB[74] BAB[75] BAT[72] BAT[73] BAT[74] BAT[75]
+   YSELB[0] YSELB[1] YSELB[2] YSELB[3] mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128
X_mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128_F0 VDDA[19] VDDAI[19] VDDAI_SAC[19]
+   VDDP[19] VDDPI[19] VSS[19] VBP[19] VBN[19] DMY_EDGE_T2[19] DMY_EDGE_T2[20]
+   PRCHGB_T QT[76] QT[77] QT[78] QT[79] RBL[76] RBL[77] RBL[78] RBL[79]
+   TKEEPT_LCGTL BAB[76] BAB[77] BAB[78] BAB[79] BAT[76] BAT[77] BAT[78] BAT[79]
+   YSELB[0] YSELB[1] YSELB[2] YSELB[3] mm17a04_u_hdrf2p_sacm1x4_bk1_rpb128
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_sac_rt BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5]
+       BAB[6] BAB[7] BAB[8] BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14]
+       BAB[15] BAB[16] BAB[17] BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23]
+       BAB[24] BAB[25] BAB[26] BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32]
+       BAB[33] BAB[34] BAB[35] BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41]
+       BAB[42] BAB[43] BAB[44] BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50]
+       BAB[51] BAB[52] BAB[53] BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59]
+       BAB[60] BAB[61] BAB[62] BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68]
+       BAB[69] BAB[70] BAB[71] BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77]
+       BAB[78] BAB[79] BAB[80] BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86]
+       BAB[87] BAB[88] BAB[89] BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95]
+       BAB[96] BAB[97] BAB[98] BAB[99] BAB[100] BAB[101] BAB[102] BAB[103]
+       BAB[104] BAB[105] BAB[106] BAB[107] BAB[108] BAB[109] BAB[110] BAB[111]
+       BAB[112] BAB[113] BAB[114] BAB[115] BAB[116] BAB[117] BAB[118] BAB[119]
+       BAB[120] BAB[121] BAB[122] BAB[123] BAB[124] BAB[125] BAB[126] BAB[127]
+       BAB[128] BAB[129] BAB[130] BAB[131] BAB[132] BAB[133] BAB[134] BAB[135]
+       BAB[136] BAB[137] BAB[138] BAB[139] BAB[140] BAB[141] BAB[142] BAB[143]
+       BAB[144] BAB[145] BAB[146] BAB[147] BAB[148] BAB[149] BAB[150] BAB[151]
+       BAB[152] BAB[153] BAB[154] BAB[155] BAB[156] BAB[157] BAB[158] BAB[159]
+       BAT[0] BAT[1] BAT[2] BAT[3] BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9]
+       BAT[10] BAT[11] BAT[12] BAT[13] BAT[14] BAT[15] BAT[16] BAT[17] BAT[18]
+       BAT[19] BAT[20] BAT[21] BAT[22] BAT[23] BAT[24] BAT[25] BAT[26] BAT[27]
+       BAT[28] BAT[29] BAT[30] BAT[31] BAT[32] BAT[33] BAT[34] BAT[35] BAT[36]
+       BAT[37] BAT[38] BAT[39] BAT[40] BAT[41] BAT[42] BAT[43] BAT[44] BAT[45]
+       BAT[46] BAT[47] BAT[48] BAT[49] BAT[50] BAT[51] BAT[52] BAT[53] BAT[54]
+       BAT[55] BAT[56] BAT[57] BAT[58] BAT[59] BAT[60] BAT[61] BAT[62] BAT[63]
+       BAT[64] BAT[65] BAT[66] BAT[67] BAT[68] BAT[69] BAT[70] BAT[71] BAT[72]
+       BAT[73] BAT[74] BAT[75] BAT[76] BAT[77] BAT[78] BAT[79] BAT[80] BAT[81]
+       BAT[82] BAT[83] BAT[84] BAT[85] BAT[86] BAT[87] BAT[88] BAT[89] BAT[90]
+       BAT[91] BAT[92] BAT[93] BAT[94] BAT[95] BAT[96] BAT[97] BAT[98] BAT[99]
+       BAT[100] BAT[101] BAT[102] BAT[103] BAT[104] BAT[105] BAT[106] BAT[107]
+       BAT[108] BAT[109] BAT[110] BAT[111] BAT[112] BAT[113] BAT[114] BAT[115]
+       BAT[116] BAT[117] BAT[118] BAT[119] BAT[120] BAT[121] BAT[122] BAT[123]
+       BAT[124] BAT[125] BAT[126] BAT[127] BAT[128] BAT[129] BAT[130] BAT[131]
+       BAT[132] BAT[133] BAT[134] BAT[135] BAT[136] BAT[137] BAT[138] BAT[139]
+       BAT[140] BAT[141] BAT[142] BAT[143] BAT[144] BAT[145] BAT[146] BAT[147]
+       BAT[148] BAT[149] BAT[150] BAT[151] BAT[152] BAT[153] BAT[154] BAT[155]
+       BAT[156] BAT[157] BAT[158] BAT[159] DMY_EDGE_LT DMY_EDGE_RT[0]
+       DMY_EDGE_RT[1] DMY_EDGE_T2[0] LCGTV LOG0 LOG1 PGIOI PRCHGB_T QT[0] QT[1]
+       QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12]
+       QT[13] QT[14] QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22]
+       QT[23] QT[24] QT[25] QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32]
+       QT[33] QT[34] QT[35] QT[36] QT[37] QT[38] QT[39] QT[40] QT[41] QT[42]
+       QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49] QT[50] QT[51] QT[52]
+       QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60] QT[61] QT[62]
+       QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70] QT[71] QT[72]
+       QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80] QT[81] QT[82]
+       QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91] QT[92]
+       QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101] QT[102]
+       QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110] QT[111]
+       QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119] QT[120]
+       QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128] QT[129]
+       QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137] QT[138]
+       QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146] QT[147]
+       QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155] QT[156]
+       QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5] RBL[6]
+       RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+       RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+       RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+       RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+       RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+       RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+       RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+       RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+       RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+       RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+       RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+       RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+       RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+       RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+       RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+       RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+       RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+       RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159]
+       RERASSB[0] RERASSB[1] TKEEPT_LCGTL VBN[0] VBN[1] VBN[2] VBN[3] VBN[4]
+       VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13]
+       VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22]
+       VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28] VBN[29] VBN[30] VBN[31]
+       VBN[32] VBN[33] VBN[34] VBN[35] VBN[36] VBN[37] VBN[38] VBN[39] VBN[40]
+       VBN[41] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8]
+       VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VBP[17]
+       VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25] VBP[26]
+       VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32] VBP[33] VBP[34] VBP[35]
+       VBP[36] VBP[37] VBP[38] VBP[39] VBP[40] VBP[41] VDDA[0] VDDA[1] VDDA[2]
+       VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10]
+       VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17] VDDA[18]
+       VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24] VDDA[25] VDDA[26]
+       VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31] VDDA[32] VDDA[33] VDDA[34]
+       VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39] VDDA[40] VDDAIR1 VDDAIR2
+       VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5]
+       VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+       VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21]
+       VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDP[29]
+       VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34] VDDP[35] VDDP[36] VDDP[37]
+       VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+       VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+       VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17]
+       VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24]
+       VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31]
+       VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36] VDDPI[37] VDDPI[38]
+       VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF VDDWL_WR_REBUF VEDGE VSS[0]
+       VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+       VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19]
+       VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28]
+       VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34] VSS[35] VSS[36] VSS[37]
+       VSS[38] VSS[39] VSS[40] VSS[41] WL_VSS YSELB[0] YSELB[1] YSELB[2]
+       YSELB[3]

*** Jumper Report ***
* Jumper: VDDA[20] VDDP[20] VDDPI[20]

X_sac_rt_seg1_S0 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAT[0]
+   BAT[1] BAT[2] BAT[3] BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10]
+   BAT[11] BAT[12] BAT[13] BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19]
+   BAT[20] BAT[21] BAT[22] BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28]
+   BAT[29] BAT[30] BAT[31] BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37]
+   BAT[38] BAT[39] BAT[40] BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46]
+   BAT[47] BAT[48] BAT[49] BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55]
+   BAT[56] BAT[57] BAT[58] BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64]
+   BAT[65] BAT[66] BAT[67] BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73]
+   BAT[74] BAT[75] BAT[76] BAT[77] BAT[78] BAT[79] DMY_EDGE_T2[0]
+   DMY_EDGE_T2[1] PRCHGB_T QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+   QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17] QT[18]
+   QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28] QT[29]
+   QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38] QT[39] QT[40]
+   QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49] QT[50] QT[51]
+   QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60] QT[61] QT[62]
+   QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70] QT[71] QT[72] QT[73]
+   QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4]
+   RBL[5] RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14]
+   RBL[15] RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23]
+   RBL[24] RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32]
+   RBL[33] RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41]
+   RBL[42] RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50]
+   RBL[51] RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59]
+   RBL[60] RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68]
+   RBL[69] RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77]
+   RBL[78] RBL[79] TKEEPT_LCGTL VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5]
+   VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15]
+   VBN[16] VBN[17] VBN[18] VBN[19] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5]
+   VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15]
+   VBP[16] VBP[17] VBP[18] VBP[19] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4]
+   VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13]
+   VDDA[14] VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDAIR1 VDDAIR1
+   VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1
+   VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1
+   VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1
+   VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1
+   VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1
+   VDDAI_SACR1 VDDAI_SACR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5]
+   VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14]
+   VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDPI[0] VDDPI[1] VDDPI[2]
+   VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+   VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17]
+   VDDPI[18] VDDPI[19] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS[17] VSS[18] VSS[19] YSELB[0] YSELB[1] YSELB[2] YSELB[3]
+   SNPS_RF_DP_UHD_512x80_sac_rt_seg1
X_mm17a04_u_hdrf2p_sacrebuf_bk1_rpb128 VDDA[20] VDDP[20] VDDPI[20]
+   VDDWL_RD_REBUF VDDWL_WR_REBUF VSS[20] VBP[20] VBN[20] REPRCHGB_T
+   RETKEEP_LCGTL REYSELB[0] REYSELB[1] REYSELB[2] REYSELB[3] DMY_EDGE_LT
+   DMY_EDGE_RT[0] DMY_EDGE_T2[1] DMY_EDGE_T2[2] LCGTV RERASSB[0] RERASSB[1]
+   WL_VSS PRCHGB_T TKEEPT_LCGTL YSELB[0] YSELB[1] YSELB[2] YSELB[3]
+   mm17a04_u_hdrf2p_sacrebuf_bk1
X_sac_rt_seg1_F0 BAB[80] BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87]
+   BAB[88] BAB[89] BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96]
+   BAB[97] BAB[98] BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104]
+   BAB[105] BAB[106] BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112]
+   BAB[113] BAB[114] BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120]
+   BAB[121] BAB[122] BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128]
+   BAB[129] BAB[130] BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136]
+   BAB[137] BAB[138] BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144]
+   BAB[145] BAB[146] BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152]
+   BAB[153] BAB[154] BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[80]
+   BAT[81] BAT[82] BAT[83] BAT[84] BAT[85] BAT[86] BAT[87] BAT[88] BAT[89]
+   BAT[90] BAT[91] BAT[92] BAT[93] BAT[94] BAT[95] BAT[96] BAT[97] BAT[98]
+   BAT[99] BAT[100] BAT[101] BAT[102] BAT[103] BAT[104] BAT[105] BAT[106]
+   BAT[107] BAT[108] BAT[109] BAT[110] BAT[111] BAT[112] BAT[113] BAT[114]
+   BAT[115] BAT[116] BAT[117] BAT[118] BAT[119] BAT[120] BAT[121] BAT[122]
+   BAT[123] BAT[124] BAT[125] BAT[126] BAT[127] BAT[128] BAT[129] BAT[130]
+   BAT[131] BAT[132] BAT[133] BAT[134] BAT[135] BAT[136] BAT[137] BAT[138]
+   BAT[139] BAT[140] BAT[141] BAT[142] BAT[143] BAT[144] BAT[145] BAT[146]
+   BAT[147] BAT[148] BAT[149] BAT[150] BAT[151] BAT[152] BAT[153] BAT[154]
+   BAT[155] BAT[156] BAT[157] BAT[158] BAT[159] DMY_EDGE_T2[2] DMY_EDGE_T2[3]
+   REPRCHGB_T QT[80] QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88]
+   QT[89] QT[90] QT[91] QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99]
+   QT[100] QT[101] QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108]
+   QT[109] QT[110] QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117]
+   QT[118] QT[119] QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126]
+   QT[127] QT[128] QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135]
+   QT[136] QT[137] QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144]
+   QT[145] QT[146] QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153]
+   QT[154] QT[155] QT[156] QT[157] QT[158] QT[159] RBL[80] RBL[81] RBL[82]
+   RBL[83] RBL[84] RBL[85] RBL[86] RBL[87] RBL[88] RBL[89] RBL[90] RBL[91]
+   RBL[92] RBL[93] RBL[94] RBL[95] RBL[96] RBL[97] RBL[98] RBL[99] RBL[100]
+   RBL[101] RBL[102] RBL[103] RBL[104] RBL[105] RBL[106] RBL[107] RBL[108]
+   RBL[109] RBL[110] RBL[111] RBL[112] RBL[113] RBL[114] RBL[115] RBL[116]
+   RBL[117] RBL[118] RBL[119] RBL[120] RBL[121] RBL[122] RBL[123] RBL[124]
+   RBL[125] RBL[126] RBL[127] RBL[128] RBL[129] RBL[130] RBL[131] RBL[132]
+   RBL[133] RBL[134] RBL[135] RBL[136] RBL[137] RBL[138] RBL[139] RBL[140]
+   RBL[141] RBL[142] RBL[143] RBL[144] RBL[145] RBL[146] RBL[147] RBL[148]
+   RBL[149] RBL[150] RBL[151] RBL[152] RBL[153] RBL[154] RBL[155] RBL[156]
+   RBL[157] RBL[158] RBL[159] RETKEEP_LCGTL VBN[21] VBN[22] VBN[23] VBN[24]
+   VBN[25] VBN[26] VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33]
+   VBN[34] VBN[35] VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBP[21] VBP[22]
+   VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+   VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40]
+   VDDA[21] VDDA[22] VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28]
+   VDDA[29] VDDA[30] VDDA[31] VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36]
+   VDDA[37] VDDA[38] VDDA[39] VDDA[40] VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2
+   VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2
+   VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAI_SACR2 VDDAI_SACR2
+   VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2
+   VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2
+   VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2
+   VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28]
+   VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34] VDDP[35] VDDP[36]
+   VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24]
+   VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31]
+   VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36] VDDPI[37] VDDPI[38]
+   VDDPI[39] VDDPI[40] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27]
+   VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34] VSS[35] VSS[36]
+   VSS[37] VSS[38] VSS[39] VSS[40] REYSELB[0] REYSELB[1] REYSELB[2] REYSELB[3]
+   SNPS_RF_DP_UHD_512x80_sac_rt_seg1
X_mm17a04_u_hdrf2p_capsac_bk1_rpb128 VDDP[41] VDDPI[41] VSS[41] VBP[41] VBN[41]
+   DMY_EDGE_RT[1] DMY_EDGE_T2[3] LOG0 LOG1 PGIOI VEDGE
+   mm17a04_u_hdrf2p_capsac_bk1
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_sac_row ARYSD BAB[0] BAB[1] BAB[2] BAB[3] BAB[4]
+       BAB[5] BAB[6] BAB[7] BAB[8] BAB[9] BAB[10] BAB[11] BAB[12] BAB[13]
+       BAB[14] BAB[15] BAB[16] BAB[17] BAB[18] BAB[19] BAB[20] BAB[21] BAB[22]
+       BAB[23] BAB[24] BAB[25] BAB[26] BAB[27] BAB[28] BAB[29] BAB[30] BAB[31]
+       BAB[32] BAB[33] BAB[34] BAB[35] BAB[36] BAB[37] BAB[38] BAB[39] BAB[40]
+       BAB[41] BAB[42] BAB[43] BAB[44] BAB[45] BAB[46] BAB[47] BAB[48] BAB[49]
+       BAB[50] BAB[51] BAB[52] BAB[53] BAB[54] BAB[55] BAB[56] BAB[57] BAB[58]
+       BAB[59] BAB[60] BAB[61] BAB[62] BAB[63] BAB[64] BAB[65] BAB[66] BAB[67]
+       BAB[68] BAB[69] BAB[70] BAB[71] BAB[72] BAB[73] BAB[74] BAB[75] BAB[76]
+       BAB[77] BAB[78] BAB[79] BAB[80] BAB[81] BAB[82] BAB[83] BAB[84] BAB[85]
+       BAB[86] BAB[87] BAB[88] BAB[89] BAB[90] BAB[91] BAB[92] BAB[93] BAB[94]
+       BAB[95] BAB[96] BAB[97] BAB[98] BAB[99] BAB[100] BAB[101] BAB[102]
+       BAB[103] BAB[104] BAB[105] BAB[106] BAB[107] BAB[108] BAB[109] BAB[110]
+       BAB[111] BAB[112] BAB[113] BAB[114] BAB[115] BAB[116] BAB[117] BAB[118]
+       BAB[119] BAB[120] BAB[121] BAB[122] BAB[123] BAB[124] BAB[125] BAB[126]
+       BAB[127] BAB[128] BAB[129] BAB[130] BAB[131] BAB[132] BAB[133] BAB[134]
+       BAB[135] BAB[136] BAB[137] BAB[138] BAB[139] BAB[140] BAB[141] BAB[142]
+       BAB[143] BAB[144] BAB[145] BAB[146] BAB[147] BAB[148] BAB[149] BAB[150]
+       BAB[151] BAB[152] BAB[153] BAB[154] BAB[155] BAB[156] BAB[157] BAB[158]
+       BAB[159] BAT[0] BAT[1] BAT[2] BAT[3] BAT[4] BAT[5] BAT[6] BAT[7] BAT[8]
+       BAT[9] BAT[10] BAT[11] BAT[12] BAT[13] BAT[14] BAT[15] BAT[16] BAT[17]
+       BAT[18] BAT[19] BAT[20] BAT[21] BAT[22] BAT[23] BAT[24] BAT[25] BAT[26]
+       BAT[27] BAT[28] BAT[29] BAT[30] BAT[31] BAT[32] BAT[33] BAT[34] BAT[35]
+       BAT[36] BAT[37] BAT[38] BAT[39] BAT[40] BAT[41] BAT[42] BAT[43] BAT[44]
+       BAT[45] BAT[46] BAT[47] BAT[48] BAT[49] BAT[50] BAT[51] BAT[52] BAT[53]
+       BAT[54] BAT[55] BAT[56] BAT[57] BAT[58] BAT[59] BAT[60] BAT[61] BAT[62]
+       BAT[63] BAT[64] BAT[65] BAT[66] BAT[67] BAT[68] BAT[69] BAT[70] BAT[71]
+       BAT[72] BAT[73] BAT[74] BAT[75] BAT[76] BAT[77] BAT[78] BAT[79] BAT[80]
+       BAT[81] BAT[82] BAT[83] BAT[84] BAT[85] BAT[86] BAT[87] BAT[88] BAT[89]
+       BAT[90] BAT[91] BAT[92] BAT[93] BAT[94] BAT[95] BAT[96] BAT[97] BAT[98]
+       BAT[99] BAT[100] BAT[101] BAT[102] BAT[103] BAT[104] BAT[105] BAT[106]
+       BAT[107] BAT[108] BAT[109] BAT[110] BAT[111] BAT[112] BAT[113] BAT[114]
+       BAT[115] BAT[116] BAT[117] BAT[118] BAT[119] BAT[120] BAT[121] BAT[122]
+       BAT[123] BAT[124] BAT[125] BAT[126] BAT[127] BAT[128] BAT[129] BAT[130]
+       BAT[131] BAT[132] BAT[133] BAT[134] BAT[135] BAT[136] BAT[137] BAT[138]
+       BAT[139] BAT[140] BAT[141] BAT[142] BAT[143] BAT[144] BAT[145] BAT[146]
+       BAT[147] BAT[148] BAT[149] BAT[150] BAT[151] BAT[152] BAT[153] BAT[154]
+       BAT[155] BAT[156] BAT[157] BAT[158] BAT[159] CENDP DEF1_RD DEF1_WR
+       DMY_EDGE_LT[0] DMY_EDGE_LT[1] DMY_EDGE_RT[0] DMY_EDGE_RT[1] FAST1_RD
+       FAST1_WR FAST2_RD FAST2_WR LCGTL LCGTL_O LCGTV[0] LCGTV[1] LOG0 LOG1
+       LRWMEB LXADR[0] LXADR[1] LXADR[2] LXADRB[0] LXADRB[1] LXADRB[2] OPT_RET
+       PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3]
+       PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3]
+       PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3] PGIOI PLBKADR[0] PLBKADR[1]
+       PLBKADR[2] PLBKADRB QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+       QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17]
+       QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27]
+       QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37]
+       QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+       QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57]
+       QT[58] QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67]
+       QT[68] QT[69] QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77]
+       QT[78] QT[79] QT[80] QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87]
+       QT[88] QT[89] QT[90] QT[91] QT[92] QT[93] QT[94] QT[95] QT[96] QT[97]
+       QT[98] QT[99] QT[100] QT[101] QT[102] QT[103] QT[104] QT[105] QT[106]
+       QT[107] QT[108] QT[109] QT[110] QT[111] QT[112] QT[113] QT[114] QT[115]
+       QT[116] QT[117] QT[118] QT[119] QT[120] QT[121] QT[122] QT[123] QT[124]
+       QT[125] QT[126] QT[127] QT[128] QT[129] QT[130] QT[131] QT[132] QT[133]
+       QT[134] QT[135] QT[136] QT[137] QT[138] QT[139] QT[140] QT[141] QT[142]
+       QT[143] QT[144] QT[145] QT[146] QT[147] QT[148] QT[149] QT[150] QT[151]
+       QT[152] QT[153] QT[154] QT[155] QT[156] QT[157] QT[158] QT[159]
+       RASSB_H[0] RASSB_H[1] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5] RBL[6]
+       RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+       RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+       RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+       RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+       RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+       RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+       RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+       RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+       RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+       RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+       RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+       RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+       RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+       RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+       RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+       RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+       RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+       RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RBLWA
+       RDBL RERASSB[0] RERASSB[1] RFLOAT RFLOAT_H RFLOAT_H_DEL0 RFLOAT_H_DEL2
+       RFLOAT_H_DEL4 RFLOAT_H_DEL6 RFLOAT_H_PGM RFLOAT_PGM RFLT_DEL_A
+       RFLT_DEL_B RFLT_DEL_C RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2]
+       RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] ROWBKDB ROWBKTB RWLB_RD
+       RWLB_WR STCLK_RD_RST_PGM T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAIR1 VDDAIR2
+       VDDAI_SACR1 VDDAI_SACR2 VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_RD_REBUF
+       VDDWL_WR VDDWL_WR_REBUF VEDGE VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2]
+       WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WFLOAT_H
+       WFLOAT_H_DEL0 WFLOAT_H_DEL2 WFLOAT_H_DEL4 WFLOAT_H_DEL6 WFLOAT_H_PGM
+       WFLOAT_PGM WL_VSS YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]
X_sac_cnt ARYSD CENDP DEF1_RD DEF1_WR DMY_EDGE_LT[0] DMY_EDGE_T2_R FAST1_RD
+   FAST1_WR FAST2_RD FAST2_WR LCGTL LCGTL_O LCGTV[0] LOG0 LOG1 LRWMEB LXADR[0]
+   LXADR[1] LXADR[2] LXADRB[0] LXADRB[1] LXADRB[2] OPT_RET PAWRB[0] PAWRB[1]
+   PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1]
+   PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1]
+   PCWRB[2] PCWRB[3] PLBKADR[0] PLBKADR[1] PLBKADR[2] PLBKADRB PRCHGB_T
+   RASSB_H[0] RASSB_H[1] RBLWA RDBL RFLOAT RFLOAT_H RFLOAT_H_DEL0 RFLOAT_H_DEL2
+   RFLOAT_H_DEL4 RFLOAT_H_DEL6 RFLOAT_H_PGM RFLOAT_PGM RFLT_DEL_A RFLT_DEL_B
+   RFLT_DEL_C RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0]
+   RMTWR[1] RMTWR[2] RMTWR[3] ROWBKDB ROWBKTB RWLB_RD RWLB_WR STCLK_RD_RST_PGM
+   T1TRD T1TWR TKEEPB TKEEPT_LCGTL VBN VBN VBN VBP VBP VBP VDDA VDDA VDDA
+   VDDAPI VDDF VDDP VDDP VDDP VDDPI VDDPI VDDWL_RD VDDWL_WR VSS VSS VSS VSSWL
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT WFLOAT_H WFLOAT_H_DEL0 WFLOAT_H_DEL2 WFLOAT_H_DEL4
+   WFLOAT_H_DEL6 WFLOAT_H_PGM WFLOAT_PGM YSELB_H[0] YSELB_H[1] YSELB_H[2]
+   YSELB_H[3] YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]
+   SNPS_RF_DP_UHD_512x80_sac_cnt
X_sac_rt BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8] BAB[9]
+   BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17] BAB[18]
+   BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26] BAB[27]
+   BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35] BAB[36]
+   BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44] BAB[45]
+   BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53] BAB[54]
+   BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62] BAB[63]
+   BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71] BAB[72]
+   BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80] BAB[81]
+   BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89] BAB[90]
+   BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98] BAB[99]
+   BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106] BAB[107]
+   BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114] BAB[115]
+   BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122] BAB[123]
+   BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130] BAB[131]
+   BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138] BAB[139]
+   BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146] BAB[147]
+   BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154] BAB[155]
+   BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3] BAT[4]
+   BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13] BAT[14]
+   BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22] BAT[23]
+   BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31] BAT[32]
+   BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40] BAT[41]
+   BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49] BAT[50]
+   BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58] BAT[59]
+   BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67] BAT[68]
+   BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76] BAT[77]
+   BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85] BAT[86]
+   BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94] BAT[95]
+   BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103] BAT[104]
+   BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111] BAT[112]
+   BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119] BAT[120]
+   BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127] BAT[128]
+   BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135] BAT[136]
+   BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143] BAT[144]
+   BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151] BAT[152]
+   BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[1] DMY_EDGE_RT[0] DMY_EDGE_RT[1] DMY_EDGE_T2_R LCGTV[1] LOG0
+   LOG1 PGIOI PRCHGB_T QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8]
+   QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17] QT[18] QT[19]
+   QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28] QT[29] QT[30]
+   QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38] QT[39] QT[40] QT[41]
+   QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49] QT[50] QT[51] QT[52]
+   QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60] QT[61] QT[62] QT[63]
+   QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70] QT[71] QT[72] QT[73] QT[74]
+   QT[75] QT[76] QT[77] QT[78] QT[79] QT[80] QT[81] QT[82] QT[83] QT[84] QT[85]
+   QT[86] QT[87] QT[88] QT[89] QT[90] QT[91] QT[92] QT[93] QT[94] QT[95] QT[96]
+   QT[97] QT[98] QT[99] QT[100] QT[101] QT[102] QT[103] QT[104] QT[105] QT[106]
+   QT[107] QT[108] QT[109] QT[110] QT[111] QT[112] QT[113] QT[114] QT[115]
+   QT[116] QT[117] QT[118] QT[119] QT[120] QT[121] QT[122] QT[123] QT[124]
+   QT[125] QT[126] QT[127] QT[128] QT[129] QT[130] QT[131] QT[132] QT[133]
+   QT[134] QT[135] QT[136] QT[137] QT[138] QT[139] QT[140] QT[141] QT[142]
+   QT[143] QT[144] QT[145] QT[146] QT[147] QT[148] QT[149] QT[150] QT[151]
+   QT[152] QT[153] QT[154] QT[155] QT[156] QT[157] QT[158] QT[159] RBL[0]
+   RBL[1] RBL[2] RBL[3] RBL[4] RBL[5] RBL[6] RBL[7] RBL[8] RBL[9] RBL[10]
+   RBL[11] RBL[12] RBL[13] RBL[14] RBL[15] RBL[16] RBL[17] RBL[18] RBL[19]
+   RBL[20] RBL[21] RBL[22] RBL[23] RBL[24] RBL[25] RBL[26] RBL[27] RBL[28]
+   RBL[29] RBL[30] RBL[31] RBL[32] RBL[33] RBL[34] RBL[35] RBL[36] RBL[37]
+   RBL[38] RBL[39] RBL[40] RBL[41] RBL[42] RBL[43] RBL[44] RBL[45] RBL[46]
+   RBL[47] RBL[48] RBL[49] RBL[50] RBL[51] RBL[52] RBL[53] RBL[54] RBL[55]
+   RBL[56] RBL[57] RBL[58] RBL[59] RBL[60] RBL[61] RBL[62] RBL[63] RBL[64]
+   RBL[65] RBL[66] RBL[67] RBL[68] RBL[69] RBL[70] RBL[71] RBL[72] RBL[73]
+   RBL[74] RBL[75] RBL[76] RBL[77] RBL[78] RBL[79] RBL[80] RBL[81] RBL[82]
+   RBL[83] RBL[84] RBL[85] RBL[86] RBL[87] RBL[88] RBL[89] RBL[90] RBL[91]
+   RBL[92] RBL[93] RBL[94] RBL[95] RBL[96] RBL[97] RBL[98] RBL[99] RBL[100]
+   RBL[101] RBL[102] RBL[103] RBL[104] RBL[105] RBL[106] RBL[107] RBL[108]
+   RBL[109] RBL[110] RBL[111] RBL[112] RBL[113] RBL[114] RBL[115] RBL[116]
+   RBL[117] RBL[118] RBL[119] RBL[120] RBL[121] RBL[122] RBL[123] RBL[124]
+   RBL[125] RBL[126] RBL[127] RBL[128] RBL[129] RBL[130] RBL[131] RBL[132]
+   RBL[133] RBL[134] RBL[135] RBL[136] RBL[137] RBL[138] RBL[139] RBL[140]
+   RBL[141] RBL[142] RBL[143] RBL[144] RBL[145] RBL[146] RBL[147] RBL[148]
+   RBL[149] RBL[150] RBL[151] RBL[152] RBL[153] RBL[154] RBL[155] RBL[156]
+   RBL[157] RBL[158] RBL[159] RERASSB[0] RERASSB[1] TKEEPT_LCGTL VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VEDGE VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS WL_VSS YSELB_H[0] YSELB_H[1] YSELB_H[2]
+   YSELB_H[3] SNPS_RF_DP_UHD_512x80_sac_rt
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_sac_row_t ARYSD BAB[0] BAB[1] BAB[2] BAB[3] BAB[4]
+       BAB[5] BAB[6] BAB[7] BAB[8] BAB[9] BAB[10] BAB[11] BAB[12] BAB[13]
+       BAB[14] BAB[15] BAB[16] BAB[17] BAB[18] BAB[19] BAB[20] BAB[21] BAB[22]
+       BAB[23] BAB[24] BAB[25] BAB[26] BAB[27] BAB[28] BAB[29] BAB[30] BAB[31]
+       BAB[32] BAB[33] BAB[34] BAB[35] BAB[36] BAB[37] BAB[38] BAB[39] BAB[40]
+       BAB[41] BAB[42] BAB[43] BAB[44] BAB[45] BAB[46] BAB[47] BAB[48] BAB[49]
+       BAB[50] BAB[51] BAB[52] BAB[53] BAB[54] BAB[55] BAB[56] BAB[57] BAB[58]
+       BAB[59] BAB[60] BAB[61] BAB[62] BAB[63] BAB[64] BAB[65] BAB[66] BAB[67]
+       BAB[68] BAB[69] BAB[70] BAB[71] BAB[72] BAB[73] BAB[74] BAB[75] BAB[76]
+       BAB[77] BAB[78] BAB[79] BAB[80] BAB[81] BAB[82] BAB[83] BAB[84] BAB[85]
+       BAB[86] BAB[87] BAB[88] BAB[89] BAB[90] BAB[91] BAB[92] BAB[93] BAB[94]
+       BAB[95] BAB[96] BAB[97] BAB[98] BAB[99] BAB[100] BAB[101] BAB[102]
+       BAB[103] BAB[104] BAB[105] BAB[106] BAB[107] BAB[108] BAB[109] BAB[110]
+       BAB[111] BAB[112] BAB[113] BAB[114] BAB[115] BAB[116] BAB[117] BAB[118]
+       BAB[119] BAB[120] BAB[121] BAB[122] BAB[123] BAB[124] BAB[125] BAB[126]
+       BAB[127] BAB[128] BAB[129] BAB[130] BAB[131] BAB[132] BAB[133] BAB[134]
+       BAB[135] BAB[136] BAB[137] BAB[138] BAB[139] BAB[140] BAB[141] BAB[142]
+       BAB[143] BAB[144] BAB[145] BAB[146] BAB[147] BAB[148] BAB[149] BAB[150]
+       BAB[151] BAB[152] BAB[153] BAB[154] BAB[155] BAB[156] BAB[157] BAB[158]
+       BAB[159] BAT[0] BAT[1] BAT[2] BAT[3] BAT[4] BAT[5] BAT[6] BAT[7] BAT[8]
+       BAT[9] BAT[10] BAT[11] BAT[12] BAT[13] BAT[14] BAT[15] BAT[16] BAT[17]
+       BAT[18] BAT[19] BAT[20] BAT[21] BAT[22] BAT[23] BAT[24] BAT[25] BAT[26]
+       BAT[27] BAT[28] BAT[29] BAT[30] BAT[31] BAT[32] BAT[33] BAT[34] BAT[35]
+       BAT[36] BAT[37] BAT[38] BAT[39] BAT[40] BAT[41] BAT[42] BAT[43] BAT[44]
+       BAT[45] BAT[46] BAT[47] BAT[48] BAT[49] BAT[50] BAT[51] BAT[52] BAT[53]
+       BAT[54] BAT[55] BAT[56] BAT[57] BAT[58] BAT[59] BAT[60] BAT[61] BAT[62]
+       BAT[63] BAT[64] BAT[65] BAT[66] BAT[67] BAT[68] BAT[69] BAT[70] BAT[71]
+       BAT[72] BAT[73] BAT[74] BAT[75] BAT[76] BAT[77] BAT[78] BAT[79] BAT[80]
+       BAT[81] BAT[82] BAT[83] BAT[84] BAT[85] BAT[86] BAT[87] BAT[88] BAT[89]
+       BAT[90] BAT[91] BAT[92] BAT[93] BAT[94] BAT[95] BAT[96] BAT[97] BAT[98]
+       BAT[99] BAT[100] BAT[101] BAT[102] BAT[103] BAT[104] BAT[105] BAT[106]
+       BAT[107] BAT[108] BAT[109] BAT[110] BAT[111] BAT[112] BAT[113] BAT[114]
+       BAT[115] BAT[116] BAT[117] BAT[118] BAT[119] BAT[120] BAT[121] BAT[122]
+       BAT[123] BAT[124] BAT[125] BAT[126] BAT[127] BAT[128] BAT[129] BAT[130]
+       BAT[131] BAT[132] BAT[133] BAT[134] BAT[135] BAT[136] BAT[137] BAT[138]
+       BAT[139] BAT[140] BAT[141] BAT[142] BAT[143] BAT[144] BAT[145] BAT[146]
+       BAT[147] BAT[148] BAT[149] BAT[150] BAT[151] BAT[152] BAT[153] BAT[154]
+       BAT[155] BAT[156] BAT[157] BAT[158] BAT[159] CENDP DEF1_RD DEF1_WR
+       DMY_EDGE_LT[0] DMY_EDGE_LT[1] DMY_EDGE_RT[0] DMY_EDGE_RT[1] FAST1_RD
+       FAST1_WR FAST2_RD FAST2_WR LCGTL[0] LCGTL[1] LCGTV[0] LCGTV[1] LOG0 LOG1
+       LRWMEB LXADR[0] LXADR[1] LXADR[2] LXADRBRD_2 LXADRBRD_3 LXADRBRD_4
+       OPT_RET PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2]
+       PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2]
+       PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3] PGIOI PLBKADR[0] PLBKADR[1]
+       PLBKADR[2] PLBKADRB QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+       QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17]
+       QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27]
+       QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37]
+       QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+       QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57]
+       QT[58] QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67]
+       QT[68] QT[69] QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77]
+       QT[78] QT[79] QT[80] QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87]
+       QT[88] QT[89] QT[90] QT[91] QT[92] QT[93] QT[94] QT[95] QT[96] QT[97]
+       QT[98] QT[99] QT[100] QT[101] QT[102] QT[103] QT[104] QT[105] QT[106]
+       QT[107] QT[108] QT[109] QT[110] QT[111] QT[112] QT[113] QT[114] QT[115]
+       QT[116] QT[117] QT[118] QT[119] QT[120] QT[121] QT[122] QT[123] QT[124]
+       QT[125] QT[126] QT[127] QT[128] QT[129] QT[130] QT[131] QT[132] QT[133]
+       QT[134] QT[135] QT[136] QT[137] QT[138] QT[139] QT[140] QT[141] QT[142]
+       QT[143] QT[144] QT[145] QT[146] QT[147] QT[148] QT[149] QT[150] QT[151]
+       QT[152] QT[153] QT[154] QT[155] QT[156] QT[157] QT[158] QT[159]
+       RASSB_H[0] RASSB_H[1] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5] RBL[6]
+       RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+       RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+       RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+       RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+       RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+       RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+       RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+       RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+       RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+       RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+       RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+       RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+       RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+       RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+       RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+       RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+       RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+       RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RBLWA
+       RDBL RERASSB[0] RERASSB[1] RFLOAT RFLOAT_H RFLOAT_H_DEL0 RFLOAT_H_DEL2
+       RFLOAT_H_DEL4 RFLOAT_H_DEL6 RFLOAT_H_PGM RFLOAT_PGM RFLT_DEL_A
+       RFLT_DEL_B RFLT_DEL_C RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2]
+       RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] ROWBKDB ROWBKTB RWLB_RD
+       RWLB_WR STCLK_RD_RST_PGM T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAIR1 VDDAIR2
+       VDDAI_SACR1 VDDAI_SACR2 VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_RD_REBUF
+       VDDWL_WR VDDWL_WR_REBUF VEDGE VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2]
+       WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WFLOAT_H
+       WFLOAT_H_DEL0 WFLOAT_H_DEL2 WFLOAT_H_DEL4 WFLOAT_H_DEL6 WFLOAT_H_PGM
+       WFLOAT_PGM WL_VSS YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]
X_sac_row ARYSD BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   CENDP DEF1_RD DEF1_WR DMY_EDGE_LT[0] DMY_EDGE_LT[1] DMY_EDGE_RT[0]
+   DMY_EDGE_RT[1] FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL[0] LCGTL[1]
+   LCGTV[0] LCGTV[1] LOG0 LOG1 LRWMEB LXADR[0] LXADR[1] LXADR[2] LXADRBRD_2
+   LXADRBRD_3 LXADRBRD_4 OPT_RET PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0]
+   PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0]
+   PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3] PGIOI
+   PLBKADR[0] PLBKADR[1] PLBKADR[2] PLBKADRB QT[0] QT[1] QT[2] QT[3] QT[4]
+   QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15]
+   QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26]
+   QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37]
+   QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48]
+   QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59]
+   QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70]
+   QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80] QT[81]
+   QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91] QT[92]
+   QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101] QT[102]
+   QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110] QT[111]
+   QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119] QT[120]
+   QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128] QT[129]
+   QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137] QT[138]
+   QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146] QT[147]
+   QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155] QT[156]
+   QT[157] QT[158] QT[159] RASSB_H[0] RASSB_H[1] RBL[0] RBL[1] RBL[2] RBL[3]
+   RBL[4] RBL[5] RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13]
+   RBL[14] RBL[15] RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22]
+   RBL[23] RBL[24] RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31]
+   RBL[32] RBL[33] RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40]
+   RBL[41] RBL[42] RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49]
+   RBL[50] RBL[51] RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58]
+   RBL[59] RBL[60] RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67]
+   RBL[68] RBL[69] RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76]
+   RBL[77] RBL[78] RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85]
+   RBL[86] RBL[87] RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94]
+   RBL[95] RBL[96] RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103]
+   RBL[104] RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111]
+   RBL[112] RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119]
+   RBL[120] RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127]
+   RBL[128] RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135]
+   RBL[136] RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143]
+   RBL[144] RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151]
+   RBL[152] RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159]
+   RBLWA RDBL RERASSB[0] RERASSB[1] RFLOAT RFLOAT_H RFLOAT_H_DEL0 RFLOAT_H_DEL2
+   RFLOAT_H_DEL4 RFLOAT_H_DEL6 RFLOAT_H_PGM RFLOAT_PGM RFLT_DEL_A RFLT_DEL_B
+   RFLT_DEL_C RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0]
+   RMTWR[1] RMTWR[2] RMTWR[3] ROWBKDB ROWBKTB RWLB_RD RWLB_WR STCLK_RD_RST_PGM
+   T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2
+   VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_RD_REBUF VDDWL_WR VDDWL_WR_REBUF VEDGE
+   VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1]
+   WCLKWR[2] WCLKWR[3] WDBL WFLOAT WFLOAT_H WFLOAT_H_DEL0 WFLOAT_H_DEL2
+   WFLOAT_H_DEL4 WFLOAT_H_DEL6 WFLOAT_H_PGM WFLOAT_PGM WL_VSS YSELRD[0]
+   YSELRD[1] YSELRD[2] YSELRD[3] SNPS_RF_DP_UHD_512x80_sac_row
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_b ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[0] XAWRB
* Jumper: PBRDB[0] XBRDB
* Jumper: PBWRB[0] XBWRB
* Jumper: PCRDB[0] XCRDB
* Jumper: PCWRB[0] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_b VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_a ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[0] XAWRB
* Jumper: PBRDB[1] XBRDB
* Jumper: PBWRB[1] XBWRB
* Jumper: PCRDB[0] XCRDB
* Jumper: PCWRB[0] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_a VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_b_1 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[0] XAWRB
* Jumper: PBRDB[2] XBRDB
* Jumper: PBWRB[2] XBWRB
* Jumper: PCRDB[0] XCRDB
* Jumper: PCWRB[0] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_b VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_a_1 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[0] XAWRB
* Jumper: PBRDB[3] XBRDB
* Jumper: PBWRB[3] XBWRB
* Jumper: PCRDB[0] XCRDB
* Jumper: PCWRB[0] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_a VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_b_2 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[0] XAWRB
* Jumper: PBRDB[0] XBRDB
* Jumper: PBWRB[0] XBWRB
* Jumper: PCRDB[1] XCRDB
* Jumper: PCWRB[1] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_b VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_a_2 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[0] XAWRB
* Jumper: PBRDB[1] XBRDB
* Jumper: PBWRB[1] XBWRB
* Jumper: PCRDB[1] XCRDB
* Jumper: PCWRB[1] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_a VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_b_3 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[0] XAWRB
* Jumper: PBRDB[2] XBRDB
* Jumper: PBWRB[2] XBWRB
* Jumper: PCRDB[1] XCRDB
* Jumper: PCWRB[1] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_b VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_a_3 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[0] XAWRB
* Jumper: PBRDB[3] XBRDB
* Jumper: PBWRB[3] XBWRB
* Jumper: PCRDB[1] XCRDB
* Jumper: PCWRB[1] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_a VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_b_4 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[0] XAWRB
* Jumper: PBRDB[0] XBRDB
* Jumper: PBWRB[0] XBWRB
* Jumper: PCRDB[2] XCRDB
* Jumper: PCWRB[2] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_b VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_a_4 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[0] XAWRB
* Jumper: PBRDB[1] XBRDB
* Jumper: PBWRB[1] XBWRB
* Jumper: PCRDB[2] XCRDB
* Jumper: PCWRB[2] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_a VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_b_5 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[0] XAWRB
* Jumper: PBRDB[2] XBRDB
* Jumper: PBWRB[2] XBWRB
* Jumper: PCRDB[2] XCRDB
* Jumper: PCWRB[2] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_b VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_a_5 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[0] XAWRB
* Jumper: PBRDB[3] XBRDB
* Jumper: PBWRB[3] XBWRB
* Jumper: PCRDB[2] XCRDB
* Jumper: PCWRB[2] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_a VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_b_6 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[0] XAWRB
* Jumper: PBRDB[0] XBRDB
* Jumper: PBWRB[0] XBWRB
* Jumper: PCRDB[3] XCRDB
* Jumper: PCWRB[3] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_b VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_a_6 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[0] XAWRB
* Jumper: PBRDB[1] XBRDB
* Jumper: PBWRB[1] XBWRB
* Jumper: PCRDB[3] XCRDB
* Jumper: PCWRB[3] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_a VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_b_7 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[0] XAWRB
* Jumper: PBRDB[2] XBRDB
* Jumper: PBWRB[2] XBWRB
* Jumper: PCRDB[3] XCRDB
* Jumper: PCWRB[3] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_b VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_a_7 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[0] XAWRB
* Jumper: PBRDB[3] XBRDB
* Jumper: PBWRB[3] XBWRB
* Jumper: PCRDB[3] XCRDB
* Jumper: PCWRB[3] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_a VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_b_8 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB_128 BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[1] XAWRB
* Jumper: PBRDB[0] XBRDB
* Jumper: PBWRB[0] XBWRB
* Jumper: PCRDB[0] XCRDB
* Jumper: PCWRB[0] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_b VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB_128
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_a_8 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB_128 BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[1] XAWRB
* Jumper: PBRDB[1] XBRDB
* Jumper: PBWRB[1] XBWRB
* Jumper: PCRDB[0] XCRDB
* Jumper: PCWRB[0] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_a VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB_128
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_b_9 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB_128 BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[1] XAWRB
* Jumper: PBRDB[2] XBRDB
* Jumper: PBWRB[2] XBWRB
* Jumper: PCRDB[0] XCRDB
* Jumper: PCWRB[0] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_b VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB_128
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_a_9 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB_128 BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[1] XAWRB
* Jumper: PBRDB[3] XBRDB
* Jumper: PBWRB[3] XBWRB
* Jumper: PCRDB[0] XCRDB
* Jumper: PCWRB[0] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_a VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB_128
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_b_10 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB_128 BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[1] XAWRB
* Jumper: PBRDB[0] XBRDB
* Jumper: PBWRB[0] XBWRB
* Jumper: PCRDB[1] XCRDB
* Jumper: PCWRB[1] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_b VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB_128
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_a_10 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB_128 BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[1] XAWRB
* Jumper: PBRDB[1] XBRDB
* Jumper: PBWRB[1] XBWRB
* Jumper: PCRDB[1] XCRDB
* Jumper: PCWRB[1] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_a VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB_128
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_b_11 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB_128 BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[1] XAWRB
* Jumper: PBRDB[2] XBRDB
* Jumper: PBWRB[2] XBWRB
* Jumper: PCRDB[1] XCRDB
* Jumper: PCWRB[1] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_b VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB_128
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_a_11 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB_128 BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[1] XAWRB
* Jumper: PBRDB[3] XBRDB
* Jumper: PBWRB[3] XBWRB
* Jumper: PCRDB[1] XCRDB
* Jumper: PCWRB[1] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_a VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB_128
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_b_12 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB_128 BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[1] XAWRB
* Jumper: PBRDB[0] XBRDB
* Jumper: PBWRB[0] XBWRB
* Jumper: PCRDB[2] XCRDB
* Jumper: PCWRB[2] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_b VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB_128
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_a_12 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB_128 BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[1] XAWRB
* Jumper: PBRDB[1] XBRDB
* Jumper: PBWRB[1] XBWRB
* Jumper: PCRDB[2] XCRDB
* Jumper: PCWRB[2] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_a VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB_128
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_b_13 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB_128 BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[1] XAWRB
* Jumper: PBRDB[2] XBRDB
* Jumper: PBWRB[2] XBWRB
* Jumper: PCRDB[2] XCRDB
* Jumper: PCWRB[2] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_b VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB_128
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_a_13 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB_128 BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[1] XAWRB
* Jumper: PBRDB[3] XBRDB
* Jumper: PBWRB[3] XBWRB
* Jumper: PCRDB[2] XCRDB
* Jumper: PCWRB[2] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_a VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB_128
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_b_14 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB_128 BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[1] XAWRB
* Jumper: PBRDB[0] XBRDB
* Jumper: PBWRB[0] XBWRB
* Jumper: PCRDB[3] XCRDB
* Jumper: PCWRB[3] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_b VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB_128
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_a_14 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB_128 BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[1] XAWRB
* Jumper: PBRDB[1] XBRDB
* Jumper: PBWRB[1] XBWRB
* Jumper: PCRDB[3] XCRDB
* Jumper: PCWRB[3] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_a VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB_128
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_b_15 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB_128 BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[1] XAWRB
* Jumper: PBRDB[2] XBRDB
* Jumper: PBWRB[2] XBWRB
* Jumper: PCRDB[3] XCRDB
* Jumper: PCWRB[3] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_b VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB_128
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_x4dec_a_15 ARYSD BKRDB BKRDB_128 CENDP DECBRD
+       DECBWR DECB_HV_RD DECB_HV_WR DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+       RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+       RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2]
+       WLRDB[3] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB
+       XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]

*** Jumper Report ***
* Jumper: BKRDB_128 BKRDB_PROG
* Jumper: DECBRD DECB_HV_RD
* Jumper: DECBWR DECB_HV_WR
* Jumper: PAWRB[1] XAWRB
* Jumper: PBRDB[3] XBRDB
* Jumper: PBWRB[3] XBWRB
* Jumper: PCRDB[3] XCRDB
* Jumper: PCWRB[3] XCWRB
* Jumper: VDDP VDDF

X_mm17a04_u_hdrf2p_x4dec_a VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+   VSSWL VBP VBN DECBRD DECBWR WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] ARYSD BKRDB BKRDB_128 BKRDB_128
+   CENDP DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1
+   LRWMEB LXADRA[0] LXADRA[1] LXADRA[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+   PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+   PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+   RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3] DECB_HV_RD
+   DECB_HV_WR XAWRB XBRDB XBWRB XCRDB XCWRB mm17a04_u_hdrf2p_x4dec
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_xdec ARYSD BKRDB BKRDB_128 CENDP DECBRD[0]
+       DECBRD[1] DECBRD[2] DECBRD[3] DECBRD[4] DECBRD[5] DECBRD[6] DECBRD[7]
+       DECBRD[8] DECBRD[9] DECBRD[10] DECBRD[11] DECBRD[12] DECBRD[13]
+       DECBRD[14] DECBRD[15] DECBRD[16] DECBRD[17] DECBRD[18] DECBRD[19]
+       DECBRD[20] DECBRD[21] DECBRD[22] DECBRD[23] DECBRD[24] DECBRD[25]
+       DECBRD[26] DECBRD[27] DECBRD[28] DECBRD[29] DECBRD[30] DECBRD[31]
+       DECBWR[0] DECBWR[1] DECBWR[2] DECBWR[3] DECBWR[4] DECBWR[5] DECBWR[6]
+       DECBWR[7] DECBWR[8] DECBWR[9] DECBWR[10] DECBWR[11] DECBWR[12]
+       DECBWR[13] DECBWR[14] DECBWR[15] DECBWR[16] DECBWR[17] DECBWR[18]
+       DECBWR[19] DECBWR[20] DECBWR[21] DECBWR[22] DECBWR[23] DECBWR[24]
+       DECBWR[25] DECBWR[26] DECBWR[27] DECBWR[28] DECBWR[29] DECBWR[30]
+       DECBWR[31] DECB_HV_RD[0] DECB_HV_RD[1] DECB_HV_RD[2] DECB_HV_RD[3]
+       DECB_HV_RD[4] DECB_HV_RD[5] DECB_HV_RD[6] DECB_HV_RD[7] DECB_HV_RD[8]
+       DECB_HV_RD[9] DECB_HV_RD[10] DECB_HV_RD[11] DECB_HV_RD[12]
+       DECB_HV_RD[13] DECB_HV_RD[14] DECB_HV_RD[15] DECB_HV_RD[16]
+       DECB_HV_RD[17] DECB_HV_RD[18] DECB_HV_RD[19] DECB_HV_RD[20]
+       DECB_HV_RD[21] DECB_HV_RD[22] DECB_HV_RD[23] DECB_HV_RD[24]
+       DECB_HV_RD[25] DECB_HV_RD[26] DECB_HV_RD[27] DECB_HV_RD[28]
+       DECB_HV_RD[29] DECB_HV_RD[30] DECB_HV_RD[31] DECB_HV_WR[0] DECB_HV_WR[1]
+       DECB_HV_WR[2] DECB_HV_WR[3] DECB_HV_WR[4] DECB_HV_WR[5] DECB_HV_WR[6]
+       DECB_HV_WR[7] DECB_HV_WR[8] DECB_HV_WR[9] DECB_HV_WR[10] DECB_HV_WR[11]
+       DECB_HV_WR[12] DECB_HV_WR[13] DECB_HV_WR[14] DECB_HV_WR[15]
+       DECB_HV_WR[16] DECB_HV_WR[17] DECB_HV_WR[18] DECB_HV_WR[19]
+       DECB_HV_WR[20] DECB_HV_WR[21] DECB_HV_WR[22] DECB_HV_WR[23]
+       DECB_HV_WR[24] DECB_HV_WR[25] DECB_HV_WR[26] DECB_HV_WR[27]
+       DECB_HV_WR[28] DECB_HV_WR[29] DECB_HV_WR[30] DECB_HV_WR[31] DEF1_RD
+       DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1 LRWMEB
+       LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3]
+       PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3]
+       PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3]
+       RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+       RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB
+       VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS VSSWL
+       WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+       WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB[4]
+       WLRDB[5] WLRDB[6] WLRDB[7] WLRDB[8] WLRDB[9] WLRDB[10] WLRDB[11]
+       WLRDB[12] WLRDB[13] WLRDB[14] WLRDB[15] WLRDB[16] WLRDB[17] WLRDB[18]
+       WLRDB[19] WLRDB[20] WLRDB[21] WLRDB[22] WLRDB[23] WLRDB[24] WLRDB[25]
+       WLRDB[26] WLRDB[27] WLRDB[28] WLRDB[29] WLRDB[30] WLRDB[31] WLRDB[32]
+       WLRDB[33] WLRDB[34] WLRDB[35] WLRDB[36] WLRDB[37] WLRDB[38] WLRDB[39]
+       WLRDB[40] WLRDB[41] WLRDB[42] WLRDB[43] WLRDB[44] WLRDB[45] WLRDB[46]
+       WLRDB[47] WLRDB[48] WLRDB[49] WLRDB[50] WLRDB[51] WLRDB[52] WLRDB[53]
+       WLRDB[54] WLRDB[55] WLRDB[56] WLRDB[57] WLRDB[58] WLRDB[59] WLRDB[60]
+       WLRDB[61] WLRDB[62] WLRDB[63] WLRDB[64] WLRDB[65] WLRDB[66] WLRDB[67]
+       WLRDB[68] WLRDB[69] WLRDB[70] WLRDB[71] WLRDB[72] WLRDB[73] WLRDB[74]
+       WLRDB[75] WLRDB[76] WLRDB[77] WLRDB[78] WLRDB[79] WLRDB[80] WLRDB[81]
+       WLRDB[82] WLRDB[83] WLRDB[84] WLRDB[85] WLRDB[86] WLRDB[87] WLRDB[88]
+       WLRDB[89] WLRDB[90] WLRDB[91] WLRDB[92] WLRDB[93] WLRDB[94] WLRDB[95]
+       WLRDB[96] WLRDB[97] WLRDB[98] WLRDB[99] WLRDB[100] WLRDB[101] WLRDB[102]
+       WLRDB[103] WLRDB[104] WLRDB[105] WLRDB[106] WLRDB[107] WLRDB[108]
+       WLRDB[109] WLRDB[110] WLRDB[111] WLRDB[112] WLRDB[113] WLRDB[114]
+       WLRDB[115] WLRDB[116] WLRDB[117] WLRDB[118] WLRDB[119] WLRDB[120]
+       WLRDB[121] WLRDB[122] WLRDB[123] WLRDB[124] WLRDB[125] WLRDB[126]
+       WLRDB[127] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLRDB_L[4]
+       WLRDB_L[5] WLRDB_L[6] WLRDB_L[7] WLRDB_L[8] WLRDB_L[9] WLRDB_L[10]
+       WLRDB_L[11] WLRDB_L[12] WLRDB_L[13] WLRDB_L[14] WLRDB_L[15] WLRDB_L[16]
+       WLRDB_L[17] WLRDB_L[18] WLRDB_L[19] WLRDB_L[20] WLRDB_L[21] WLRDB_L[22]
+       WLRDB_L[23] WLRDB_L[24] WLRDB_L[25] WLRDB_L[26] WLRDB_L[27] WLRDB_L[28]
+       WLRDB_L[29] WLRDB_L[30] WLRDB_L[31] WLRDB_L[32] WLRDB_L[33] WLRDB_L[34]
+       WLRDB_L[35] WLRDB_L[36] WLRDB_L[37] WLRDB_L[38] WLRDB_L[39] WLRDB_L[40]
+       WLRDB_L[41] WLRDB_L[42] WLRDB_L[43] WLRDB_L[44] WLRDB_L[45] WLRDB_L[46]
+       WLRDB_L[47] WLRDB_L[48] WLRDB_L[49] WLRDB_L[50] WLRDB_L[51] WLRDB_L[52]
+       WLRDB_L[53] WLRDB_L[54] WLRDB_L[55] WLRDB_L[56] WLRDB_L[57] WLRDB_L[58]
+       WLRDB_L[59] WLRDB_L[60] WLRDB_L[61] WLRDB_L[62] WLRDB_L[63] WLRDB_L[64]
+       WLRDB_L[65] WLRDB_L[66] WLRDB_L[67] WLRDB_L[68] WLRDB_L[69] WLRDB_L[70]
+       WLRDB_L[71] WLRDB_L[72] WLRDB_L[73] WLRDB_L[74] WLRDB_L[75] WLRDB_L[76]
+       WLRDB_L[77] WLRDB_L[78] WLRDB_L[79] WLRDB_L[80] WLRDB_L[81] WLRDB_L[82]
+       WLRDB_L[83] WLRDB_L[84] WLRDB_L[85] WLRDB_L[86] WLRDB_L[87] WLRDB_L[88]
+       WLRDB_L[89] WLRDB_L[90] WLRDB_L[91] WLRDB_L[92] WLRDB_L[93] WLRDB_L[94]
+       WLRDB_L[95] WLRDB_L[96] WLRDB_L[97] WLRDB_L[98] WLRDB_L[99] WLRDB_L[100]
+       WLRDB_L[101] WLRDB_L[102] WLRDB_L[103] WLRDB_L[104] WLRDB_L[105]
+       WLRDB_L[106] WLRDB_L[107] WLRDB_L[108] WLRDB_L[109] WLRDB_L[110]
+       WLRDB_L[111] WLRDB_L[112] WLRDB_L[113] WLRDB_L[114] WLRDB_L[115]
+       WLRDB_L[116] WLRDB_L[117] WLRDB_L[118] WLRDB_L[119] WLRDB_L[120]
+       WLRDB_L[121] WLRDB_L[122] WLRDB_L[123] WLRDB_L[124] WLRDB_L[125]
+       WLRDB_L[126] WLRDB_L[127] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3] WLWRB[4]
+       WLWRB[5] WLWRB[6] WLWRB[7] WLWRB[8] WLWRB[9] WLWRB[10] WLWRB[11]
+       WLWRB[12] WLWRB[13] WLWRB[14] WLWRB[15] WLWRB[16] WLWRB[17] WLWRB[18]
+       WLWRB[19] WLWRB[20] WLWRB[21] WLWRB[22] WLWRB[23] WLWRB[24] WLWRB[25]
+       WLWRB[26] WLWRB[27] WLWRB[28] WLWRB[29] WLWRB[30] WLWRB[31] WLWRB[32]
+       WLWRB[33] WLWRB[34] WLWRB[35] WLWRB[36] WLWRB[37] WLWRB[38] WLWRB[39]
+       WLWRB[40] WLWRB[41] WLWRB[42] WLWRB[43] WLWRB[44] WLWRB[45] WLWRB[46]
+       WLWRB[47] WLWRB[48] WLWRB[49] WLWRB[50] WLWRB[51] WLWRB[52] WLWRB[53]
+       WLWRB[54] WLWRB[55] WLWRB[56] WLWRB[57] WLWRB[58] WLWRB[59] WLWRB[60]
+       WLWRB[61] WLWRB[62] WLWRB[63] WLWRB[64] WLWRB[65] WLWRB[66] WLWRB[67]
+       WLWRB[68] WLWRB[69] WLWRB[70] WLWRB[71] WLWRB[72] WLWRB[73] WLWRB[74]
+       WLWRB[75] WLWRB[76] WLWRB[77] WLWRB[78] WLWRB[79] WLWRB[80] WLWRB[81]
+       WLWRB[82] WLWRB[83] WLWRB[84] WLWRB[85] WLWRB[86] WLWRB[87] WLWRB[88]
+       WLWRB[89] WLWRB[90] WLWRB[91] WLWRB[92] WLWRB[93] WLWRB[94] WLWRB[95]
+       WLWRB[96] WLWRB[97] WLWRB[98] WLWRB[99] WLWRB[100] WLWRB[101] WLWRB[102]
+       WLWRB[103] WLWRB[104] WLWRB[105] WLWRB[106] WLWRB[107] WLWRB[108]
+       WLWRB[109] WLWRB[110] WLWRB[111] WLWRB[112] WLWRB[113] WLWRB[114]
+       WLWRB[115] WLWRB[116] WLWRB[117] WLWRB[118] WLWRB[119] WLWRB[120]
+       WLWRB[121] WLWRB[122] WLWRB[123] WLWRB[124] WLWRB[125] WLWRB[126]
+       WLWRB[127] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] WLWRB_L[4]
+       WLWRB_L[5] WLWRB_L[6] WLWRB_L[7] WLWRB_L[8] WLWRB_L[9] WLWRB_L[10]
+       WLWRB_L[11] WLWRB_L[12] WLWRB_L[13] WLWRB_L[14] WLWRB_L[15] WLWRB_L[16]
+       WLWRB_L[17] WLWRB_L[18] WLWRB_L[19] WLWRB_L[20] WLWRB_L[21] WLWRB_L[22]
+       WLWRB_L[23] WLWRB_L[24] WLWRB_L[25] WLWRB_L[26] WLWRB_L[27] WLWRB_L[28]
+       WLWRB_L[29] WLWRB_L[30] WLWRB_L[31] WLWRB_L[32] WLWRB_L[33] WLWRB_L[34]
+       WLWRB_L[35] WLWRB_L[36] WLWRB_L[37] WLWRB_L[38] WLWRB_L[39] WLWRB_L[40]
+       WLWRB_L[41] WLWRB_L[42] WLWRB_L[43] WLWRB_L[44] WLWRB_L[45] WLWRB_L[46]
+       WLWRB_L[47] WLWRB_L[48] WLWRB_L[49] WLWRB_L[50] WLWRB_L[51] WLWRB_L[52]
+       WLWRB_L[53] WLWRB_L[54] WLWRB_L[55] WLWRB_L[56] WLWRB_L[57] WLWRB_L[58]
+       WLWRB_L[59] WLWRB_L[60] WLWRB_L[61] WLWRB_L[62] WLWRB_L[63] WLWRB_L[64]
+       WLWRB_L[65] WLWRB_L[66] WLWRB_L[67] WLWRB_L[68] WLWRB_L[69] WLWRB_L[70]
+       WLWRB_L[71] WLWRB_L[72] WLWRB_L[73] WLWRB_L[74] WLWRB_L[75] WLWRB_L[76]
+       WLWRB_L[77] WLWRB_L[78] WLWRB_L[79] WLWRB_L[80] WLWRB_L[81] WLWRB_L[82]
+       WLWRB_L[83] WLWRB_L[84] WLWRB_L[85] WLWRB_L[86] WLWRB_L[87] WLWRB_L[88]
+       WLWRB_L[89] WLWRB_L[90] WLWRB_L[91] WLWRB_L[92] WLWRB_L[93] WLWRB_L[94]
+       WLWRB_L[95] WLWRB_L[96] WLWRB_L[97] WLWRB_L[98] WLWRB_L[99] WLWRB_L[100]
+       WLWRB_L[101] WLWRB_L[102] WLWRB_L[103] WLWRB_L[104] WLWRB_L[105]
+       WLWRB_L[106] WLWRB_L[107] WLWRB_L[108] WLWRB_L[109] WLWRB_L[110]
+       WLWRB_L[111] WLWRB_L[112] WLWRB_L[113] WLWRB_L[114] WLWRB_L[115]
+       WLWRB_L[116] WLWRB_L[117] WLWRB_L[118] WLWRB_L[119] WLWRB_L[120]
+       WLWRB_L[121] WLWRB_L[122] WLWRB_L[123] WLWRB_L[124] WLWRB_L[125]
+       WLWRB_L[126] WLWRB_L[127] XAWRB[0] XBRDB[0] XBWRB[0] XCRDB[0] XCWRB[0]
+       YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]
X_ary_x4dec_b_S0 ARYSD BKRDB BKRDB_128 CENDP DECBRD[0] DECBWR[0] DECB_HV_RD[0]
+   DECB_HV_WR[0] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0
+   LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0] PAWRB[1] PAWRB[2]
+   PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2]
+   PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2]
+   PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2]
+   RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR
+   TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS VSSWL
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB_L[0]
+   WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3]
+   WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] XAWRB[0] XBRDB[0] XBWRB[0]
+   XCRDB[0] XCWRB[0] YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]
+   SNPS_RF_DP_UHD_512x80_ary_x4dec_b
X_ary_x4dec_a_S0 ARYSD BKRDB BKRDB_128 CENDP DECBRD[1] DECBWR[1] DECB_HV_RD[1]
+   DECB_HV_WR[1] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0
+   LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0] PAWRB[1] PAWRB[2]
+   PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2]
+   PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2]
+   PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2]
+   RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR
+   TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS VSSWL
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT WLRDB[4] WLRDB[5] WLRDB[6] WLRDB[7] WLRDB_L[4]
+   WLRDB_L[5] WLRDB_L[6] WLRDB_L[7] WLWRB[4] WLWRB[5] WLWRB[6] WLWRB[7]
+   WLWRB_L[4] WLWRB_L[5] WLWRB_L[6] WLWRB_L[7] PAWRB[0] PBRDB[1] PBWRB[1]
+   PCRDB[0] PCWRB[0] YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]
+   SNPS_RF_DP_UHD_512x80_ary_x4dec_a
X_ary_x4dec_b_S1 ARYSD BKRDB BKRDB_128 CENDP DECBRD[2] DECBWR[2] DECB_HV_RD[2]
+   DECB_HV_WR[2] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0
+   LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0] PAWRB[1] PAWRB[2]
+   PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2]
+   PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2]
+   PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2]
+   RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR
+   TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS VSSWL
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT WLRDB[8] WLRDB[9] WLRDB[10] WLRDB[11] WLRDB_L[8]
+   WLRDB_L[9] WLRDB_L[10] WLRDB_L[11] WLWRB[8] WLWRB[9] WLWRB[10] WLWRB[11]
+   WLWRB_L[8] WLWRB_L[9] WLWRB_L[10] WLWRB_L[11] PAWRB[0] PBRDB[2] PBWRB[2]
+   PCRDB[0] PCWRB[0] YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]
+   SNPS_RF_DP_UHD_512x80_ary_x4dec_b_1
X_ary_x4dec_a_S1 ARYSD BKRDB BKRDB_128 CENDP DECBRD[3] DECBWR[3] DECB_HV_RD[3]
+   DECB_HV_WR[3] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0
+   LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0] PAWRB[1] PAWRB[2]
+   PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2]
+   PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2]
+   PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2]
+   RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR
+   TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS VSSWL
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT WLRDB[12] WLRDB[13] WLRDB[14] WLRDB[15] WLRDB_L[12]
+   WLRDB_L[13] WLRDB_L[14] WLRDB_L[15] WLWRB[12] WLWRB[13] WLWRB[14] WLWRB[15]
+   WLWRB_L[12] WLWRB_L[13] WLWRB_L[14] WLWRB_L[15] PAWRB[0] PBRDB[3] PBWRB[3]
+   PCRDB[0] PCWRB[0] YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]
+   SNPS_RF_DP_UHD_512x80_ary_x4dec_a_1
X_ary_x4dec_b_S2 ARYSD BKRDB BKRDB_128 CENDP DECBRD[4] DECBWR[4] DECB_HV_RD[4]
+   DECB_HV_WR[4] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0
+   LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0] PAWRB[1] PAWRB[2]
+   PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2]
+   PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2]
+   PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2]
+   RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR
+   TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS VSSWL
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT WLRDB[16] WLRDB[17] WLRDB[18] WLRDB[19] WLRDB_L[16]
+   WLRDB_L[17] WLRDB_L[18] WLRDB_L[19] WLWRB[16] WLWRB[17] WLWRB[18] WLWRB[19]
+   WLWRB_L[16] WLWRB_L[17] WLWRB_L[18] WLWRB_L[19] PAWRB[0] PBRDB[0] PBWRB[0]
+   PCRDB[1] PCWRB[1] YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]
+   SNPS_RF_DP_UHD_512x80_ary_x4dec_b_2
X_ary_x4dec_a_S2 ARYSD BKRDB BKRDB_128 CENDP DECBRD[5] DECBWR[5] DECB_HV_RD[5]
+   DECB_HV_WR[5] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0
+   LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0] PAWRB[1] PAWRB[2]
+   PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2]
+   PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2]
+   PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2]
+   RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR
+   TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS VSSWL
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT WLRDB[20] WLRDB[21] WLRDB[22] WLRDB[23] WLRDB_L[20]
+   WLRDB_L[21] WLRDB_L[22] WLRDB_L[23] WLWRB[20] WLWRB[21] WLWRB[22] WLWRB[23]
+   WLWRB_L[20] WLWRB_L[21] WLWRB_L[22] WLWRB_L[23] PAWRB[0] PBRDB[1] PBWRB[1]
+   PCRDB[1] PCWRB[1] YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]
+   SNPS_RF_DP_UHD_512x80_ary_x4dec_a_2
X_ary_x4dec_b_S3 ARYSD BKRDB BKRDB_128 CENDP DECBRD[6] DECBWR[6] DECB_HV_RD[6]
+   DECB_HV_WR[6] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0
+   LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0] PAWRB[1] PAWRB[2]
+   PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2]
+   PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2]
+   PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2]
+   RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR
+   TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS VSSWL
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT WLRDB[24] WLRDB[25] WLRDB[26] WLRDB[27] WLRDB_L[24]
+   WLRDB_L[25] WLRDB_L[26] WLRDB_L[27] WLWRB[24] WLWRB[25] WLWRB[26] WLWRB[27]
+   WLWRB_L[24] WLWRB_L[25] WLWRB_L[26] WLWRB_L[27] PAWRB[0] PBRDB[2] PBWRB[2]
+   PCRDB[1] PCWRB[1] YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]
+   SNPS_RF_DP_UHD_512x80_ary_x4dec_b_3
X_ary_x4dec_a_S3 ARYSD BKRDB BKRDB_128 CENDP DECBRD[7] DECBWR[7] DECB_HV_RD[7]
+   DECB_HV_WR[7] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0
+   LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0] PAWRB[1] PAWRB[2]
+   PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2]
+   PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2]
+   PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2]
+   RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR
+   TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS VSSWL
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT WLRDB[28] WLRDB[29] WLRDB[30] WLRDB[31] WLRDB_L[28]
+   WLRDB_L[29] WLRDB_L[30] WLRDB_L[31] WLWRB[28] WLWRB[29] WLWRB[30] WLWRB[31]
+   WLWRB_L[28] WLWRB_L[29] WLWRB_L[30] WLWRB_L[31] PAWRB[0] PBRDB[3] PBWRB[3]
+   PCRDB[1] PCWRB[1] YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]
+   SNPS_RF_DP_UHD_512x80_ary_x4dec_a_3
X_ary_x4dec_b_S4 ARYSD BKRDB BKRDB_128 CENDP DECBRD[8] DECBWR[8] DECB_HV_RD[8]
+   DECB_HV_WR[8] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0
+   LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0] PAWRB[1] PAWRB[2]
+   PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2]
+   PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2]
+   PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2]
+   RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR
+   TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS VSSWL
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT WLRDB[32] WLRDB[33] WLRDB[34] WLRDB[35] WLRDB_L[32]
+   WLRDB_L[33] WLRDB_L[34] WLRDB_L[35] WLWRB[32] WLWRB[33] WLWRB[34] WLWRB[35]
+   WLWRB_L[32] WLWRB_L[33] WLWRB_L[34] WLWRB_L[35] PAWRB[0] PBRDB[0] PBWRB[0]
+   PCRDB[2] PCWRB[2] YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]
+   SNPS_RF_DP_UHD_512x80_ary_x4dec_b_4
X_ary_x4dec_a_S4 ARYSD BKRDB BKRDB_128 CENDP DECBRD[9] DECBWR[9] DECB_HV_RD[9]
+   DECB_HV_WR[9] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0
+   LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0] PAWRB[1] PAWRB[2]
+   PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2]
+   PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2]
+   PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2]
+   RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR
+   TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_WR VSS VSSWL
+   WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2]
+   WCLKWR[3] WDBL WFLOAT WLRDB[36] WLRDB[37] WLRDB[38] WLRDB[39] WLRDB_L[36]
+   WLRDB_L[37] WLRDB_L[38] WLRDB_L[39] WLWRB[36] WLWRB[37] WLWRB[38] WLWRB[39]
+   WLWRB_L[36] WLWRB_L[37] WLWRB_L[38] WLWRB_L[39] PAWRB[0] PBRDB[1] PBWRB[1]
+   PCRDB[2] PCWRB[2] YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]
+   SNPS_RF_DP_UHD_512x80_ary_x4dec_a_4
X_ary_x4dec_b_S5 ARYSD BKRDB BKRDB_128 CENDP DECBRD[10] DECBWR[10]
+   DECB_HV_RD[10] DECB_HV_WR[10] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+   FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0]
+   PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+   PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+   PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+   RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+   RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+   VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+   WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[40] WLRDB[41] WLRDB[42]
+   WLRDB[43] WLRDB_L[40] WLRDB_L[41] WLRDB_L[42] WLRDB_L[43] WLWRB[40]
+   WLWRB[41] WLWRB[42] WLWRB[43] WLWRB_L[40] WLWRB_L[41] WLWRB_L[42]
+   WLWRB_L[43] PAWRB[0] PBRDB[2] PBWRB[2] PCRDB[2] PCWRB[2] YSELRD[0] YSELRD[1]
+   YSELRD[2] YSELRD[3] SNPS_RF_DP_UHD_512x80_ary_x4dec_b_5
X_ary_x4dec_a_S5 ARYSD BKRDB BKRDB_128 CENDP DECBRD[11] DECBWR[11]
+   DECB_HV_RD[11] DECB_HV_WR[11] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+   FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0]
+   PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+   PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+   PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+   RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+   RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+   VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+   WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[44] WLRDB[45] WLRDB[46]
+   WLRDB[47] WLRDB_L[44] WLRDB_L[45] WLRDB_L[46] WLRDB_L[47] WLWRB[44]
+   WLWRB[45] WLWRB[46] WLWRB[47] WLWRB_L[44] WLWRB_L[45] WLWRB_L[46]
+   WLWRB_L[47] PAWRB[0] PBRDB[3] PBWRB[3] PCRDB[2] PCWRB[2] YSELRD[0] YSELRD[1]
+   YSELRD[2] YSELRD[3] SNPS_RF_DP_UHD_512x80_ary_x4dec_a_5
X_ary_x4dec_b_S6 ARYSD BKRDB BKRDB_128 CENDP DECBRD[12] DECBWR[12]
+   DECB_HV_RD[12] DECB_HV_WR[12] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+   FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0]
+   PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+   PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+   PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+   RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+   RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+   VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+   WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[48] WLRDB[49] WLRDB[50]
+   WLRDB[51] WLRDB_L[48] WLRDB_L[49] WLRDB_L[50] WLRDB_L[51] WLWRB[48]
+   WLWRB[49] WLWRB[50] WLWRB[51] WLWRB_L[48] WLWRB_L[49] WLWRB_L[50]
+   WLWRB_L[51] PAWRB[0] PBRDB[0] PBWRB[0] PCRDB[3] PCWRB[3] YSELRD[0] YSELRD[1]
+   YSELRD[2] YSELRD[3] SNPS_RF_DP_UHD_512x80_ary_x4dec_b_6
X_ary_x4dec_a_S6 ARYSD BKRDB BKRDB_128 CENDP DECBRD[13] DECBWR[13]
+   DECB_HV_RD[13] DECB_HV_WR[13] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+   FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0]
+   PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+   PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+   PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+   RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+   RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+   VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+   WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[52] WLRDB[53] WLRDB[54]
+   WLRDB[55] WLRDB_L[52] WLRDB_L[53] WLRDB_L[54] WLRDB_L[55] WLWRB[52]
+   WLWRB[53] WLWRB[54] WLWRB[55] WLWRB_L[52] WLWRB_L[53] WLWRB_L[54]
+   WLWRB_L[55] PAWRB[0] PBRDB[1] PBWRB[1] PCRDB[3] PCWRB[3] YSELRD[0] YSELRD[1]
+   YSELRD[2] YSELRD[3] SNPS_RF_DP_UHD_512x80_ary_x4dec_a_6
X_ary_x4dec_b_S7 ARYSD BKRDB BKRDB_128 CENDP DECBRD[14] DECBWR[14]
+   DECB_HV_RD[14] DECB_HV_WR[14] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+   FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0]
+   PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+   PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+   PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+   RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+   RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+   VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+   WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[56] WLRDB[57] WLRDB[58]
+   WLRDB[59] WLRDB_L[56] WLRDB_L[57] WLRDB_L[58] WLRDB_L[59] WLWRB[56]
+   WLWRB[57] WLWRB[58] WLWRB[59] WLWRB_L[56] WLWRB_L[57] WLWRB_L[58]
+   WLWRB_L[59] PAWRB[0] PBRDB[2] PBWRB[2] PCRDB[3] PCWRB[3] YSELRD[0] YSELRD[1]
+   YSELRD[2] YSELRD[3] SNPS_RF_DP_UHD_512x80_ary_x4dec_b_7
X_ary_x4dec_a_S7 ARYSD BKRDB BKRDB_128 CENDP DECBRD[15] DECBWR[15]
+   DECB_HV_RD[15] DECB_HV_WR[15] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+   FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0]
+   PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+   PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+   PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+   RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+   RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+   VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+   WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[60] WLRDB[61] WLRDB[62]
+   WLRDB[63] WLRDB_L[60] WLRDB_L[61] WLRDB_L[62] WLRDB_L[63] WLWRB[60]
+   WLWRB[61] WLWRB[62] WLWRB[63] WLWRB_L[60] WLWRB_L[61] WLWRB_L[62]
+   WLWRB_L[63] PAWRB[0] PBRDB[3] PBWRB[3] PCRDB[3] PCWRB[3] YSELRD[0] YSELRD[1]
+   YSELRD[2] YSELRD[3] SNPS_RF_DP_UHD_512x80_ary_x4dec_a_7
X_ary_x4dec_b_F7 ARYSD BKRDB BKRDB_128 CENDP DECBRD[16] DECBWR[16]
+   DECB_HV_RD[16] DECB_HV_WR[16] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+   FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0]
+   PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+   PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+   PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+   RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+   RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+   VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+   WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[64] WLRDB[65] WLRDB[66]
+   WLRDB[67] WLRDB_L[64] WLRDB_L[65] WLRDB_L[66] WLRDB_L[67] WLWRB[64]
+   WLWRB[65] WLWRB[66] WLWRB[67] WLWRB_L[64] WLWRB_L[65] WLWRB_L[66]
+   WLWRB_L[67] PAWRB[1] PBRDB[0] PBWRB[0] PCRDB[0] PCWRB[0] YSELRD[0] YSELRD[1]
+   YSELRD[2] YSELRD[3] SNPS_RF_DP_UHD_512x80_ary_x4dec_b_8
X_ary_x4dec_a_F7 ARYSD BKRDB BKRDB_128 CENDP DECBRD[17] DECBWR[17]
+   DECB_HV_RD[17] DECB_HV_WR[17] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+   FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0]
+   PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+   PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+   PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+   RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+   RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+   VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+   WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[68] WLRDB[69] WLRDB[70]
+   WLRDB[71] WLRDB_L[68] WLRDB_L[69] WLRDB_L[70] WLRDB_L[71] WLWRB[68]
+   WLWRB[69] WLWRB[70] WLWRB[71] WLWRB_L[68] WLWRB_L[69] WLWRB_L[70]
+   WLWRB_L[71] PAWRB[1] PBRDB[1] PBWRB[1] PCRDB[0] PCWRB[0] YSELRD[0] YSELRD[1]
+   YSELRD[2] YSELRD[3] SNPS_RF_DP_UHD_512x80_ary_x4dec_a_8
X_ary_x4dec_b_F6 ARYSD BKRDB BKRDB_128 CENDP DECBRD[18] DECBWR[18]
+   DECB_HV_RD[18] DECB_HV_WR[18] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+   FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0]
+   PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+   PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+   PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+   RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+   RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+   VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+   WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[72] WLRDB[73] WLRDB[74]
+   WLRDB[75] WLRDB_L[72] WLRDB_L[73] WLRDB_L[74] WLRDB_L[75] WLWRB[72]
+   WLWRB[73] WLWRB[74] WLWRB[75] WLWRB_L[72] WLWRB_L[73] WLWRB_L[74]
+   WLWRB_L[75] PAWRB[1] PBRDB[2] PBWRB[2] PCRDB[0] PCWRB[0] YSELRD[0] YSELRD[1]
+   YSELRD[2] YSELRD[3] SNPS_RF_DP_UHD_512x80_ary_x4dec_b_9
X_ary_x4dec_a_F6 ARYSD BKRDB BKRDB_128 CENDP DECBRD[19] DECBWR[19]
+   DECB_HV_RD[19] DECB_HV_WR[19] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+   FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0]
+   PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+   PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+   PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+   RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+   RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+   VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+   WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[76] WLRDB[77] WLRDB[78]
+   WLRDB[79] WLRDB_L[76] WLRDB_L[77] WLRDB_L[78] WLRDB_L[79] WLWRB[76]
+   WLWRB[77] WLWRB[78] WLWRB[79] WLWRB_L[76] WLWRB_L[77] WLWRB_L[78]
+   WLWRB_L[79] PAWRB[1] PBRDB[3] PBWRB[3] PCRDB[0] PCWRB[0] YSELRD[0] YSELRD[1]
+   YSELRD[2] YSELRD[3] SNPS_RF_DP_UHD_512x80_ary_x4dec_a_9
X_ary_x4dec_b_F5 ARYSD BKRDB BKRDB_128 CENDP DECBRD[20] DECBWR[20]
+   DECB_HV_RD[20] DECB_HV_WR[20] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+   FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0]
+   PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+   PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+   PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+   RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+   RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+   VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+   WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[80] WLRDB[81] WLRDB[82]
+   WLRDB[83] WLRDB_L[80] WLRDB_L[81] WLRDB_L[82] WLRDB_L[83] WLWRB[80]
+   WLWRB[81] WLWRB[82] WLWRB[83] WLWRB_L[80] WLWRB_L[81] WLWRB_L[82]
+   WLWRB_L[83] PAWRB[1] PBRDB[0] PBWRB[0] PCRDB[1] PCWRB[1] YSELRD[0] YSELRD[1]
+   YSELRD[2] YSELRD[3] SNPS_RF_DP_UHD_512x80_ary_x4dec_b_10
X_ary_x4dec_a_F5 ARYSD BKRDB BKRDB_128 CENDP DECBRD[21] DECBWR[21]
+   DECB_HV_RD[21] DECB_HV_WR[21] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+   FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0]
+   PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+   PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+   PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+   RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+   RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+   VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+   WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[84] WLRDB[85] WLRDB[86]
+   WLRDB[87] WLRDB_L[84] WLRDB_L[85] WLRDB_L[86] WLRDB_L[87] WLWRB[84]
+   WLWRB[85] WLWRB[86] WLWRB[87] WLWRB_L[84] WLWRB_L[85] WLWRB_L[86]
+   WLWRB_L[87] PAWRB[1] PBRDB[1] PBWRB[1] PCRDB[1] PCWRB[1] YSELRD[0] YSELRD[1]
+   YSELRD[2] YSELRD[3] SNPS_RF_DP_UHD_512x80_ary_x4dec_a_10
X_ary_x4dec_b_F4 ARYSD BKRDB BKRDB_128 CENDP DECBRD[22] DECBWR[22]
+   DECB_HV_RD[22] DECB_HV_WR[22] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+   FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0]
+   PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+   PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+   PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+   RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+   RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+   VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+   WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[88] WLRDB[89] WLRDB[90]
+   WLRDB[91] WLRDB_L[88] WLRDB_L[89] WLRDB_L[90] WLRDB_L[91] WLWRB[88]
+   WLWRB[89] WLWRB[90] WLWRB[91] WLWRB_L[88] WLWRB_L[89] WLWRB_L[90]
+   WLWRB_L[91] PAWRB[1] PBRDB[2] PBWRB[2] PCRDB[1] PCWRB[1] YSELRD[0] YSELRD[1]
+   YSELRD[2] YSELRD[3] SNPS_RF_DP_UHD_512x80_ary_x4dec_b_11
X_ary_x4dec_a_F4 ARYSD BKRDB BKRDB_128 CENDP DECBRD[23] DECBWR[23]
+   DECB_HV_RD[23] DECB_HV_WR[23] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+   FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0]
+   PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+   PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+   PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+   RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+   RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+   VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+   WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[92] WLRDB[93] WLRDB[94]
+   WLRDB[95] WLRDB_L[92] WLRDB_L[93] WLRDB_L[94] WLRDB_L[95] WLWRB[92]
+   WLWRB[93] WLWRB[94] WLWRB[95] WLWRB_L[92] WLWRB_L[93] WLWRB_L[94]
+   WLWRB_L[95] PAWRB[1] PBRDB[3] PBWRB[3] PCRDB[1] PCWRB[1] YSELRD[0] YSELRD[1]
+   YSELRD[2] YSELRD[3] SNPS_RF_DP_UHD_512x80_ary_x4dec_a_11
X_ary_x4dec_b_F3 ARYSD BKRDB BKRDB_128 CENDP DECBRD[24] DECBWR[24]
+   DECB_HV_RD[24] DECB_HV_WR[24] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+   FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0]
+   PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+   PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+   PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+   RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+   RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+   VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+   WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[96] WLRDB[97] WLRDB[98]
+   WLRDB[99] WLRDB_L[96] WLRDB_L[97] WLRDB_L[98] WLRDB_L[99] WLWRB[96]
+   WLWRB[97] WLWRB[98] WLWRB[99] WLWRB_L[96] WLWRB_L[97] WLWRB_L[98]
+   WLWRB_L[99] PAWRB[1] PBRDB[0] PBWRB[0] PCRDB[2] PCWRB[2] YSELRD[0] YSELRD[1]
+   YSELRD[2] YSELRD[3] SNPS_RF_DP_UHD_512x80_ary_x4dec_b_12
X_ary_x4dec_a_F3 ARYSD BKRDB BKRDB_128 CENDP DECBRD[25] DECBWR[25]
+   DECB_HV_RD[25] DECB_HV_WR[25] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+   FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0]
+   PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+   PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+   PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+   RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+   RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+   VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+   WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[100] WLRDB[101] WLRDB[102]
+   WLRDB[103] WLRDB_L[100] WLRDB_L[101] WLRDB_L[102] WLRDB_L[103] WLWRB[100]
+   WLWRB[101] WLWRB[102] WLWRB[103] WLWRB_L[100] WLWRB_L[101] WLWRB_L[102]
+   WLWRB_L[103] PAWRB[1] PBRDB[1] PBWRB[1] PCRDB[2] PCWRB[2] YSELRD[0]
+   YSELRD[1] YSELRD[2] YSELRD[3] SNPS_RF_DP_UHD_512x80_ary_x4dec_a_12
X_ary_x4dec_b_F2 ARYSD BKRDB BKRDB_128 CENDP DECBRD[26] DECBWR[26]
+   DECB_HV_RD[26] DECB_HV_WR[26] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+   FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0]
+   PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+   PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+   PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+   RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+   RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+   VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+   WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[104] WLRDB[105] WLRDB[106]
+   WLRDB[107] WLRDB_L[104] WLRDB_L[105] WLRDB_L[106] WLRDB_L[107] WLWRB[104]
+   WLWRB[105] WLWRB[106] WLWRB[107] WLWRB_L[104] WLWRB_L[105] WLWRB_L[106]
+   WLWRB_L[107] PAWRB[1] PBRDB[2] PBWRB[2] PCRDB[2] PCWRB[2] YSELRD[0]
+   YSELRD[1] YSELRD[2] YSELRD[3] SNPS_RF_DP_UHD_512x80_ary_x4dec_b_13
X_ary_x4dec_a_F2 ARYSD BKRDB BKRDB_128 CENDP DECBRD[27] DECBWR[27]
+   DECB_HV_RD[27] DECB_HV_WR[27] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+   FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0]
+   PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+   PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+   PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+   RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+   RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+   VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+   WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[108] WLRDB[109] WLRDB[110]
+   WLRDB[111] WLRDB_L[108] WLRDB_L[109] WLRDB_L[110] WLRDB_L[111] WLWRB[108]
+   WLWRB[109] WLWRB[110] WLWRB[111] WLWRB_L[108] WLWRB_L[109] WLWRB_L[110]
+   WLWRB_L[111] PAWRB[1] PBRDB[3] PBWRB[3] PCRDB[2] PCWRB[2] YSELRD[0]
+   YSELRD[1] YSELRD[2] YSELRD[3] SNPS_RF_DP_UHD_512x80_ary_x4dec_a_13
X_ary_x4dec_b_F1 ARYSD BKRDB BKRDB_128 CENDP DECBRD[28] DECBWR[28]
+   DECB_HV_RD[28] DECB_HV_WR[28] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+   FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0]
+   PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+   PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+   PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+   RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+   RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+   VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+   WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[112] WLRDB[113] WLRDB[114]
+   WLRDB[115] WLRDB_L[112] WLRDB_L[113] WLRDB_L[114] WLRDB_L[115] WLWRB[112]
+   WLWRB[113] WLWRB[114] WLWRB[115] WLWRB_L[112] WLWRB_L[113] WLWRB_L[114]
+   WLWRB_L[115] PAWRB[1] PBRDB[0] PBWRB[0] PCRDB[3] PCWRB[3] YSELRD[0]
+   YSELRD[1] YSELRD[2] YSELRD[3] SNPS_RF_DP_UHD_512x80_ary_x4dec_b_14
X_ary_x4dec_a_F1 ARYSD BKRDB BKRDB_128 CENDP DECBRD[29] DECBWR[29]
+   DECB_HV_RD[29] DECB_HV_WR[29] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+   FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0]
+   PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+   PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+   PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+   RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+   RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+   VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+   WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[116] WLRDB[117] WLRDB[118]
+   WLRDB[119] WLRDB_L[116] WLRDB_L[117] WLRDB_L[118] WLRDB_L[119] WLWRB[116]
+   WLWRB[117] WLWRB[118] WLWRB[119] WLWRB_L[116] WLWRB_L[117] WLWRB_L[118]
+   WLWRB_L[119] PAWRB[1] PBRDB[1] PBWRB[1] PCRDB[3] PCWRB[3] YSELRD[0]
+   YSELRD[1] YSELRD[2] YSELRD[3] SNPS_RF_DP_UHD_512x80_ary_x4dec_a_14
X_ary_x4dec_b_F0 ARYSD BKRDB BKRDB_128 CENDP DECBRD[30] DECBWR[30]
+   DECB_HV_RD[30] DECB_HV_WR[30] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+   FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0]
+   PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+   PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+   PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+   RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+   RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+   VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+   WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[120] WLRDB[121] WLRDB[122]
+   WLRDB[123] WLRDB_L[120] WLRDB_L[121] WLRDB_L[122] WLRDB_L[123] WLWRB[120]
+   WLWRB[121] WLWRB[122] WLWRB[123] WLWRB_L[120] WLWRB_L[121] WLWRB_L[122]
+   WLWRB_L[123] PAWRB[1] PBRDB[2] PBWRB[2] PCRDB[3] PCWRB[3] YSELRD[0]
+   YSELRD[1] YSELRD[2] YSELRD[3] SNPS_RF_DP_UHD_512x80_ary_x4dec_b_15
X_ary_x4dec_a_F0 ARYSD BKRDB BKRDB_128 CENDP DECBRD[31] DECBWR[31]
+   DECB_HV_RD[31] DECB_HV_WR[31] DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD
+   FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0]
+   PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+   PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+   PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+   RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+   RWLB_WR T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAPI VDDF VDDP VDDPI VDDWL_RD
+   VDDWL_WR VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+   WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRDB[124] WLRDB[125] WLRDB[126]
+   WLRDB[127] WLRDB_L[124] WLRDB_L[125] WLRDB_L[126] WLRDB_L[127] WLWRB[124]
+   WLWRB[125] WLWRB[126] WLWRB[127] WLWRB_L[124] WLWRB_L[125] WLWRB_L[126]
+   WLWRB_L[127] PAWRB[1] PBRDB[3] PBWRB[3] PCRDB[3] PCWRB[3] YSELRD[0]
+   YSELRD[1] YSELRD[2] YSELRD[3] SNPS_RF_DP_UHD_512x80_ary_x4dec_a_15
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_buf DMY_EDGE_LT[1] DMY_EDGE_LT[32] LCGTV
+       RASSB[0] RASSB[1] VBN VBP VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS WLRD[0]
+       WLRD[1] WLRD[2] WLRD[3] WLRD[4] WLRD[5] WLRD[6] WLRD[7] WLRD[8] WLRD[9]
+       WLRD[10] WLRD[11] WLRD[12] WLRD[13] WLRD[14] WLRD[15] WLRD[16] WLRD[17]
+       WLRD[18] WLRD[19] WLRD[20] WLRD[21] WLRD[22] WLRD[23] WLRD[24] WLRD[25]
+       WLRD[26] WLRD[27] WLRD[28] WLRD[29] WLRD[30] WLRD[31] WLRD[32] WLRD[33]
+       WLRD[34] WLRD[35] WLRD[36] WLRD[37] WLRD[38] WLRD[39] WLRD[40] WLRD[41]
+       WLRD[42] WLRD[43] WLRD[44] WLRD[45] WLRD[46] WLRD[47] WLRD[48] WLRD[49]
+       WLRD[50] WLRD[51] WLRD[52] WLRD[53] WLRD[54] WLRD[55] WLRD[56] WLRD[57]
+       WLRD[58] WLRD[59] WLRD[60] WLRD[61] WLRD[62] WLRD[63] WLRD[64] WLRD[65]
+       WLRD[66] WLRD[67] WLRD[68] WLRD[69] WLRD[70] WLRD[71] WLRD[72] WLRD[73]
+       WLRD[74] WLRD[75] WLRD[76] WLRD[77] WLRD[78] WLRD[79] WLRD[80] WLRD[81]
+       WLRD[82] WLRD[83] WLRD[84] WLRD[85] WLRD[86] WLRD[87] WLRD[88] WLRD[89]
+       WLRD[90] WLRD[91] WLRD[92] WLRD[93] WLRD[94] WLRD[95] WLRD[96] WLRD[97]
+       WLRD[98] WLRD[99] WLRD[100] WLRD[101] WLRD[102] WLRD[103] WLRD[104]
+       WLRD[105] WLRD[106] WLRD[107] WLRD[108] WLRD[109] WLRD[110] WLRD[111]
+       WLRD[112] WLRD[113] WLRD[114] WLRD[115] WLRD[116] WLRD[117] WLRD[118]
+       WLRD[119] WLRD[120] WLRD[121] WLRD[122] WLRD[123] WLRD[124] WLRD[125]
+       WLRD[126] WLRD[127] WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB[4]
+       WLRDB[5] WLRDB[6] WLRDB[7] WLRDB[8] WLRDB[9] WLRDB[10] WLRDB[11]
+       WLRDB[12] WLRDB[13] WLRDB[14] WLRDB[15] WLRDB[16] WLRDB[17] WLRDB[18]
+       WLRDB[19] WLRDB[20] WLRDB[21] WLRDB[22] WLRDB[23] WLRDB[24] WLRDB[25]
+       WLRDB[26] WLRDB[27] WLRDB[28] WLRDB[29] WLRDB[30] WLRDB[31] WLRDB[32]
+       WLRDB[33] WLRDB[34] WLRDB[35] WLRDB[36] WLRDB[37] WLRDB[38] WLRDB[39]
+       WLRDB[40] WLRDB[41] WLRDB[42] WLRDB[43] WLRDB[44] WLRDB[45] WLRDB[46]
+       WLRDB[47] WLRDB[48] WLRDB[49] WLRDB[50] WLRDB[51] WLRDB[52] WLRDB[53]
+       WLRDB[54] WLRDB[55] WLRDB[56] WLRDB[57] WLRDB[58] WLRDB[59] WLRDB[60]
+       WLRDB[61] WLRDB[62] WLRDB[63] WLRDB[64] WLRDB[65] WLRDB[66] WLRDB[67]
+       WLRDB[68] WLRDB[69] WLRDB[70] WLRDB[71] WLRDB[72] WLRDB[73] WLRDB[74]
+       WLRDB[75] WLRDB[76] WLRDB[77] WLRDB[78] WLRDB[79] WLRDB[80] WLRDB[81]
+       WLRDB[82] WLRDB[83] WLRDB[84] WLRDB[85] WLRDB[86] WLRDB[87] WLRDB[88]
+       WLRDB[89] WLRDB[90] WLRDB[91] WLRDB[92] WLRDB[93] WLRDB[94] WLRDB[95]
+       WLRDB[96] WLRDB[97] WLRDB[98] WLRDB[99] WLRDB[100] WLRDB[101] WLRDB[102]
+       WLRDB[103] WLRDB[104] WLRDB[105] WLRDB[106] WLRDB[107] WLRDB[108]
+       WLRDB[109] WLRDB[110] WLRDB[111] WLRDB[112] WLRDB[113] WLRDB[114]
+       WLRDB[115] WLRDB[116] WLRDB[117] WLRDB[118] WLRDB[119] WLRDB[120]
+       WLRDB[121] WLRDB[122] WLRDB[123] WLRDB[124] WLRDB[125] WLRDB[126]
+       WLRDB[127] WLWR[0] WLWR[1] WLWR[2] WLWR[3] WLWR[4] WLWR[5] WLWR[6]
+       WLWR[7] WLWR[8] WLWR[9] WLWR[10] WLWR[11] WLWR[12] WLWR[13] WLWR[14]
+       WLWR[15] WLWR[16] WLWR[17] WLWR[18] WLWR[19] WLWR[20] WLWR[21] WLWR[22]
+       WLWR[23] WLWR[24] WLWR[25] WLWR[26] WLWR[27] WLWR[28] WLWR[29] WLWR[30]
+       WLWR[31] WLWR[32] WLWR[33] WLWR[34] WLWR[35] WLWR[36] WLWR[37] WLWR[38]
+       WLWR[39] WLWR[40] WLWR[41] WLWR[42] WLWR[43] WLWR[44] WLWR[45] WLWR[46]
+       WLWR[47] WLWR[48] WLWR[49] WLWR[50] WLWR[51] WLWR[52] WLWR[53] WLWR[54]
+       WLWR[55] WLWR[56] WLWR[57] WLWR[58] WLWR[59] WLWR[60] WLWR[61] WLWR[62]
+       WLWR[63] WLWR[64] WLWR[65] WLWR[66] WLWR[67] WLWR[68] WLWR[69] WLWR[70]
+       WLWR[71] WLWR[72] WLWR[73] WLWR[74] WLWR[75] WLWR[76] WLWR[77] WLWR[78]
+       WLWR[79] WLWR[80] WLWR[81] WLWR[82] WLWR[83] WLWR[84] WLWR[85] WLWR[86]
+       WLWR[87] WLWR[88] WLWR[89] WLWR[90] WLWR[91] WLWR[92] WLWR[93] WLWR[94]
+       WLWR[95] WLWR[96] WLWR[97] WLWR[98] WLWR[99] WLWR[100] WLWR[101]
+       WLWR[102] WLWR[103] WLWR[104] WLWR[105] WLWR[106] WLWR[107] WLWR[108]
+       WLWR[109] WLWR[110] WLWR[111] WLWR[112] WLWR[113] WLWR[114] WLWR[115]
+       WLWR[116] WLWR[117] WLWR[118] WLWR[119] WLWR[120] WLWR[121] WLWR[122]
+       WLWR[123] WLWR[124] WLWR[125] WLWR[126] WLWR[127] WLWRB[0] WLWRB[1]
+       WLWRB[2] WLWRB[3] WLWRB[4] WLWRB[5] WLWRB[6] WLWRB[7] WLWRB[8] WLWRB[9]
+       WLWRB[10] WLWRB[11] WLWRB[12] WLWRB[13] WLWRB[14] WLWRB[15] WLWRB[16]
+       WLWRB[17] WLWRB[18] WLWRB[19] WLWRB[20] WLWRB[21] WLWRB[22] WLWRB[23]
+       WLWRB[24] WLWRB[25] WLWRB[26] WLWRB[27] WLWRB[28] WLWRB[29] WLWRB[30]
+       WLWRB[31] WLWRB[32] WLWRB[33] WLWRB[34] WLWRB[35] WLWRB[36] WLWRB[37]
+       WLWRB[38] WLWRB[39] WLWRB[40] WLWRB[41] WLWRB[42] WLWRB[43] WLWRB[44]
+       WLWRB[45] WLWRB[46] WLWRB[47] WLWRB[48] WLWRB[49] WLWRB[50] WLWRB[51]
+       WLWRB[52] WLWRB[53] WLWRB[54] WLWRB[55] WLWRB[56] WLWRB[57] WLWRB[58]
+       WLWRB[59] WLWRB[60] WLWRB[61] WLWRB[62] WLWRB[63] WLWRB[64] WLWRB[65]
+       WLWRB[66] WLWRB[67] WLWRB[68] WLWRB[69] WLWRB[70] WLWRB[71] WLWRB[72]
+       WLWRB[73] WLWRB[74] WLWRB[75] WLWRB[76] WLWRB[77] WLWRB[78] WLWRB[79]
+       WLWRB[80] WLWRB[81] WLWRB[82] WLWRB[83] WLWRB[84] WLWRB[85] WLWRB[86]
+       WLWRB[87] WLWRB[88] WLWRB[89] WLWRB[90] WLWRB[91] WLWRB[92] WLWRB[93]
+       WLWRB[94] WLWRB[95] WLWRB[96] WLWRB[97] WLWRB[98] WLWRB[99] WLWRB[100]
+       WLWRB[101] WLWRB[102] WLWRB[103] WLWRB[104] WLWRB[105] WLWRB[106]
+       WLWRB[107] WLWRB[108] WLWRB[109] WLWRB[110] WLWRB[111] WLWRB[112]
+       WLWRB[113] WLWRB[114] WLWRB[115] WLWRB[116] WLWRB[117] WLWRB[118]
+       WLWRB[119] WLWRB[120] WLWRB[121] WLWRB[122] WLWRB[123] WLWRB[124]
+       WLWRB[125] WLWRB[126] WLWRB[127]
X_mm17a04_u_hdrf2p_x4buf_b_S0 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[0] WLRD[1] WLRD[2] WLRD[3] WLWR[0] WLWR[1] WLWR[2] WLWR[3]
+   DMY_EDGE_LT[1] DMY_EDGE_LT[0] LCGTV RASSB[0] RASSB[1] WLRDB[0] WLRDB[1]
+   WLRDB[2] WLRDB[3] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3] mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_a_S0 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[4] WLRD[5] WLRD[6] WLRD[7] WLWR[4] WLWR[5] WLWR[6] WLWR[7]
+   DMY_EDGE_LT[0] DMY_EDGE_LT[2] LCGTV RASSB[0] RASSB[1] WLRDB[4] WLRDB[5]
+   WLRDB[6] WLRDB[7] WLWRB[4] WLWRB[5] WLWRB[6] WLWRB[7] mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_b_S1 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[8] WLRD[9] WLRD[10] WLRD[11] WLWR[8] WLWR[9] WLWR[10] WLWR[11]
+   DMY_EDGE_LT[2] DMY_EDGE_LT[3] LCGTV RASSB[0] RASSB[1] WLRDB[8] WLRDB[9]
+   WLRDB[10] WLRDB[11] WLWRB[8] WLWRB[9] WLWRB[10] WLWRB[11]
+   mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_a_S1 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[12] WLRD[13] WLRD[14] WLRD[15] WLWR[12] WLWR[13] WLWR[14] WLWR[15]
+   DMY_EDGE_LT[3] DMY_EDGE_LT[4] LCGTV RASSB[0] RASSB[1] WLRDB[12] WLRDB[13]
+   WLRDB[14] WLRDB[15] WLWRB[12] WLWRB[13] WLWRB[14] WLWRB[15]
+   mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_b_S2 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[16] WLRD[17] WLRD[18] WLRD[19] WLWR[16] WLWR[17] WLWR[18] WLWR[19]
+   DMY_EDGE_LT[4] DMY_EDGE_LT[5] LCGTV RASSB[0] RASSB[1] WLRDB[16] WLRDB[17]
+   WLRDB[18] WLRDB[19] WLWRB[16] WLWRB[17] WLWRB[18] WLWRB[19]
+   mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_a_S2 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[20] WLRD[21] WLRD[22] WLRD[23] WLWR[20] WLWR[21] WLWR[22] WLWR[23]
+   DMY_EDGE_LT[5] DMY_EDGE_LT[6] LCGTV RASSB[0] RASSB[1] WLRDB[20] WLRDB[21]
+   WLRDB[22] WLRDB[23] WLWRB[20] WLWRB[21] WLWRB[22] WLWRB[23]
+   mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_b_S3 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[24] WLRD[25] WLRD[26] WLRD[27] WLWR[24] WLWR[25] WLWR[26] WLWR[27]
+   DMY_EDGE_LT[6] DMY_EDGE_LT[7] LCGTV RASSB[0] RASSB[1] WLRDB[24] WLRDB[25]
+   WLRDB[26] WLRDB[27] WLWRB[24] WLWRB[25] WLWRB[26] WLWRB[27]
+   mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_a_S3 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[28] WLRD[29] WLRD[30] WLRD[31] WLWR[28] WLWR[29] WLWR[30] WLWR[31]
+   DMY_EDGE_LT[7] DMY_EDGE_LT[8] LCGTV RASSB[0] RASSB[1] WLRDB[28] WLRDB[29]
+   WLRDB[30] WLRDB[31] WLWRB[28] WLWRB[29] WLWRB[30] WLWRB[31]
+   mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_b_S4 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[32] WLRD[33] WLRD[34] WLRD[35] WLWR[32] WLWR[33] WLWR[34] WLWR[35]
+   DMY_EDGE_LT[8] DMY_EDGE_LT[9] LCGTV RASSB[0] RASSB[1] WLRDB[32] WLRDB[33]
+   WLRDB[34] WLRDB[35] WLWRB[32] WLWRB[33] WLWRB[34] WLWRB[35]
+   mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_a_S4 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[36] WLRD[37] WLRD[38] WLRD[39] WLWR[36] WLWR[37] WLWR[38] WLWR[39]
+   DMY_EDGE_LT[9] DMY_EDGE_LT[10] LCGTV RASSB[0] RASSB[1] WLRDB[36] WLRDB[37]
+   WLRDB[38] WLRDB[39] WLWRB[36] WLWRB[37] WLWRB[38] WLWRB[39]
+   mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_b_S5 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[40] WLRD[41] WLRD[42] WLRD[43] WLWR[40] WLWR[41] WLWR[42] WLWR[43]
+   DMY_EDGE_LT[10] DMY_EDGE_LT[11] LCGTV RASSB[0] RASSB[1] WLRDB[40] WLRDB[41]
+   WLRDB[42] WLRDB[43] WLWRB[40] WLWRB[41] WLWRB[42] WLWRB[43]
+   mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_a_S5 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[44] WLRD[45] WLRD[46] WLRD[47] WLWR[44] WLWR[45] WLWR[46] WLWR[47]
+   DMY_EDGE_LT[11] DMY_EDGE_LT[12] LCGTV RASSB[0] RASSB[1] WLRDB[44] WLRDB[45]
+   WLRDB[46] WLRDB[47] WLWRB[44] WLWRB[45] WLWRB[46] WLWRB[47]
+   mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_b_S6 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[48] WLRD[49] WLRD[50] WLRD[51] WLWR[48] WLWR[49] WLWR[50] WLWR[51]
+   DMY_EDGE_LT[12] DMY_EDGE_LT[13] LCGTV RASSB[0] RASSB[1] WLRDB[48] WLRDB[49]
+   WLRDB[50] WLRDB[51] WLWRB[48] WLWRB[49] WLWRB[50] WLWRB[51]
+   mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_a_S6 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[52] WLRD[53] WLRD[54] WLRD[55] WLWR[52] WLWR[53] WLWR[54] WLWR[55]
+   DMY_EDGE_LT[13] DMY_EDGE_LT[14] LCGTV RASSB[0] RASSB[1] WLRDB[52] WLRDB[53]
+   WLRDB[54] WLRDB[55] WLWRB[52] WLWRB[53] WLWRB[54] WLWRB[55]
+   mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_b_S7 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[56] WLRD[57] WLRD[58] WLRD[59] WLWR[56] WLWR[57] WLWR[58] WLWR[59]
+   DMY_EDGE_LT[14] DMY_EDGE_LT[15] LCGTV RASSB[0] RASSB[1] WLRDB[56] WLRDB[57]
+   WLRDB[58] WLRDB[59] WLWRB[56] WLWRB[57] WLWRB[58] WLWRB[59]
+   mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_a_S7 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[60] WLRD[61] WLRD[62] WLRD[63] WLWR[60] WLWR[61] WLWR[62] WLWR[63]
+   DMY_EDGE_LT[15] DMY_EDGE_LT[16] LCGTV RASSB[0] RASSB[1] WLRDB[60] WLRDB[61]
+   WLRDB[62] WLRDB[63] WLWRB[60] WLWRB[61] WLWRB[62] WLWRB[63]
+   mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_b_F7 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[64] WLRD[65] WLRD[66] WLRD[67] WLWR[64] WLWR[65] WLWR[66] WLWR[67]
+   DMY_EDGE_LT[16] DMY_EDGE_LT[17] LCGTV RASSB[0] RASSB[1] WLRDB[64] WLRDB[65]
+   WLRDB[66] WLRDB[67] WLWRB[64] WLWRB[65] WLWRB[66] WLWRB[67]
+   mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_a_F7 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[68] WLRD[69] WLRD[70] WLRD[71] WLWR[68] WLWR[69] WLWR[70] WLWR[71]
+   DMY_EDGE_LT[17] DMY_EDGE_LT[18] LCGTV RASSB[0] RASSB[1] WLRDB[68] WLRDB[69]
+   WLRDB[70] WLRDB[71] WLWRB[68] WLWRB[69] WLWRB[70] WLWRB[71]
+   mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_b_F6 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[72] WLRD[73] WLRD[74] WLRD[75] WLWR[72] WLWR[73] WLWR[74] WLWR[75]
+   DMY_EDGE_LT[18] DMY_EDGE_LT[19] LCGTV RASSB[0] RASSB[1] WLRDB[72] WLRDB[73]
+   WLRDB[74] WLRDB[75] WLWRB[72] WLWRB[73] WLWRB[74] WLWRB[75]
+   mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_a_F6 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[76] WLRD[77] WLRD[78] WLRD[79] WLWR[76] WLWR[77] WLWR[78] WLWR[79]
+   DMY_EDGE_LT[19] DMY_EDGE_LT[20] LCGTV RASSB[0] RASSB[1] WLRDB[76] WLRDB[77]
+   WLRDB[78] WLRDB[79] WLWRB[76] WLWRB[77] WLWRB[78] WLWRB[79]
+   mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_b_F5 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[80] WLRD[81] WLRD[82] WLRD[83] WLWR[80] WLWR[81] WLWR[82] WLWR[83]
+   DMY_EDGE_LT[20] DMY_EDGE_LT[21] LCGTV RASSB[0] RASSB[1] WLRDB[80] WLRDB[81]
+   WLRDB[82] WLRDB[83] WLWRB[80] WLWRB[81] WLWRB[82] WLWRB[83]
+   mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_a_F5 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[84] WLRD[85] WLRD[86] WLRD[87] WLWR[84] WLWR[85] WLWR[86] WLWR[87]
+   DMY_EDGE_LT[21] DMY_EDGE_LT[22] LCGTV RASSB[0] RASSB[1] WLRDB[84] WLRDB[85]
+   WLRDB[86] WLRDB[87] WLWRB[84] WLWRB[85] WLWRB[86] WLWRB[87]
+   mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_b_F4 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[88] WLRD[89] WLRD[90] WLRD[91] WLWR[88] WLWR[89] WLWR[90] WLWR[91]
+   DMY_EDGE_LT[22] DMY_EDGE_LT[23] LCGTV RASSB[0] RASSB[1] WLRDB[88] WLRDB[89]
+   WLRDB[90] WLRDB[91] WLWRB[88] WLWRB[89] WLWRB[90] WLWRB[91]
+   mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_a_F4 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[92] WLRD[93] WLRD[94] WLRD[95] WLWR[92] WLWR[93] WLWR[94] WLWR[95]
+   DMY_EDGE_LT[23] DMY_EDGE_LT[24] LCGTV RASSB[0] RASSB[1] WLRDB[92] WLRDB[93]
+   WLRDB[94] WLRDB[95] WLWRB[92] WLWRB[93] WLWRB[94] WLWRB[95]
+   mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_b_F3 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[96] WLRD[97] WLRD[98] WLRD[99] WLWR[96] WLWR[97] WLWR[98] WLWR[99]
+   DMY_EDGE_LT[24] DMY_EDGE_LT[25] LCGTV RASSB[0] RASSB[1] WLRDB[96] WLRDB[97]
+   WLRDB[98] WLRDB[99] WLWRB[96] WLWRB[97] WLWRB[98] WLWRB[99]
+   mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_a_F3 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[100] WLRD[101] WLRD[102] WLRD[103] WLWR[100] WLWR[101] WLWR[102]
+   WLWR[103] DMY_EDGE_LT[25] DMY_EDGE_LT[26] LCGTV RASSB[0] RASSB[1] WLRDB[100]
+   WLRDB[101] WLRDB[102] WLRDB[103] WLWRB[100] WLWRB[101] WLWRB[102] WLWRB[103]
+   mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_b_F2 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[104] WLRD[105] WLRD[106] WLRD[107] WLWR[104] WLWR[105] WLWR[106]
+   WLWR[107] DMY_EDGE_LT[26] DMY_EDGE_LT[27] LCGTV RASSB[0] RASSB[1] WLRDB[104]
+   WLRDB[105] WLRDB[106] WLRDB[107] WLWRB[104] WLWRB[105] WLWRB[106] WLWRB[107]
+   mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_a_F2 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[108] WLRD[109] WLRD[110] WLRD[111] WLWR[108] WLWR[109] WLWR[110]
+   WLWR[111] DMY_EDGE_LT[27] DMY_EDGE_LT[28] LCGTV RASSB[0] RASSB[1] WLRDB[108]
+   WLRDB[109] WLRDB[110] WLRDB[111] WLWRB[108] WLWRB[109] WLWRB[110] WLWRB[111]
+   mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_b_F1 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[112] WLRD[113] WLRD[114] WLRD[115] WLWR[112] WLWR[113] WLWR[114]
+   WLWR[115] DMY_EDGE_LT[28] DMY_EDGE_LT[29] LCGTV RASSB[0] RASSB[1] WLRDB[112]
+   WLRDB[113] WLRDB[114] WLRDB[115] WLWRB[112] WLWRB[113] WLWRB[114] WLWRB[115]
+   mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_a_F1 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[116] WLRD[117] WLRD[118] WLRD[119] WLWR[116] WLWR[117] WLWR[118]
+   WLWR[119] DMY_EDGE_LT[29] DMY_EDGE_LT[30] LCGTV RASSB[0] RASSB[1] WLRDB[116]
+   WLRDB[117] WLRDB[118] WLRDB[119] WLWRB[116] WLWRB[117] WLWRB[118] WLWRB[119]
+   mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_b_F0 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[120] WLRD[121] WLRD[122] WLRD[123] WLWR[120] WLWR[121] WLWR[122]
+   WLWR[123] DMY_EDGE_LT[30] DMY_EDGE_LT[31] LCGTV RASSB[0] RASSB[1] WLRDB[120]
+   WLRDB[121] WLRDB[122] WLRDB[123] WLWRB[120] WLWRB[121] WLWRB[122] WLWRB[123]
+   mm17a04_u_hdrf2p_x4buf
X_mm17a04_u_hdrf2p_x4buf_a_F0 VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS VBP VBN
+   WLRD[124] WLRD[125] WLRD[126] WLRD[127] WLWR[124] WLWR[125] WLWR[126]
+   WLWR[127] DMY_EDGE_LT[31] DMY_EDGE_LT[32] LCGTV RASSB[0] RASSB[1] WLRDB[124]
+   WLRDB[125] WLRDB[126] WLRDB[127] WLWRB[124] WLWRB[125] WLWRB[126] WLWRB[127]
+   mm17a04_u_hdrf2p_x4buf
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_buf_lsh DMY_EDGE_LT[0] DMY_EDGE_LT[1] LCGTV
+       RASSB_H[0] RASSB_H[1] VBN VBP VDDA VDDP VDDPI VDDWL_RD VDDWL_WR VSS
+       WLRD[0] WLRD[1] WLRD[2] WLRD[3] WLRD[4] WLRD[5] WLRD[6] WLRD[7] WLRD[8]
+       WLRD[9] WLRD[10] WLRD[11] WLRD[12] WLRD[13] WLRD[14] WLRD[15] WLRD[16]
+       WLRD[17] WLRD[18] WLRD[19] WLRD[20] WLRD[21] WLRD[22] WLRD[23] WLRD[24]
+       WLRD[25] WLRD[26] WLRD[27] WLRD[28] WLRD[29] WLRD[30] WLRD[31] WLRD[32]
+       WLRD[33] WLRD[34] WLRD[35] WLRD[36] WLRD[37] WLRD[38] WLRD[39] WLRD[40]
+       WLRD[41] WLRD[42] WLRD[43] WLRD[44] WLRD[45] WLRD[46] WLRD[47] WLRD[48]
+       WLRD[49] WLRD[50] WLRD[51] WLRD[52] WLRD[53] WLRD[54] WLRD[55] WLRD[56]
+       WLRD[57] WLRD[58] WLRD[59] WLRD[60] WLRD[61] WLRD[62] WLRD[63] WLRD[64]
+       WLRD[65] WLRD[66] WLRD[67] WLRD[68] WLRD[69] WLRD[70] WLRD[71] WLRD[72]
+       WLRD[73] WLRD[74] WLRD[75] WLRD[76] WLRD[77] WLRD[78] WLRD[79] WLRD[80]
+       WLRD[81] WLRD[82] WLRD[83] WLRD[84] WLRD[85] WLRD[86] WLRD[87] WLRD[88]
+       WLRD[89] WLRD[90] WLRD[91] WLRD[92] WLRD[93] WLRD[94] WLRD[95] WLRD[96]
+       WLRD[97] WLRD[98] WLRD[99] WLRD[100] WLRD[101] WLRD[102] WLRD[103]
+       WLRD[104] WLRD[105] WLRD[106] WLRD[107] WLRD[108] WLRD[109] WLRD[110]
+       WLRD[111] WLRD[112] WLRD[113] WLRD[114] WLRD[115] WLRD[116] WLRD[117]
+       WLRD[118] WLRD[119] WLRD[120] WLRD[121] WLRD[122] WLRD[123] WLRD[124]
+       WLRD[125] WLRD[126] WLRD[127] WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3]
+       WLRDB[4] WLRDB[5] WLRDB[6] WLRDB[7] WLRDB[8] WLRDB[9] WLRDB[10]
+       WLRDB[11] WLRDB[12] WLRDB[13] WLRDB[14] WLRDB[15] WLRDB[16] WLRDB[17]
+       WLRDB[18] WLRDB[19] WLRDB[20] WLRDB[21] WLRDB[22] WLRDB[23] WLRDB[24]
+       WLRDB[25] WLRDB[26] WLRDB[27] WLRDB[28] WLRDB[29] WLRDB[30] WLRDB[31]
+       WLRDB[32] WLRDB[33] WLRDB[34] WLRDB[35] WLRDB[36] WLRDB[37] WLRDB[38]
+       WLRDB[39] WLRDB[40] WLRDB[41] WLRDB[42] WLRDB[43] WLRDB[44] WLRDB[45]
+       WLRDB[46] WLRDB[47] WLRDB[48] WLRDB[49] WLRDB[50] WLRDB[51] WLRDB[52]
+       WLRDB[53] WLRDB[54] WLRDB[55] WLRDB[56] WLRDB[57] WLRDB[58] WLRDB[59]
+       WLRDB[60] WLRDB[61] WLRDB[62] WLRDB[63] WLRDB[64] WLRDB[65] WLRDB[66]
+       WLRDB[67] WLRDB[68] WLRDB[69] WLRDB[70] WLRDB[71] WLRDB[72] WLRDB[73]
+       WLRDB[74] WLRDB[75] WLRDB[76] WLRDB[77] WLRDB[78] WLRDB[79] WLRDB[80]
+       WLRDB[81] WLRDB[82] WLRDB[83] WLRDB[84] WLRDB[85] WLRDB[86] WLRDB[87]
+       WLRDB[88] WLRDB[89] WLRDB[90] WLRDB[91] WLRDB[92] WLRDB[93] WLRDB[94]
+       WLRDB[95] WLRDB[96] WLRDB[97] WLRDB[98] WLRDB[99] WLRDB[100] WLRDB[101]
+       WLRDB[102] WLRDB[103] WLRDB[104] WLRDB[105] WLRDB[106] WLRDB[107]
+       WLRDB[108] WLRDB[109] WLRDB[110] WLRDB[111] WLRDB[112] WLRDB[113]
+       WLRDB[114] WLRDB[115] WLRDB[116] WLRDB[117] WLRDB[118] WLRDB[119]
+       WLRDB[120] WLRDB[121] WLRDB[122] WLRDB[123] WLRDB[124] WLRDB[125]
+       WLRDB[126] WLRDB[127] WLWR[0] WLWR[1] WLWR[2] WLWR[3] WLWR[4] WLWR[5]
+       WLWR[6] WLWR[7] WLWR[8] WLWR[9] WLWR[10] WLWR[11] WLWR[12] WLWR[13]
+       WLWR[14] WLWR[15] WLWR[16] WLWR[17] WLWR[18] WLWR[19] WLWR[20] WLWR[21]
+       WLWR[22] WLWR[23] WLWR[24] WLWR[25] WLWR[26] WLWR[27] WLWR[28] WLWR[29]
+       WLWR[30] WLWR[31] WLWR[32] WLWR[33] WLWR[34] WLWR[35] WLWR[36] WLWR[37]
+       WLWR[38] WLWR[39] WLWR[40] WLWR[41] WLWR[42] WLWR[43] WLWR[44] WLWR[45]
+       WLWR[46] WLWR[47] WLWR[48] WLWR[49] WLWR[50] WLWR[51] WLWR[52] WLWR[53]
+       WLWR[54] WLWR[55] WLWR[56] WLWR[57] WLWR[58] WLWR[59] WLWR[60] WLWR[61]
+       WLWR[62] WLWR[63] WLWR[64] WLWR[65] WLWR[66] WLWR[67] WLWR[68] WLWR[69]
+       WLWR[70] WLWR[71] WLWR[72] WLWR[73] WLWR[74] WLWR[75] WLWR[76] WLWR[77]
+       WLWR[78] WLWR[79] WLWR[80] WLWR[81] WLWR[82] WLWR[83] WLWR[84] WLWR[85]
+       WLWR[86] WLWR[87] WLWR[88] WLWR[89] WLWR[90] WLWR[91] WLWR[92] WLWR[93]
+       WLWR[94] WLWR[95] WLWR[96] WLWR[97] WLWR[98] WLWR[99] WLWR[100]
+       WLWR[101] WLWR[102] WLWR[103] WLWR[104] WLWR[105] WLWR[106] WLWR[107]
+       WLWR[108] WLWR[109] WLWR[110] WLWR[111] WLWR[112] WLWR[113] WLWR[114]
+       WLWR[115] WLWR[116] WLWR[117] WLWR[118] WLWR[119] WLWR[120] WLWR[121]
+       WLWR[122] WLWR[123] WLWR[124] WLWR[125] WLWR[126] WLWR[127] WLWRB[0]
+       WLWRB[1] WLWRB[2] WLWRB[3] WLWRB[4] WLWRB[5] WLWRB[6] WLWRB[7] WLWRB[8]
+       WLWRB[9] WLWRB[10] WLWRB[11] WLWRB[12] WLWRB[13] WLWRB[14] WLWRB[15]
+       WLWRB[16] WLWRB[17] WLWRB[18] WLWRB[19] WLWRB[20] WLWRB[21] WLWRB[22]
+       WLWRB[23] WLWRB[24] WLWRB[25] WLWRB[26] WLWRB[27] WLWRB[28] WLWRB[29]
+       WLWRB[30] WLWRB[31] WLWRB[32] WLWRB[33] WLWRB[34] WLWRB[35] WLWRB[36]
+       WLWRB[37] WLWRB[38] WLWRB[39] WLWRB[40] WLWRB[41] WLWRB[42] WLWRB[43]
+       WLWRB[44] WLWRB[45] WLWRB[46] WLWRB[47] WLWRB[48] WLWRB[49] WLWRB[50]
+       WLWRB[51] WLWRB[52] WLWRB[53] WLWRB[54] WLWRB[55] WLWRB[56] WLWRB[57]
+       WLWRB[58] WLWRB[59] WLWRB[60] WLWRB[61] WLWRB[62] WLWRB[63] WLWRB[64]
+       WLWRB[65] WLWRB[66] WLWRB[67] WLWRB[68] WLWRB[69] WLWRB[70] WLWRB[71]
+       WLWRB[72] WLWRB[73] WLWRB[74] WLWRB[75] WLWRB[76] WLWRB[77] WLWRB[78]
+       WLWRB[79] WLWRB[80] WLWRB[81] WLWRB[82] WLWRB[83] WLWRB[84] WLWRB[85]
+       WLWRB[86] WLWRB[87] WLWRB[88] WLWRB[89] WLWRB[90] WLWRB[91] WLWRB[92]
+       WLWRB[93] WLWRB[94] WLWRB[95] WLWRB[96] WLWRB[97] WLWRB[98] WLWRB[99]
+       WLWRB[100] WLWRB[101] WLWRB[102] WLWRB[103] WLWRB[104] WLWRB[105]
+       WLWRB[106] WLWRB[107] WLWRB[108] WLWRB[109] WLWRB[110] WLWRB[111]
+       WLWRB[112] WLWRB[113] WLWRB[114] WLWRB[115] WLWRB[116] WLWRB[117]
+       WLWRB[118] WLWRB[119] WLWRB[120] WLWRB[121] WLWRB[122] WLWRB[123]
+       WLWRB[124] WLWRB[125] WLWRB[126] WLWRB[127]
X_ary_buf DMY_EDGE_LT[0] DMY_EDGE_LT[1] LCGTV RASSB_H[0] RASSB_H[1] VBN VBP VDDA
+   VDDP VDDPI VDDWL_RD VDDWL_WR VSS WLRD[0] WLRD[1] WLRD[2] WLRD[3] WLRD[4]
+   WLRD[5] WLRD[6] WLRD[7] WLRD[8] WLRD[9] WLRD[10] WLRD[11] WLRD[12] WLRD[13]
+   WLRD[14] WLRD[15] WLRD[16] WLRD[17] WLRD[18] WLRD[19] WLRD[20] WLRD[21]
+   WLRD[22] WLRD[23] WLRD[24] WLRD[25] WLRD[26] WLRD[27] WLRD[28] WLRD[29]
+   WLRD[30] WLRD[31] WLRD[32] WLRD[33] WLRD[34] WLRD[35] WLRD[36] WLRD[37]
+   WLRD[38] WLRD[39] WLRD[40] WLRD[41] WLRD[42] WLRD[43] WLRD[44] WLRD[45]
+   WLRD[46] WLRD[47] WLRD[48] WLRD[49] WLRD[50] WLRD[51] WLRD[52] WLRD[53]
+   WLRD[54] WLRD[55] WLRD[56] WLRD[57] WLRD[58] WLRD[59] WLRD[60] WLRD[61]
+   WLRD[62] WLRD[63] WLRD[64] WLRD[65] WLRD[66] WLRD[67] WLRD[68] WLRD[69]
+   WLRD[70] WLRD[71] WLRD[72] WLRD[73] WLRD[74] WLRD[75] WLRD[76] WLRD[77]
+   WLRD[78] WLRD[79] WLRD[80] WLRD[81] WLRD[82] WLRD[83] WLRD[84] WLRD[85]
+   WLRD[86] WLRD[87] WLRD[88] WLRD[89] WLRD[90] WLRD[91] WLRD[92] WLRD[93]
+   WLRD[94] WLRD[95] WLRD[96] WLRD[97] WLRD[98] WLRD[99] WLRD[100] WLRD[101]
+   WLRD[102] WLRD[103] WLRD[104] WLRD[105] WLRD[106] WLRD[107] WLRD[108]
+   WLRD[109] WLRD[110] WLRD[111] WLRD[112] WLRD[113] WLRD[114] WLRD[115]
+   WLRD[116] WLRD[117] WLRD[118] WLRD[119] WLRD[120] WLRD[121] WLRD[122]
+   WLRD[123] WLRD[124] WLRD[125] WLRD[126] WLRD[127] WLRDB[0] WLRDB[1] WLRDB[2]
+   WLRDB[3] WLRDB[4] WLRDB[5] WLRDB[6] WLRDB[7] WLRDB[8] WLRDB[9] WLRDB[10]
+   WLRDB[11] WLRDB[12] WLRDB[13] WLRDB[14] WLRDB[15] WLRDB[16] WLRDB[17]
+   WLRDB[18] WLRDB[19] WLRDB[20] WLRDB[21] WLRDB[22] WLRDB[23] WLRDB[24]
+   WLRDB[25] WLRDB[26] WLRDB[27] WLRDB[28] WLRDB[29] WLRDB[30] WLRDB[31]
+   WLRDB[32] WLRDB[33] WLRDB[34] WLRDB[35] WLRDB[36] WLRDB[37] WLRDB[38]
+   WLRDB[39] WLRDB[40] WLRDB[41] WLRDB[42] WLRDB[43] WLRDB[44] WLRDB[45]
+   WLRDB[46] WLRDB[47] WLRDB[48] WLRDB[49] WLRDB[50] WLRDB[51] WLRDB[52]
+   WLRDB[53] WLRDB[54] WLRDB[55] WLRDB[56] WLRDB[57] WLRDB[58] WLRDB[59]
+   WLRDB[60] WLRDB[61] WLRDB[62] WLRDB[63] WLRDB[64] WLRDB[65] WLRDB[66]
+   WLRDB[67] WLRDB[68] WLRDB[69] WLRDB[70] WLRDB[71] WLRDB[72] WLRDB[73]
+   WLRDB[74] WLRDB[75] WLRDB[76] WLRDB[77] WLRDB[78] WLRDB[79] WLRDB[80]
+   WLRDB[81] WLRDB[82] WLRDB[83] WLRDB[84] WLRDB[85] WLRDB[86] WLRDB[87]
+   WLRDB[88] WLRDB[89] WLRDB[90] WLRDB[91] WLRDB[92] WLRDB[93] WLRDB[94]
+   WLRDB[95] WLRDB[96] WLRDB[97] WLRDB[98] WLRDB[99] WLRDB[100] WLRDB[101]
+   WLRDB[102] WLRDB[103] WLRDB[104] WLRDB[105] WLRDB[106] WLRDB[107] WLRDB[108]
+   WLRDB[109] WLRDB[110] WLRDB[111] WLRDB[112] WLRDB[113] WLRDB[114] WLRDB[115]
+   WLRDB[116] WLRDB[117] WLRDB[118] WLRDB[119] WLRDB[120] WLRDB[121] WLRDB[122]
+   WLRDB[123] WLRDB[124] WLRDB[125] WLRDB[126] WLRDB[127] WLWR[0] WLWR[1]
+   WLWR[2] WLWR[3] WLWR[4] WLWR[5] WLWR[6] WLWR[7] WLWR[8] WLWR[9] WLWR[10]
+   WLWR[11] WLWR[12] WLWR[13] WLWR[14] WLWR[15] WLWR[16] WLWR[17] WLWR[18]
+   WLWR[19] WLWR[20] WLWR[21] WLWR[22] WLWR[23] WLWR[24] WLWR[25] WLWR[26]
+   WLWR[27] WLWR[28] WLWR[29] WLWR[30] WLWR[31] WLWR[32] WLWR[33] WLWR[34]
+   WLWR[35] WLWR[36] WLWR[37] WLWR[38] WLWR[39] WLWR[40] WLWR[41] WLWR[42]
+   WLWR[43] WLWR[44] WLWR[45] WLWR[46] WLWR[47] WLWR[48] WLWR[49] WLWR[50]
+   WLWR[51] WLWR[52] WLWR[53] WLWR[54] WLWR[55] WLWR[56] WLWR[57] WLWR[58]
+   WLWR[59] WLWR[60] WLWR[61] WLWR[62] WLWR[63] WLWR[64] WLWR[65] WLWR[66]
+   WLWR[67] WLWR[68] WLWR[69] WLWR[70] WLWR[71] WLWR[72] WLWR[73] WLWR[74]
+   WLWR[75] WLWR[76] WLWR[77] WLWR[78] WLWR[79] WLWR[80] WLWR[81] WLWR[82]
+   WLWR[83] WLWR[84] WLWR[85] WLWR[86] WLWR[87] WLWR[88] WLWR[89] WLWR[90]
+   WLWR[91] WLWR[92] WLWR[93] WLWR[94] WLWR[95] WLWR[96] WLWR[97] WLWR[98]
+   WLWR[99] WLWR[100] WLWR[101] WLWR[102] WLWR[103] WLWR[104] WLWR[105]
+   WLWR[106] WLWR[107] WLWR[108] WLWR[109] WLWR[110] WLWR[111] WLWR[112]
+   WLWR[113] WLWR[114] WLWR[115] WLWR[116] WLWR[117] WLWR[118] WLWR[119]
+   WLWR[120] WLWR[121] WLWR[122] WLWR[123] WLWR[124] WLWR[125] WLWR[126]
+   WLWR[127] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3] WLWRB[4] WLWRB[5] WLWRB[6]
+   WLWRB[7] WLWRB[8] WLWRB[9] WLWRB[10] WLWRB[11] WLWRB[12] WLWRB[13] WLWRB[14]
+   WLWRB[15] WLWRB[16] WLWRB[17] WLWRB[18] WLWRB[19] WLWRB[20] WLWRB[21]
+   WLWRB[22] WLWRB[23] WLWRB[24] WLWRB[25] WLWRB[26] WLWRB[27] WLWRB[28]
+   WLWRB[29] WLWRB[30] WLWRB[31] WLWRB[32] WLWRB[33] WLWRB[34] WLWRB[35]
+   WLWRB[36] WLWRB[37] WLWRB[38] WLWRB[39] WLWRB[40] WLWRB[41] WLWRB[42]
+   WLWRB[43] WLWRB[44] WLWRB[45] WLWRB[46] WLWRB[47] WLWRB[48] WLWRB[49]
+   WLWRB[50] WLWRB[51] WLWRB[52] WLWRB[53] WLWRB[54] WLWRB[55] WLWRB[56]
+   WLWRB[57] WLWRB[58] WLWRB[59] WLWRB[60] WLWRB[61] WLWRB[62] WLWRB[63]
+   WLWRB[64] WLWRB[65] WLWRB[66] WLWRB[67] WLWRB[68] WLWRB[69] WLWRB[70]
+   WLWRB[71] WLWRB[72] WLWRB[73] WLWRB[74] WLWRB[75] WLWRB[76] WLWRB[77]
+   WLWRB[78] WLWRB[79] WLWRB[80] WLWRB[81] WLWRB[82] WLWRB[83] WLWRB[84]
+   WLWRB[85] WLWRB[86] WLWRB[87] WLWRB[88] WLWRB[89] WLWRB[90] WLWRB[91]
+   WLWRB[92] WLWRB[93] WLWRB[94] WLWRB[95] WLWRB[96] WLWRB[97] WLWRB[98]
+   WLWRB[99] WLWRB[100] WLWRB[101] WLWRB[102] WLWRB[103] WLWRB[104] WLWRB[105]
+   WLWRB[106] WLWRB[107] WLWRB[108] WLWRB[109] WLWRB[110] WLWRB[111] WLWRB[112]
+   WLWRB[113] WLWRB[114] WLWRB[115] WLWRB[116] WLWRB[117] WLWRB[118] WLWRB[119]
+   WLWRB[120] WLWRB[121] WLWRB[122] WLWRB[123] WLWRB[124] WLWRB[125] WLWRB[126]
+   WLWRB[127] SNPS_RF_DP_UHD_512x80_ary_buf
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_cnt ARYSD BKRDB BKRDB_128 CENDP DEF1_RD
+       DEF1_WR DMY_EDGE_LT[0] DMY_EDGE_LT[1] FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LCGTV LOG0 LOG1 LRWMEB LXADRB[0] LXADRB[1] LXADRB[2]
+       PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3]
+       PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3]
+       PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3] RASSB_H[0] RASSB_H[1] RBLWA RDBL
+       RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0]
+       RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB VBN[0]
+       VBN[1] VBN[2] VBP[0] VBP[1] VBP[2] VDDA[0] VDDA[1] VDDA[2] VDDAPI VDDF
+       VDDP[0] VDDP[1] VDDP[2] VDDPI[0] VDDPI[1] VDDPI[2] VDDWL_RD VDDWL_WR
+       VSS[0] VSS[1] VSS[2] VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3]
+       WCLKWR[0] WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WLRD_H[0] WLRD_H[1]
+       WLRD_H[2] WLRD_H[3] WLRD_H[4] WLRD_H[5] WLRD_H[6] WLRD_H[7] WLRD_H[8]
+       WLRD_H[9] WLRD_H[10] WLRD_H[11] WLRD_H[12] WLRD_H[13] WLRD_H[14]
+       WLRD_H[15] WLRD_H[16] WLRD_H[17] WLRD_H[18] WLRD_H[19] WLRD_H[20]
+       WLRD_H[21] WLRD_H[22] WLRD_H[23] WLRD_H[24] WLRD_H[25] WLRD_H[26]
+       WLRD_H[27] WLRD_H[28] WLRD_H[29] WLRD_H[30] WLRD_H[31] WLRD_H[32]
+       WLRD_H[33] WLRD_H[34] WLRD_H[35] WLRD_H[36] WLRD_H[37] WLRD_H[38]
+       WLRD_H[39] WLRD_H[40] WLRD_H[41] WLRD_H[42] WLRD_H[43] WLRD_H[44]
+       WLRD_H[45] WLRD_H[46] WLRD_H[47] WLRD_H[48] WLRD_H[49] WLRD_H[50]
+       WLRD_H[51] WLRD_H[52] WLRD_H[53] WLRD_H[54] WLRD_H[55] WLRD_H[56]
+       WLRD_H[57] WLRD_H[58] WLRD_H[59] WLRD_H[60] WLRD_H[61] WLRD_H[62]
+       WLRD_H[63] WLRD_H[64] WLRD_H[65] WLRD_H[66] WLRD_H[67] WLRD_H[68]
+       WLRD_H[69] WLRD_H[70] WLRD_H[71] WLRD_H[72] WLRD_H[73] WLRD_H[74]
+       WLRD_H[75] WLRD_H[76] WLRD_H[77] WLRD_H[78] WLRD_H[79] WLRD_H[80]
+       WLRD_H[81] WLRD_H[82] WLRD_H[83] WLRD_H[84] WLRD_H[85] WLRD_H[86]
+       WLRD_H[87] WLRD_H[88] WLRD_H[89] WLRD_H[90] WLRD_H[91] WLRD_H[92]
+       WLRD_H[93] WLRD_H[94] WLRD_H[95] WLRD_H[96] WLRD_H[97] WLRD_H[98]
+       WLRD_H[99] WLRD_H[100] WLRD_H[101] WLRD_H[102] WLRD_H[103] WLRD_H[104]
+       WLRD_H[105] WLRD_H[106] WLRD_H[107] WLRD_H[108] WLRD_H[109] WLRD_H[110]
+       WLRD_H[111] WLRD_H[112] WLRD_H[113] WLRD_H[114] WLRD_H[115] WLRD_H[116]
+       WLRD_H[117] WLRD_H[118] WLRD_H[119] WLRD_H[120] WLRD_H[121] WLRD_H[122]
+       WLRD_H[123] WLRD_H[124] WLRD_H[125] WLRD_H[126] WLRD_H[127] WLWR_H[0]
+       WLWR_H[1] WLWR_H[2] WLWR_H[3] WLWR_H[4] WLWR_H[5] WLWR_H[6] WLWR_H[7]
+       WLWR_H[8] WLWR_H[9] WLWR_H[10] WLWR_H[11] WLWR_H[12] WLWR_H[13]
+       WLWR_H[14] WLWR_H[15] WLWR_H[16] WLWR_H[17] WLWR_H[18] WLWR_H[19]
+       WLWR_H[20] WLWR_H[21] WLWR_H[22] WLWR_H[23] WLWR_H[24] WLWR_H[25]
+       WLWR_H[26] WLWR_H[27] WLWR_H[28] WLWR_H[29] WLWR_H[30] WLWR_H[31]
+       WLWR_H[32] WLWR_H[33] WLWR_H[34] WLWR_H[35] WLWR_H[36] WLWR_H[37]
+       WLWR_H[38] WLWR_H[39] WLWR_H[40] WLWR_H[41] WLWR_H[42] WLWR_H[43]
+       WLWR_H[44] WLWR_H[45] WLWR_H[46] WLWR_H[47] WLWR_H[48] WLWR_H[49]
+       WLWR_H[50] WLWR_H[51] WLWR_H[52] WLWR_H[53] WLWR_H[54] WLWR_H[55]
+       WLWR_H[56] WLWR_H[57] WLWR_H[58] WLWR_H[59] WLWR_H[60] WLWR_H[61]
+       WLWR_H[62] WLWR_H[63] WLWR_H[64] WLWR_H[65] WLWR_H[66] WLWR_H[67]
+       WLWR_H[68] WLWR_H[69] WLWR_H[70] WLWR_H[71] WLWR_H[72] WLWR_H[73]
+       WLWR_H[74] WLWR_H[75] WLWR_H[76] WLWR_H[77] WLWR_H[78] WLWR_H[79]
+       WLWR_H[80] WLWR_H[81] WLWR_H[82] WLWR_H[83] WLWR_H[84] WLWR_H[85]
+       WLWR_H[86] WLWR_H[87] WLWR_H[88] WLWR_H[89] WLWR_H[90] WLWR_H[91]
+       WLWR_H[92] WLWR_H[93] WLWR_H[94] WLWR_H[95] WLWR_H[96] WLWR_H[97]
+       WLWR_H[98] WLWR_H[99] WLWR_H[100] WLWR_H[101] WLWR_H[102] WLWR_H[103]
+       WLWR_H[104] WLWR_H[105] WLWR_H[106] WLWR_H[107] WLWR_H[108] WLWR_H[109]
+       WLWR_H[110] WLWR_H[111] WLWR_H[112] WLWR_H[113] WLWR_H[114] WLWR_H[115]
+       WLWR_H[116] WLWR_H[117] WLWR_H[118] WLWR_H[119] WLWR_H[120] WLWR_H[121]
+       WLWR_H[122] WLWR_H[123] WLWR_H[124] WLWR_H[125] WLWR_H[126] WLWR_H[127]
+       XAWRB XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]
*X_ary_edg VBN[0] VBP[0] VDDA[0] VDDP[0] VDDPI[0] VSS[0]
*+  SNPS_RF_DP_UHD_512x80_ary_edg
X_ary_xdec ARYSD BKRDB BKRDB_128 CENDP DECBRD[0] DECBRD[1] DECBRD[2] DECBRD[3]
+   DECBRD[4] DECBRD[5] DECBRD[6] DECBRD[7] DECBRD[8] DECBRD[9] DECBRD[10]
+   DECBRD[11] DECBRD[12] DECBRD[13] DECBRD[14] DECBRD[15] DECBRD[16] DECBRD[17]
+   DECBRD[18] DECBRD[19] DECBRD[20] DECBRD[21] DECBRD[22] DECBRD[23] DECBRD[24]
+   DECBRD[25] DECBRD[26] DECBRD[27] DECBRD[28] DECBRD[29] DECBRD[30] DECBRD[31]
+   DECBWR[0] DECBWR[1] DECBWR[2] DECBWR[3] DECBWR[4] DECBWR[5] DECBWR[6]
+   DECBWR[7] DECBWR[8] DECBWR[9] DECBWR[10] DECBWR[11] DECBWR[12] DECBWR[13]
+   DECBWR[14] DECBWR[15] DECBWR[16] DECBWR[17] DECBWR[18] DECBWR[19] DECBWR[20]
+   DECBWR[21] DECBWR[22] DECBWR[23] DECBWR[24] DECBWR[25] DECBWR[26] DECBWR[27]
+   DECBWR[28] DECBWR[29] DECBWR[30] DECBWR[31] DECBRD[0] DECBRD[1] DECBRD[2]
+   DECBRD[3] DECBRD[4] DECBRD[5] DECBRD[6] DECBRD[7] DECBRD[8] DECBRD[9]
+   DECBRD[10] DECBRD[11] DECBRD[12] DECBRD[13] DECBRD[14] DECBRD[15] DECBRD[16]
+   DECBRD[17] DECBRD[18] DECBRD[19] DECBRD[20] DECBRD[21] DECBRD[22] DECBRD[23]
+   DECBRD[24] DECBRD[25] DECBRD[26] DECBRD[27] DECBRD[28] DECBRD[29] DECBRD[30]
+   DECBRD[31] DECBWR[0] DECBWR[1] DECBWR[2] DECBWR[3] DECBWR[4] DECBWR[5]
+   DECBWR[6] DECBWR[7] DECBWR[8] DECBWR[9] DECBWR[10] DECBWR[11] DECBWR[12]
+   DECBWR[13] DECBWR[14] DECBWR[15] DECBWR[16] DECBWR[17] DECBWR[18] DECBWR[19]
+   DECBWR[20] DECBWR[21] DECBWR[22] DECBWR[23] DECBWR[24] DECBWR[25] DECBWR[26]
+   DECBWR[27] DECBWR[28] DECBWR[29] DECBWR[30] DECBWR[31] DEF1_RD DEF1_WR
+   FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LOG0 LOG1 LRWMEB LXADRB[0]
+   LXADRB[1] LXADRB[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1]
+   PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1]
+   PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3] RBLWA RDBL RFLOAT
+   RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1]
+   RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB VBN[1] VBP[1] VDDA[1]
+   VDDAPI VDDF VDDP[1] VDDPI[1] VDDWL_RD VDDWL_WR VSS[1] VSSWL WCLKRD[0]
+   WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL
+   WFLOAT WLRDB[0] WLRDB[1] WLRDB[2] WLRDB[3] WLRDB[4] WLRDB[5] WLRDB[6]
+   WLRDB[7] WLRDB[8] WLRDB[9] WLRDB[10] WLRDB[11] WLRDB[12] WLRDB[13] WLRDB[14]
+   WLRDB[15] WLRDB[16] WLRDB[17] WLRDB[18] WLRDB[19] WLRDB[20] WLRDB[21]
+   WLRDB[22] WLRDB[23] WLRDB[24] WLRDB[25] WLRDB[26] WLRDB[27] WLRDB[28]
+   WLRDB[29] WLRDB[30] WLRDB[31] WLRDB[32] WLRDB[33] WLRDB[34] WLRDB[35]
+   WLRDB[36] WLRDB[37] WLRDB[38] WLRDB[39] WLRDB[40] WLRDB[41] WLRDB[42]
+   WLRDB[43] WLRDB[44] WLRDB[45] WLRDB[46] WLRDB[47] WLRDB[48] WLRDB[49]
+   WLRDB[50] WLRDB[51] WLRDB[52] WLRDB[53] WLRDB[54] WLRDB[55] WLRDB[56]
+   WLRDB[57] WLRDB[58] WLRDB[59] WLRDB[60] WLRDB[61] WLRDB[62] WLRDB[63]
+   WLRDB[64] WLRDB[65] WLRDB[66] WLRDB[67] WLRDB[68] WLRDB[69] WLRDB[70]
+   WLRDB[71] WLRDB[72] WLRDB[73] WLRDB[74] WLRDB[75] WLRDB[76] WLRDB[77]
+   WLRDB[78] WLRDB[79] WLRDB[80] WLRDB[81] WLRDB[82] WLRDB[83] WLRDB[84]
+   WLRDB[85] WLRDB[86] WLRDB[87] WLRDB[88] WLRDB[89] WLRDB[90] WLRDB[91]
+   WLRDB[92] WLRDB[93] WLRDB[94] WLRDB[95] WLRDB[96] WLRDB[97] WLRDB[98]
+   WLRDB[99] WLRDB[100] WLRDB[101] WLRDB[102] WLRDB[103] WLRDB[104] WLRDB[105]
+   WLRDB[106] WLRDB[107] WLRDB[108] WLRDB[109] WLRDB[110] WLRDB[111] WLRDB[112]
+   WLRDB[113] WLRDB[114] WLRDB[115] WLRDB[116] WLRDB[117] WLRDB[118] WLRDB[119]
+   WLRDB[120] WLRDB[121] WLRDB[122] WLRDB[123] WLRDB[124] WLRDB[125] WLRDB[126]
+   WLRDB[127] WLRDB_L[0] WLRDB_L[1] WLRDB_L[2] WLRDB_L[3] WLRDB_L[4] WLRDB_L[5]
+   WLRDB_L[6] WLRDB_L[7] WLRDB_L[8] WLRDB_L[9] WLRDB_L[10] WLRDB_L[11]
+   WLRDB_L[12] WLRDB_L[13] WLRDB_L[14] WLRDB_L[15] WLRDB_L[16] WLRDB_L[17]
+   WLRDB_L[18] WLRDB_L[19] WLRDB_L[20] WLRDB_L[21] WLRDB_L[22] WLRDB_L[23]
+   WLRDB_L[24] WLRDB_L[25] WLRDB_L[26] WLRDB_L[27] WLRDB_L[28] WLRDB_L[29]
+   WLRDB_L[30] WLRDB_L[31] WLRDB_L[32] WLRDB_L[33] WLRDB_L[34] WLRDB_L[35]
+   WLRDB_L[36] WLRDB_L[37] WLRDB_L[38] WLRDB_L[39] WLRDB_L[40] WLRDB_L[41]
+   WLRDB_L[42] WLRDB_L[43] WLRDB_L[44] WLRDB_L[45] WLRDB_L[46] WLRDB_L[47]
+   WLRDB_L[48] WLRDB_L[49] WLRDB_L[50] WLRDB_L[51] WLRDB_L[52] WLRDB_L[53]
+   WLRDB_L[54] WLRDB_L[55] WLRDB_L[56] WLRDB_L[57] WLRDB_L[58] WLRDB_L[59]
+   WLRDB_L[60] WLRDB_L[61] WLRDB_L[62] WLRDB_L[63] WLRDB_L[64] WLRDB_L[65]
+   WLRDB_L[66] WLRDB_L[67] WLRDB_L[68] WLRDB_L[69] WLRDB_L[70] WLRDB_L[71]
+   WLRDB_L[72] WLRDB_L[73] WLRDB_L[74] WLRDB_L[75] WLRDB_L[76] WLRDB_L[77]
+   WLRDB_L[78] WLRDB_L[79] WLRDB_L[80] WLRDB_L[81] WLRDB_L[82] WLRDB_L[83]
+   WLRDB_L[84] WLRDB_L[85] WLRDB_L[86] WLRDB_L[87] WLRDB_L[88] WLRDB_L[89]
+   WLRDB_L[90] WLRDB_L[91] WLRDB_L[92] WLRDB_L[93] WLRDB_L[94] WLRDB_L[95]
+   WLRDB_L[96] WLRDB_L[97] WLRDB_L[98] WLRDB_L[99] WLRDB_L[100] WLRDB_L[101]
+   WLRDB_L[102] WLRDB_L[103] WLRDB_L[104] WLRDB_L[105] WLRDB_L[106]
+   WLRDB_L[107] WLRDB_L[108] WLRDB_L[109] WLRDB_L[110] WLRDB_L[111]
+   WLRDB_L[112] WLRDB_L[113] WLRDB_L[114] WLRDB_L[115] WLRDB_L[116]
+   WLRDB_L[117] WLRDB_L[118] WLRDB_L[119] WLRDB_L[120] WLRDB_L[121]
+   WLRDB_L[122] WLRDB_L[123] WLRDB_L[124] WLRDB_L[125] WLRDB_L[126]
+   WLRDB_L[127] WLWRB[0] WLWRB[1] WLWRB[2] WLWRB[3] WLWRB[4] WLWRB[5] WLWRB[6]
+   WLWRB[7] WLWRB[8] WLWRB[9] WLWRB[10] WLWRB[11] WLWRB[12] WLWRB[13] WLWRB[14]
+   WLWRB[15] WLWRB[16] WLWRB[17] WLWRB[18] WLWRB[19] WLWRB[20] WLWRB[21]
+   WLWRB[22] WLWRB[23] WLWRB[24] WLWRB[25] WLWRB[26] WLWRB[27] WLWRB[28]
+   WLWRB[29] WLWRB[30] WLWRB[31] WLWRB[32] WLWRB[33] WLWRB[34] WLWRB[35]
+   WLWRB[36] WLWRB[37] WLWRB[38] WLWRB[39] WLWRB[40] WLWRB[41] WLWRB[42]
+   WLWRB[43] WLWRB[44] WLWRB[45] WLWRB[46] WLWRB[47] WLWRB[48] WLWRB[49]
+   WLWRB[50] WLWRB[51] WLWRB[52] WLWRB[53] WLWRB[54] WLWRB[55] WLWRB[56]
+   WLWRB[57] WLWRB[58] WLWRB[59] WLWRB[60] WLWRB[61] WLWRB[62] WLWRB[63]
+   WLWRB[64] WLWRB[65] WLWRB[66] WLWRB[67] WLWRB[68] WLWRB[69] WLWRB[70]
+   WLWRB[71] WLWRB[72] WLWRB[73] WLWRB[74] WLWRB[75] WLWRB[76] WLWRB[77]
+   WLWRB[78] WLWRB[79] WLWRB[80] WLWRB[81] WLWRB[82] WLWRB[83] WLWRB[84]
+   WLWRB[85] WLWRB[86] WLWRB[87] WLWRB[88] WLWRB[89] WLWRB[90] WLWRB[91]
+   WLWRB[92] WLWRB[93] WLWRB[94] WLWRB[95] WLWRB[96] WLWRB[97] WLWRB[98]
+   WLWRB[99] WLWRB[100] WLWRB[101] WLWRB[102] WLWRB[103] WLWRB[104] WLWRB[105]
+   WLWRB[106] WLWRB[107] WLWRB[108] WLWRB[109] WLWRB[110] WLWRB[111] WLWRB[112]
+   WLWRB[113] WLWRB[114] WLWRB[115] WLWRB[116] WLWRB[117] WLWRB[118] WLWRB[119]
+   WLWRB[120] WLWRB[121] WLWRB[122] WLWRB[123] WLWRB[124] WLWRB[125] WLWRB[126]
+   WLWRB[127] WLWRB_L[0] WLWRB_L[1] WLWRB_L[2] WLWRB_L[3] WLWRB_L[4] WLWRB_L[5]
+   WLWRB_L[6] WLWRB_L[7] WLWRB_L[8] WLWRB_L[9] WLWRB_L[10] WLWRB_L[11]
+   WLWRB_L[12] WLWRB_L[13] WLWRB_L[14] WLWRB_L[15] WLWRB_L[16] WLWRB_L[17]
+   WLWRB_L[18] WLWRB_L[19] WLWRB_L[20] WLWRB_L[21] WLWRB_L[22] WLWRB_L[23]
+   WLWRB_L[24] WLWRB_L[25] WLWRB_L[26] WLWRB_L[27] WLWRB_L[28] WLWRB_L[29]
+   WLWRB_L[30] WLWRB_L[31] WLWRB_L[32] WLWRB_L[33] WLWRB_L[34] WLWRB_L[35]
+   WLWRB_L[36] WLWRB_L[37] WLWRB_L[38] WLWRB_L[39] WLWRB_L[40] WLWRB_L[41]
+   WLWRB_L[42] WLWRB_L[43] WLWRB_L[44] WLWRB_L[45] WLWRB_L[46] WLWRB_L[47]
+   WLWRB_L[48] WLWRB_L[49] WLWRB_L[50] WLWRB_L[51] WLWRB_L[52] WLWRB_L[53]
+   WLWRB_L[54] WLWRB_L[55] WLWRB_L[56] WLWRB_L[57] WLWRB_L[58] WLWRB_L[59]
+   WLWRB_L[60] WLWRB_L[61] WLWRB_L[62] WLWRB_L[63] WLWRB_L[64] WLWRB_L[65]
+   WLWRB_L[66] WLWRB_L[67] WLWRB_L[68] WLWRB_L[69] WLWRB_L[70] WLWRB_L[71]
+   WLWRB_L[72] WLWRB_L[73] WLWRB_L[74] WLWRB_L[75] WLWRB_L[76] WLWRB_L[77]
+   WLWRB_L[78] WLWRB_L[79] WLWRB_L[80] WLWRB_L[81] WLWRB_L[82] WLWRB_L[83]
+   WLWRB_L[84] WLWRB_L[85] WLWRB_L[86] WLWRB_L[87] WLWRB_L[88] WLWRB_L[89]
+   WLWRB_L[90] WLWRB_L[91] WLWRB_L[92] WLWRB_L[93] WLWRB_L[94] WLWRB_L[95]
+   WLWRB_L[96] WLWRB_L[97] WLWRB_L[98] WLWRB_L[99] WLWRB_L[100] WLWRB_L[101]
+   WLWRB_L[102] WLWRB_L[103] WLWRB_L[104] WLWRB_L[105] WLWRB_L[106]
+   WLWRB_L[107] WLWRB_L[108] WLWRB_L[109] WLWRB_L[110] WLWRB_L[111]
+   WLWRB_L[112] WLWRB_L[113] WLWRB_L[114] WLWRB_L[115] WLWRB_L[116]
+   WLWRB_L[117] WLWRB_L[118] WLWRB_L[119] WLWRB_L[120] WLWRB_L[121]
+   WLWRB_L[122] WLWRB_L[123] WLWRB_L[124] WLWRB_L[125] WLWRB_L[126]
+   WLWRB_L[127] XAWRB XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2]
+   YSELRD[3] SNPS_RF_DP_UHD_512x80_ary_xdec
X_ary_buf_lsh DMY_EDGE_LT[0] DMY_EDGE_LT[1] LCGTV RASSB_H[0] RASSB_H[1] VBN[2]
+   VBP[2] VDDA[2] VDDP[2] VDDPI[2] VDDWL_RD VDDWL_WR VSS[2] WLRD_H[0] WLRD_H[1]
+   WLRD_H[2] WLRD_H[3] WLRD_H[4] WLRD_H[5] WLRD_H[6] WLRD_H[7] WLRD_H[8]
+   WLRD_H[9] WLRD_H[10] WLRD_H[11] WLRD_H[12] WLRD_H[13] WLRD_H[14] WLRD_H[15]
+   WLRD_H[16] WLRD_H[17] WLRD_H[18] WLRD_H[19] WLRD_H[20] WLRD_H[21] WLRD_H[22]
+   WLRD_H[23] WLRD_H[24] WLRD_H[25] WLRD_H[26] WLRD_H[27] WLRD_H[28] WLRD_H[29]
+   WLRD_H[30] WLRD_H[31] WLRD_H[32] WLRD_H[33] WLRD_H[34] WLRD_H[35] WLRD_H[36]
+   WLRD_H[37] WLRD_H[38] WLRD_H[39] WLRD_H[40] WLRD_H[41] WLRD_H[42] WLRD_H[43]
+   WLRD_H[44] WLRD_H[45] WLRD_H[46] WLRD_H[47] WLRD_H[48] WLRD_H[49] WLRD_H[50]
+   WLRD_H[51] WLRD_H[52] WLRD_H[53] WLRD_H[54] WLRD_H[55] WLRD_H[56] WLRD_H[57]
+   WLRD_H[58] WLRD_H[59] WLRD_H[60] WLRD_H[61] WLRD_H[62] WLRD_H[63] WLRD_H[64]
+   WLRD_H[65] WLRD_H[66] WLRD_H[67] WLRD_H[68] WLRD_H[69] WLRD_H[70] WLRD_H[71]
+   WLRD_H[72] WLRD_H[73] WLRD_H[74] WLRD_H[75] WLRD_H[76] WLRD_H[77] WLRD_H[78]
+   WLRD_H[79] WLRD_H[80] WLRD_H[81] WLRD_H[82] WLRD_H[83] WLRD_H[84] WLRD_H[85]
+   WLRD_H[86] WLRD_H[87] WLRD_H[88] WLRD_H[89] WLRD_H[90] WLRD_H[91] WLRD_H[92]
+   WLRD_H[93] WLRD_H[94] WLRD_H[95] WLRD_H[96] WLRD_H[97] WLRD_H[98] WLRD_H[99]
+   WLRD_H[100] WLRD_H[101] WLRD_H[102] WLRD_H[103] WLRD_H[104] WLRD_H[105]
+   WLRD_H[106] WLRD_H[107] WLRD_H[108] WLRD_H[109] WLRD_H[110] WLRD_H[111]
+   WLRD_H[112] WLRD_H[113] WLRD_H[114] WLRD_H[115] WLRD_H[116] WLRD_H[117]
+   WLRD_H[118] WLRD_H[119] WLRD_H[120] WLRD_H[121] WLRD_H[122] WLRD_H[123]
+   WLRD_H[124] WLRD_H[125] WLRD_H[126] WLRD_H[127] WLRDB[0] WLRDB[1] WLRDB[2]
+   WLRDB[3] WLRDB[4] WLRDB[5] WLRDB[6] WLRDB[7] WLRDB[8] WLRDB[9] WLRDB[10]
+   WLRDB[11] WLRDB[12] WLRDB[13] WLRDB[14] WLRDB[15] WLRDB[16] WLRDB[17]
+   WLRDB[18] WLRDB[19] WLRDB[20] WLRDB[21] WLRDB[22] WLRDB[23] WLRDB[24]
+   WLRDB[25] WLRDB[26] WLRDB[27] WLRDB[28] WLRDB[29] WLRDB[30] WLRDB[31]
+   WLRDB[32] WLRDB[33] WLRDB[34] WLRDB[35] WLRDB[36] WLRDB[37] WLRDB[38]
+   WLRDB[39] WLRDB[40] WLRDB[41] WLRDB[42] WLRDB[43] WLRDB[44] WLRDB[45]
+   WLRDB[46] WLRDB[47] WLRDB[48] WLRDB[49] WLRDB[50] WLRDB[51] WLRDB[52]
+   WLRDB[53] WLRDB[54] WLRDB[55] WLRDB[56] WLRDB[57] WLRDB[58] WLRDB[59]
+   WLRDB[60] WLRDB[61] WLRDB[62] WLRDB[63] WLRDB[64] WLRDB[65] WLRDB[66]
+   WLRDB[67] WLRDB[68] WLRDB[69] WLRDB[70] WLRDB[71] WLRDB[72] WLRDB[73]
+   WLRDB[74] WLRDB[75] WLRDB[76] WLRDB[77] WLRDB[78] WLRDB[79] WLRDB[80]
+   WLRDB[81] WLRDB[82] WLRDB[83] WLRDB[84] WLRDB[85] WLRDB[86] WLRDB[87]
+   WLRDB[88] WLRDB[89] WLRDB[90] WLRDB[91] WLRDB[92] WLRDB[93] WLRDB[94]
+   WLRDB[95] WLRDB[96] WLRDB[97] WLRDB[98] WLRDB[99] WLRDB[100] WLRDB[101]
+   WLRDB[102] WLRDB[103] WLRDB[104] WLRDB[105] WLRDB[106] WLRDB[107] WLRDB[108]
+   WLRDB[109] WLRDB[110] WLRDB[111] WLRDB[112] WLRDB[113] WLRDB[114] WLRDB[115]
+   WLRDB[116] WLRDB[117] WLRDB[118] WLRDB[119] WLRDB[120] WLRDB[121] WLRDB[122]
+   WLRDB[123] WLRDB[124] WLRDB[125] WLRDB[126] WLRDB[127] WLWR_H[0] WLWR_H[1]
+   WLWR_H[2] WLWR_H[3] WLWR_H[4] WLWR_H[5] WLWR_H[6] WLWR_H[7] WLWR_H[8]
+   WLWR_H[9] WLWR_H[10] WLWR_H[11] WLWR_H[12] WLWR_H[13] WLWR_H[14] WLWR_H[15]
+   WLWR_H[16] WLWR_H[17] WLWR_H[18] WLWR_H[19] WLWR_H[20] WLWR_H[21] WLWR_H[22]
+   WLWR_H[23] WLWR_H[24] WLWR_H[25] WLWR_H[26] WLWR_H[27] WLWR_H[28] WLWR_H[29]
+   WLWR_H[30] WLWR_H[31] WLWR_H[32] WLWR_H[33] WLWR_H[34] WLWR_H[35] WLWR_H[36]
+   WLWR_H[37] WLWR_H[38] WLWR_H[39] WLWR_H[40] WLWR_H[41] WLWR_H[42] WLWR_H[43]
+   WLWR_H[44] WLWR_H[45] WLWR_H[46] WLWR_H[47] WLWR_H[48] WLWR_H[49] WLWR_H[50]
+   WLWR_H[51] WLWR_H[52] WLWR_H[53] WLWR_H[54] WLWR_H[55] WLWR_H[56] WLWR_H[57]
+   WLWR_H[58] WLWR_H[59] WLWR_H[60] WLWR_H[61] WLWR_H[62] WLWR_H[63] WLWR_H[64]
+   WLWR_H[65] WLWR_H[66] WLWR_H[67] WLWR_H[68] WLWR_H[69] WLWR_H[70] WLWR_H[71]
+   WLWR_H[72] WLWR_H[73] WLWR_H[74] WLWR_H[75] WLWR_H[76] WLWR_H[77] WLWR_H[78]
+   WLWR_H[79] WLWR_H[80] WLWR_H[81] WLWR_H[82] WLWR_H[83] WLWR_H[84] WLWR_H[85]
+   WLWR_H[86] WLWR_H[87] WLWR_H[88] WLWR_H[89] WLWR_H[90] WLWR_H[91] WLWR_H[92]
+   WLWR_H[93] WLWR_H[94] WLWR_H[95] WLWR_H[96] WLWR_H[97] WLWR_H[98] WLWR_H[99]
+   WLWR_H[100] WLWR_H[101] WLWR_H[102] WLWR_H[103] WLWR_H[104] WLWR_H[105]
+   WLWR_H[106] WLWR_H[107] WLWR_H[108] WLWR_H[109] WLWR_H[110] WLWR_H[111]
+   WLWR_H[112] WLWR_H[113] WLWR_H[114] WLWR_H[115] WLWR_H[116] WLWR_H[117]
+   WLWR_H[118] WLWR_H[119] WLWR_H[120] WLWR_H[121] WLWR_H[122] WLWR_H[123]
+   WLWR_H[124] WLWR_H[125] WLWR_H[126] WLWR_H[127] WLWRB[0] WLWRB[1] WLWRB[2]
+   WLWRB[3] WLWRB[4] WLWRB[5] WLWRB[6] WLWRB[7] WLWRB[8] WLWRB[9] WLWRB[10]
+   WLWRB[11] WLWRB[12] WLWRB[13] WLWRB[14] WLWRB[15] WLWRB[16] WLWRB[17]
+   WLWRB[18] WLWRB[19] WLWRB[20] WLWRB[21] WLWRB[22] WLWRB[23] WLWRB[24]
+   WLWRB[25] WLWRB[26] WLWRB[27] WLWRB[28] WLWRB[29] WLWRB[30] WLWRB[31]
+   WLWRB[32] WLWRB[33] WLWRB[34] WLWRB[35] WLWRB[36] WLWRB[37] WLWRB[38]
+   WLWRB[39] WLWRB[40] WLWRB[41] WLWRB[42] WLWRB[43] WLWRB[44] WLWRB[45]
+   WLWRB[46] WLWRB[47] WLWRB[48] WLWRB[49] WLWRB[50] WLWRB[51] WLWRB[52]
+   WLWRB[53] WLWRB[54] WLWRB[55] WLWRB[56] WLWRB[57] WLWRB[58] WLWRB[59]
+   WLWRB[60] WLWRB[61] WLWRB[62] WLWRB[63] WLWRB[64] WLWRB[65] WLWRB[66]
+   WLWRB[67] WLWRB[68] WLWRB[69] WLWRB[70] WLWRB[71] WLWRB[72] WLWRB[73]
+   WLWRB[74] WLWRB[75] WLWRB[76] WLWRB[77] WLWRB[78] WLWRB[79] WLWRB[80]
+   WLWRB[81] WLWRB[82] WLWRB[83] WLWRB[84] WLWRB[85] WLWRB[86] WLWRB[87]
+   WLWRB[88] WLWRB[89] WLWRB[90] WLWRB[91] WLWRB[92] WLWRB[93] WLWRB[94]
+   WLWRB[95] WLWRB[96] WLWRB[97] WLWRB[98] WLWRB[99] WLWRB[100] WLWRB[101]
+   WLWRB[102] WLWRB[103] WLWRB[104] WLWRB[105] WLWRB[106] WLWRB[107] WLWRB[108]
+   WLWRB[109] WLWRB[110] WLWRB[111] WLWRB[112] WLWRB[113] WLWRB[114] WLWRB[115]
+   WLWRB[116] WLWRB[117] WLWRB[118] WLWRB[119] WLWRB[120] WLWRB[121] WLWRB[122]
+   WLWRB[123] WLWRB[124] WLWRB[125] WLWRB[126] WLWRB[127]
+   SNPS_RF_DP_UHD_512x80_ary_buf_lsh
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_rt_seg1 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4]
+       BAB[5] BAB[6] BAB[7] BAB[8] BAB[9] BAB[10] BAB[11] BAB[12] BAB[13]
+       BAB[14] BAB[15] BAB[16] BAB[17] BAB[18] BAB[19] BAB[20] BAB[21] BAB[22]
+       BAB[23] BAB[24] BAB[25] BAB[26] BAB[27] BAB[28] BAB[29] BAB[30] BAB[31]
+       BAB[32] BAB[33] BAB[34] BAB[35] BAB[36] BAB[37] BAB[38] BAB[39] BAB[40]
+       BAB[41] BAB[42] BAB[43] BAB[44] BAB[45] BAB[46] BAB[47] BAB[48] BAB[49]
+       BAB[50] BAB[51] BAB[52] BAB[53] BAB[54] BAB[55] BAB[56] BAB[57] BAB[58]
+       BAB[59] BAB[60] BAB[61] BAB[62] BAB[63] BAB[64] BAB[65] BAB[66] BAB[67]
+       BAB[68] BAB[69] BAB[70] BAB[71] BAB[72] BAB[73] BAB[74] BAB[75] BAB[76]
+       BAB[77] BAB[78] BAB[79] BAT[0] BAT[1] BAT[2] BAT[3] BAT[4] BAT[5] BAT[6]
+       BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13] BAT[14] BAT[15]
+       BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22] BAT[23] BAT[24]
+       BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31] BAT[32] BAT[33]
+       BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40] BAT[41] BAT[42]
+       BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49] BAT[50] BAT[51]
+       BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58] BAT[59] BAT[60]
+       BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67] BAT[68] BAT[69]
+       BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76] BAT[77] BAT[78]
+       BAT[79] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9]
+       QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17] QT[18] QT[19]
+       QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28] QT[29]
+       QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38] QT[39]
+       QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49]
+       QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59]
+       QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+       QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79]
+       RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5] RBL[6] RBL[7] RBL[8] RBL[9]
+       RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15] RBL[16] RBL[17] RBL[18]
+       RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24] RBL[25] RBL[26] RBL[27]
+       RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33] RBL[34] RBL[35] RBL[36]
+       RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42] RBL[43] RBL[44] RBL[45]
+       RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51] RBL[52] RBL[53] RBL[54]
+       RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60] RBL[61] RBL[62] RBL[63]
+       RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69] RBL[70] RBL[71] RBL[72]
+       RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78] RBL[79] VBN[0] VBN[1]
+       VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11]
+       VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBP[0]
+       VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10]
+       VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19]
+       VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8]
+       VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16]
+       VDDA[17] VDDA[18] VDDA[19] VDDAI[0] VDDAI[1] VDDAI[2] VDDAI[3] VDDAI[4]
+       VDDAI[5] VDDAI[6] VDDAI[7] VDDAI[8] VDDAI[9] VDDAI[10] VDDAI[11]
+       VDDAI[12] VDDAI[13] VDDAI[14] VDDAI[15] VDDAI[16] VDDAI[17] VDDAI[18]
+       VDDAI[19] VDDAI_SAC[0] VDDAI_SAC[1] VDDAI_SAC[2] VDDAI_SAC[3]
+       VDDAI_SAC[4] VDDAI_SAC[5] VDDAI_SAC[6] VDDAI_SAC[7] VDDAI_SAC[8]
+       VDDAI_SAC[9] VDDAI_SAC[10] VDDAI_SAC[11] VDDAI_SAC[12] VDDAI_SAC[13]
+       VDDAI_SAC[14] VDDAI_SAC[15] VDDAI_SAC[16] VDDAI_SAC[17] VDDAI_SAC[18]
+       VDDAI_SAC[19] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6]
+       VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14]
+       VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDPI[0] VDDPI[1] VDDPI[2]
+       VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+       VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17]
+       VDDPI[18] VDDPI[19] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6]
+       VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15]
+       VSS[16] VSS[17] VSS[18] VSS[19] WLRD[0] WLRD[1] WLRD[2] WLRD[3] WLWR[0]
+       WLWR[1] WLWR[2] WLWR[3]
X_mm17a04_u_hdrf2p_ar4x4m1_S0 VDDA[0] VDDAI[0] VDDAI_SAC[0] VDDP[0] VDDPI[0]
+   VSS[0] VBP[0] VBN[0] BAB[0] BAB[1] BAB[2] BAB[3] BAT[0] BAT[1] BAT[2] BAT[3]
+   QT[0] QT[1] QT[2] QT[3] RBL[0] RBL[1] RBL[2] RBL[3] WLRD[0] WLRD[1] WLRD[2]
+   WLRD[3] WLWR[0] WLWR[1] WLWR[2] WLWR[3] mm17a04_u_hdrf2p_ar4x4m1
X_mm17a04_u_hdrf2p_ar4x4m1_S1 VDDA[1] VDDAI[1] VDDAI_SAC[1] VDDP[1] VDDPI[1]
+   VSS[1] VBP[1] VBN[1] BAB[4] BAB[5] BAB[6] BAB[7] BAT[4] BAT[5] BAT[6] BAT[7]
+   QT[4] QT[5] QT[6] QT[7] RBL[4] RBL[5] RBL[6] RBL[7] WLRD[0] WLRD[1] WLRD[2]
+   WLRD[3] WLWR[0] WLWR[1] WLWR[2] WLWR[3] mm17a04_u_hdrf2p_ar4x4m1
X_mm17a04_u_hdrf2p_ar4x4m1_S2 VDDA[2] VDDAI[2] VDDAI_SAC[2] VDDP[2] VDDPI[2]
+   VSS[2] VBP[2] VBN[2] BAB[8] BAB[9] BAB[10] BAB[11] BAT[8] BAT[9] BAT[10]
+   BAT[11] QT[8] QT[9] QT[10] QT[11] RBL[8] RBL[9] RBL[10] RBL[11] WLRD[0]
+   WLRD[1] WLRD[2] WLRD[3] WLWR[0] WLWR[1] WLWR[2] WLWR[3]
+   mm17a04_u_hdrf2p_ar4x4m1
X_mm17a04_u_hdrf2p_ar4x4m1_S3 VDDA[3] VDDAI[3] VDDAI_SAC[3] VDDP[3] VDDPI[3]
+   VSS[3] VBP[3] VBN[3] BAB[12] BAB[13] BAB[14] BAB[15] BAT[12] BAT[13] BAT[14]
+   BAT[15] QT[12] QT[13] QT[14] QT[15] RBL[12] RBL[13] RBL[14] RBL[15] WLRD[0]
+   WLRD[1] WLRD[2] WLRD[3] WLWR[0] WLWR[1] WLWR[2] WLWR[3]
+   mm17a04_u_hdrf2p_ar4x4m1
X_mm17a04_u_hdrf2p_ar4x4m1_S4 VDDA[4] VDDAI[4] VDDAI_SAC[4] VDDP[4] VDDPI[4]
+   VSS[4] VBP[4] VBN[4] BAB[16] BAB[17] BAB[18] BAB[19] BAT[16] BAT[17] BAT[18]
+   BAT[19] QT[16] QT[17] QT[18] QT[19] RBL[16] RBL[17] RBL[18] RBL[19] WLRD[0]
+   WLRD[1] WLRD[2] WLRD[3] WLWR[0] WLWR[1] WLWR[2] WLWR[3]
+   mm17a04_u_hdrf2p_ar4x4m1
X_mm17a04_u_hdrf2p_ar4x4m1_S5 VDDA[5] VDDAI[5] VDDAI_SAC[5] VDDP[5] VDDPI[5]
+   VSS[5] VBP[5] VBN[5] BAB[20] BAB[21] BAB[22] BAB[23] BAT[20] BAT[21] BAT[22]
+   BAT[23] QT[20] QT[21] QT[22] QT[23] RBL[20] RBL[21] RBL[22] RBL[23] WLRD[0]
+   WLRD[1] WLRD[2] WLRD[3] WLWR[0] WLWR[1] WLWR[2] WLWR[3]
+   mm17a04_u_hdrf2p_ar4x4m1
X_mm17a04_u_hdrf2p_ar4x4m1_S6 VDDA[6] VDDAI[6] VDDAI_SAC[6] VDDP[6] VDDPI[6]
+   VSS[6] VBP[6] VBN[6] BAB[24] BAB[25] BAB[26] BAB[27] BAT[24] BAT[25] BAT[26]
+   BAT[27] QT[24] QT[25] QT[26] QT[27] RBL[24] RBL[25] RBL[26] RBL[27] WLRD[0]
+   WLRD[1] WLRD[2] WLRD[3] WLWR[0] WLWR[1] WLWR[2] WLWR[3]
+   mm17a04_u_hdrf2p_ar4x4m1
X_mm17a04_u_hdrf2p_ar4x4m1_S7 VDDA[7] VDDAI[7] VDDAI_SAC[7] VDDP[7] VDDPI[7]
+   VSS[7] VBP[7] VBN[7] BAB[28] BAB[29] BAB[30] BAB[31] BAT[28] BAT[29] BAT[30]
+   BAT[31] QT[28] QT[29] QT[30] QT[31] RBL[28] RBL[29] RBL[30] RBL[31] WLRD[0]
+   WLRD[1] WLRD[2] WLRD[3] WLWR[0] WLWR[1] WLWR[2] WLWR[3]
+   mm17a04_u_hdrf2p_ar4x4m1
X_mm17a04_u_hdrf2p_ar4x4m1_S8 VDDA[8] VDDAI[8] VDDAI_SAC[8] VDDP[8] VDDPI[8]
+   VSS[8] VBP[8] VBN[8] BAB[32] BAB[33] BAB[34] BAB[35] BAT[32] BAT[33] BAT[34]
+   BAT[35] QT[32] QT[33] QT[34] QT[35] RBL[32] RBL[33] RBL[34] RBL[35] WLRD[0]
+   WLRD[1] WLRD[2] WLRD[3] WLWR[0] WLWR[1] WLWR[2] WLWR[3]
+   mm17a04_u_hdrf2p_ar4x4m1
X_mm17a04_u_hdrf2p_ar4x4m1_S9 VDDA[9] VDDAI[9] VDDAI_SAC[9] VDDP[9] VDDPI[9]
+   VSS[9] VBP[9] VBN[9] BAB[36] BAB[37] BAB[38] BAB[39] BAT[36] BAT[37] BAT[38]
+   BAT[39] QT[36] QT[37] QT[38] QT[39] RBL[36] RBL[37] RBL[38] RBL[39] WLRD[0]
+   WLRD[1] WLRD[2] WLRD[3] WLWR[0] WLWR[1] WLWR[2] WLWR[3]
+   mm17a04_u_hdrf2p_ar4x4m1
X_mm17a04_u_hdrf2p_ar4x4m1_F9 VDDA[10] VDDAI[10] VDDAI_SAC[10] VDDP[10]
+   VDDPI[10] VSS[10] VBP[10] VBN[10] BAB[40] BAB[41] BAB[42] BAB[43] BAT[40]
+   BAT[41] BAT[42] BAT[43] QT[40] QT[41] QT[42] QT[43] RBL[40] RBL[41] RBL[42]
+   RBL[43] WLRD[0] WLRD[1] WLRD[2] WLRD[3] WLWR[0] WLWR[1] WLWR[2] WLWR[3]
+   mm17a04_u_hdrf2p_ar4x4m1
X_mm17a04_u_hdrf2p_ar4x4m1_F8 VDDA[11] VDDAI[11] VDDAI_SAC[11] VDDP[11]
+   VDDPI[11] VSS[11] VBP[11] VBN[11] BAB[44] BAB[45] BAB[46] BAB[47] BAT[44]
+   BAT[45] BAT[46] BAT[47] QT[44] QT[45] QT[46] QT[47] RBL[44] RBL[45] RBL[46]
+   RBL[47] WLRD[0] WLRD[1] WLRD[2] WLRD[3] WLWR[0] WLWR[1] WLWR[2] WLWR[3]
+   mm17a04_u_hdrf2p_ar4x4m1
X_mm17a04_u_hdrf2p_ar4x4m1_F7 VDDA[12] VDDAI[12] VDDAI_SAC[12] VDDP[12]
+   VDDPI[12] VSS[12] VBP[12] VBN[12] BAB[48] BAB[49] BAB[50] BAB[51] BAT[48]
+   BAT[49] BAT[50] BAT[51] QT[48] QT[49] QT[50] QT[51] RBL[48] RBL[49] RBL[50]
+   RBL[51] WLRD[0] WLRD[1] WLRD[2] WLRD[3] WLWR[0] WLWR[1] WLWR[2] WLWR[3]
+   mm17a04_u_hdrf2p_ar4x4m1
X_mm17a04_u_hdrf2p_ar4x4m1_F6 VDDA[13] VDDAI[13] VDDAI_SAC[13] VDDP[13]
+   VDDPI[13] VSS[13] VBP[13] VBN[13] BAB[52] BAB[53] BAB[54] BAB[55] BAT[52]
+   BAT[53] BAT[54] BAT[55] QT[52] QT[53] QT[54] QT[55] RBL[52] RBL[53] RBL[54]
+   RBL[55] WLRD[0] WLRD[1] WLRD[2] WLRD[3] WLWR[0] WLWR[1] WLWR[2] WLWR[3]
+   mm17a04_u_hdrf2p_ar4x4m1
X_mm17a04_u_hdrf2p_ar4x4m1_F5 VDDA[14] VDDAI[14] VDDAI_SAC[14] VDDP[14]
+   VDDPI[14] VSS[14] VBP[14] VBN[14] BAB[56] BAB[57] BAB[58] BAB[59] BAT[56]
+   BAT[57] BAT[58] BAT[59] QT[56] QT[57] QT[58] QT[59] RBL[56] RBL[57] RBL[58]
+   RBL[59] WLRD[0] WLRD[1] WLRD[2] WLRD[3] WLWR[0] WLWR[1] WLWR[2] WLWR[3]
+   mm17a04_u_hdrf2p_ar4x4m1
X_mm17a04_u_hdrf2p_ar4x4m1_F4 VDDA[15] VDDAI[15] VDDAI_SAC[15] VDDP[15]
+   VDDPI[15] VSS[15] VBP[15] VBN[15] BAB[60] BAB[61] BAB[62] BAB[63] BAT[60]
+   BAT[61] BAT[62] BAT[63] QT[60] QT[61] QT[62] QT[63] RBL[60] RBL[61] RBL[62]
+   RBL[63] WLRD[0] WLRD[1] WLRD[2] WLRD[3] WLWR[0] WLWR[1] WLWR[2] WLWR[3]
+   mm17a04_u_hdrf2p_ar4x4m1
X_mm17a04_u_hdrf2p_ar4x4m1_F3 VDDA[16] VDDAI[16] VDDAI_SAC[16] VDDP[16]
+   VDDPI[16] VSS[16] VBP[16] VBN[16] BAB[64] BAB[65] BAB[66] BAB[67] BAT[64]
+   BAT[65] BAT[66] BAT[67] QT[64] QT[65] QT[66] QT[67] RBL[64] RBL[65] RBL[66]
+   RBL[67] WLRD[0] WLRD[1] WLRD[2] WLRD[3] WLWR[0] WLWR[1] WLWR[2] WLWR[3]
+   mm17a04_u_hdrf2p_ar4x4m1
X_mm17a04_u_hdrf2p_ar4x4m1_F2 VDDA[17] VDDAI[17] VDDAI_SAC[17] VDDP[17]
+   VDDPI[17] VSS[17] VBP[17] VBN[17] BAB[68] BAB[69] BAB[70] BAB[71] BAT[68]
+   BAT[69] BAT[70] BAT[71] QT[68] QT[69] QT[70] QT[71] RBL[68] RBL[69] RBL[70]
+   RBL[71] WLRD[0] WLRD[1] WLRD[2] WLRD[3] WLWR[0] WLWR[1] WLWR[2] WLWR[3]
+   mm17a04_u_hdrf2p_ar4x4m1
X_mm17a04_u_hdrf2p_ar4x4m1_F1 VDDA[18] VDDAI[18] VDDAI_SAC[18] VDDP[18]
+   VDDPI[18] VSS[18] VBP[18] VBN[18] BAB[72] BAB[73] BAB[74] BAB[75] BAT[72]
+   BAT[73] BAT[74] BAT[75] QT[72] QT[73] QT[74] QT[75] RBL[72] RBL[73] RBL[74]
+   RBL[75] WLRD[0] WLRD[1] WLRD[2] WLRD[3] WLWR[0] WLWR[1] WLWR[2] WLWR[3]
+   mm17a04_u_hdrf2p_ar4x4m1
X_mm17a04_u_hdrf2p_ar4x4m1_F0 VDDA[19] VDDAI[19] VDDAI_SAC[19] VDDP[19]
+   VDDPI[19] VSS[19] VBP[19] VBN[19] BAB[76] BAB[77] BAB[78] BAB[79] BAT[76]
+   BAT[77] BAT[78] BAT[79] QT[76] QT[77] QT[78] QT[79] RBL[76] RBL[77] RBL[78]
+   RBL[79] WLRD[0] WLRD[1] WLRD[2] WLRD[3] WLWR[0] WLWR[1] WLWR[2] WLWR[3]
+   mm17a04_u_hdrf2p_ar4x4m1
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_rt_b BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5]
+       BAB[6] BAB[7] BAB[8] BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14]
+       BAB[15] BAB[16] BAB[17] BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23]
+       BAB[24] BAB[25] BAB[26] BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32]
+       BAB[33] BAB[34] BAB[35] BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41]
+       BAB[42] BAB[43] BAB[44] BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50]
+       BAB[51] BAB[52] BAB[53] BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59]
+       BAB[60] BAB[61] BAB[62] BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68]
+       BAB[69] BAB[70] BAB[71] BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77]
+       BAB[78] BAB[79] BAB[80] BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86]
+       BAB[87] BAB[88] BAB[89] BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95]
+       BAB[96] BAB[97] BAB[98] BAB[99] BAB[100] BAB[101] BAB[102] BAB[103]
+       BAB[104] BAB[105] BAB[106] BAB[107] BAB[108] BAB[109] BAB[110] BAB[111]
+       BAB[112] BAB[113] BAB[114] BAB[115] BAB[116] BAB[117] BAB[118] BAB[119]
+       BAB[120] BAB[121] BAB[122] BAB[123] BAB[124] BAB[125] BAB[126] BAB[127]
+       BAB[128] BAB[129] BAB[130] BAB[131] BAB[132] BAB[133] BAB[134] BAB[135]
+       BAB[136] BAB[137] BAB[138] BAB[139] BAB[140] BAB[141] BAB[142] BAB[143]
+       BAB[144] BAB[145] BAB[146] BAB[147] BAB[148] BAB[149] BAB[150] BAB[151]
+       BAB[152] BAB[153] BAB[154] BAB[155] BAB[156] BAB[157] BAB[158] BAB[159]
+       BAT[0] BAT[1] BAT[2] BAT[3] BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9]
+       BAT[10] BAT[11] BAT[12] BAT[13] BAT[14] BAT[15] BAT[16] BAT[17] BAT[18]
+       BAT[19] BAT[20] BAT[21] BAT[22] BAT[23] BAT[24] BAT[25] BAT[26] BAT[27]
+       BAT[28] BAT[29] BAT[30] BAT[31] BAT[32] BAT[33] BAT[34] BAT[35] BAT[36]
+       BAT[37] BAT[38] BAT[39] BAT[40] BAT[41] BAT[42] BAT[43] BAT[44] BAT[45]
+       BAT[46] BAT[47] BAT[48] BAT[49] BAT[50] BAT[51] BAT[52] BAT[53] BAT[54]
+       BAT[55] BAT[56] BAT[57] BAT[58] BAT[59] BAT[60] BAT[61] BAT[62] BAT[63]
+       BAT[64] BAT[65] BAT[66] BAT[67] BAT[68] BAT[69] BAT[70] BAT[71] BAT[72]
+       BAT[73] BAT[74] BAT[75] BAT[76] BAT[77] BAT[78] BAT[79] BAT[80] BAT[81]
+       BAT[82] BAT[83] BAT[84] BAT[85] BAT[86] BAT[87] BAT[88] BAT[89] BAT[90]
+       BAT[91] BAT[92] BAT[93] BAT[94] BAT[95] BAT[96] BAT[97] BAT[98] BAT[99]
+       BAT[100] BAT[101] BAT[102] BAT[103] BAT[104] BAT[105] BAT[106] BAT[107]
+       BAT[108] BAT[109] BAT[110] BAT[111] BAT[112] BAT[113] BAT[114] BAT[115]
+       BAT[116] BAT[117] BAT[118] BAT[119] BAT[120] BAT[121] BAT[122] BAT[123]
+       BAT[124] BAT[125] BAT[126] BAT[127] BAT[128] BAT[129] BAT[130] BAT[131]
+       BAT[132] BAT[133] BAT[134] BAT[135] BAT[136] BAT[137] BAT[138] BAT[139]
+       BAT[140] BAT[141] BAT[142] BAT[143] BAT[144] BAT[145] BAT[146] BAT[147]
+       BAT[148] BAT[149] BAT[150] BAT[151] BAT[152] BAT[153] BAT[154] BAT[155]
+       BAT[156] BAT[157] BAT[158] BAT[159] DMY_EDGE_LB DMY_EDGE_LT
+       DMY_EDGE_RB[0] DMY_EDGE_RB[1] DMY_EDGE_RT[0] DMY_EDGE_RT[1] LCGTV LOG0
+       LOG1 PGIOI QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9]
+       QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17] QT[18] QT[19]
+       QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28] QT[29]
+       QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38] QT[39]
+       QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49]
+       QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59]
+       QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+       QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79]
+       QT[80] QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89]
+       QT[90] QT[91] QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99]
+       QT[100] QT[101] QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108]
+       QT[109] QT[110] QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117]
+       QT[118] QT[119] QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126]
+       QT[127] QT[128] QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135]
+       QT[136] QT[137] QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144]
+       QT[145] QT[146] QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153]
+       QT[154] QT[155] QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2]
+       RBL[3] RBL[4] RBL[5] RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12]
+       RBL[13] RBL[14] RBL[15] RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21]
+       RBL[22] RBL[23] RBL[24] RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30]
+       RBL[31] RBL[32] RBL[33] RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39]
+       RBL[40] RBL[41] RBL[42] RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48]
+       RBL[49] RBL[50] RBL[51] RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57]
+       RBL[58] RBL[59] RBL[60] RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66]
+       RBL[67] RBL[68] RBL[69] RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75]
+       RBL[76] RBL[77] RBL[78] RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84]
+       RBL[85] RBL[86] RBL[87] RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93]
+       RBL[94] RBL[95] RBL[96] RBL[97] RBL[98] RBL[99] RBL[100] RBL[101]
+       RBL[102] RBL[103] RBL[104] RBL[105] RBL[106] RBL[107] RBL[108] RBL[109]
+       RBL[110] RBL[111] RBL[112] RBL[113] RBL[114] RBL[115] RBL[116] RBL[117]
+       RBL[118] RBL[119] RBL[120] RBL[121] RBL[122] RBL[123] RBL[124] RBL[125]
+       RBL[126] RBL[127] RBL[128] RBL[129] RBL[130] RBL[131] RBL[132] RBL[133]
+       RBL[134] RBL[135] RBL[136] RBL[137] RBL[138] RBL[139] RBL[140] RBL[141]
+       RBL[142] RBL[143] RBL[144] RBL[145] RBL[146] RBL[147] RBL[148] RBL[149]
+       RBL[150] RBL[151] RBL[152] RBL[153] RBL[154] RBL[155] RBL[156] RBL[157]
+       RBL[158] RBL[159] RERASSB[0] RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3]
+       VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12]
+       VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20] VBN[21]
+       VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28] VBN[29] VBN[30]
+       VBN[31] VBN[32] VBN[33] VBN[34] VBN[35] VBN[36] VBN[37] VBN[38] VBN[39]
+       VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7]
+       VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+       VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+       VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32] VBP[33] VBP[34]
+       VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40] VBP[41] VDDA[0] VDDA[1]
+       VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10]
+       VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17] VDDA[18]
+       VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24] VDDA[25] VDDA[26]
+       VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31] VDDA[32] VDDA[33] VDDA[34]
+       VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39] VDDA[40] VDDA[41] VDDAIR1
+       VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+       VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+       VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20]
+       VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28]
+       VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34] VDDP[35] VDDP[36]
+       VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0] VDDPI[1] VDDPI[2]
+       VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+       VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17]
+       VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24]
+       VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31]
+       VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36] VDDPI[37] VDDPI[38]
+       VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF VDDWL_WR_REBUF VEDGE VSS[0]
+       VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+       VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19]
+       VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28]
+       VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34] VSS[35] VSS[36] VSS[37]
+       VSS[38] VSS[39] VSS[40] VSS[41] WLRD[0] WLRD[1] WLRD[2] WLRD[3] WLWR[0]
+       WLWR[1] WLWR[2] WLWR[3] WL_VSS
X_ary_rt_seg1_S0 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAT[0]
+   BAT[1] BAT[2] BAT[3] BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10]
+   BAT[11] BAT[12] BAT[13] BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19]
+   BAT[20] BAT[21] BAT[22] BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28]
+   BAT[29] BAT[30] BAT[31] BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37]
+   BAT[38] BAT[39] BAT[40] BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46]
+   BAT[47] BAT[48] BAT[49] BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55]
+   BAT[56] BAT[57] BAT[58] BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64]
+   BAT[65] BAT[66] BAT[67] BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73]
+   BAT[74] BAT[75] BAT[76] BAT[77] BAT[78] BAT[79] QT[0] QT[1] QT[2] QT[3]
+   QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] RBL[0]
+   RBL[1] RBL[2] RBL[3] RBL[4] RBL[5] RBL[6] RBL[7] RBL[8] RBL[9] RBL[10]
+   RBL[11] RBL[12] RBL[13] RBL[14] RBL[15] RBL[16] RBL[17] RBL[18] RBL[19]
+   RBL[20] RBL[21] RBL[22] RBL[23] RBL[24] RBL[25] RBL[26] RBL[27] RBL[28]
+   RBL[29] RBL[30] RBL[31] RBL[32] RBL[33] RBL[34] RBL[35] RBL[36] RBL[37]
+   RBL[38] RBL[39] RBL[40] RBL[41] RBL[42] RBL[43] RBL[44] RBL[45] RBL[46]
+   RBL[47] RBL[48] RBL[49] RBL[50] RBL[51] RBL[52] RBL[53] RBL[54] RBL[55]
+   RBL[56] RBL[57] RBL[58] RBL[59] RBL[60] RBL[61] RBL[62] RBL[63] RBL[64]
+   RBL[65] RBL[66] RBL[67] RBL[68] RBL[69] RBL[70] RBL[71] RBL[72] RBL[73]
+   RBL[74] RBL[75] RBL[76] RBL[77] RBL[78] RBL[79] VBN[0] VBN[1] VBN[2] VBN[3]
+   VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13]
+   VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VDDA[0] VDDA[1] VDDA[2]
+   VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11]
+   VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19]
+   VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1
+   VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1
+   VDDAIR1 VDDAIR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1
+   VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1
+   VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1
+   VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDPI[0] VDDPI[1]
+   VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9]
+   VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16]
+   VDDPI[17] VDDPI[18] VDDPI[19] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+   VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15]
+   VSS[16] VSS[17] VSS[18] VSS[19] WLRD[0] WLRD[1] WLRD[2] WLRD[3] WLWR[0]
+   WLWR[1] WLWR[2] WLWR[3] SNPS_RF_DP_UHD_512x80_ary_rt_seg1
X_mm17a04_u_hdrf2p_x4rebuf_b VDDA[20] VDDP[20] VDDPI[20] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VSS[20] VBP[20] VBN[20] REWLRD[0] REWLRD[1] REWLRD[2]
+   REWLRD[3] REWLWR[0] REWLWR[1] REWLWR[2] REWLWR[3] DMY_EDGE_LB DMY_EDGE_LT
+   DMY_EDGE_RB[0] DMY_EDGE_RT[0] LCGTV RERASSB[0] RERASSB[1] WL_VSS WLRD[0]
+   WLRD[1] WLRD[2] WLRD[3] WLWR[0] WLWR[1] WLWR[2] WLWR[3]
+   mm17a04_u_hdrf2p_x4rebuf
X_ary_rt_seg1_F0 BAB[80] BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87]
+   BAB[88] BAB[89] BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96]
+   BAB[97] BAB[98] BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104]
+   BAB[105] BAB[106] BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112]
+   BAB[113] BAB[114] BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120]
+   BAB[121] BAB[122] BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128]
+   BAB[129] BAB[130] BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136]
+   BAB[137] BAB[138] BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144]
+   BAB[145] BAB[146] BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152]
+   BAB[153] BAB[154] BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[80]
+   BAT[81] BAT[82] BAT[83] BAT[84] BAT[85] BAT[86] BAT[87] BAT[88] BAT[89]
+   BAT[90] BAT[91] BAT[92] BAT[93] BAT[94] BAT[95] BAT[96] BAT[97] BAT[98]
+   BAT[99] BAT[100] BAT[101] BAT[102] BAT[103] BAT[104] BAT[105] BAT[106]
+   BAT[107] BAT[108] BAT[109] BAT[110] BAT[111] BAT[112] BAT[113] BAT[114]
+   BAT[115] BAT[116] BAT[117] BAT[118] BAT[119] BAT[120] BAT[121] BAT[122]
+   BAT[123] BAT[124] BAT[125] BAT[126] BAT[127] BAT[128] BAT[129] BAT[130]
+   BAT[131] BAT[132] BAT[133] BAT[134] BAT[135] BAT[136] BAT[137] BAT[138]
+   BAT[139] BAT[140] BAT[141] BAT[142] BAT[143] BAT[144] BAT[145] BAT[146]
+   BAT[147] BAT[148] BAT[149] BAT[150] BAT[151] BAT[152] BAT[153] BAT[154]
+   BAT[155] BAT[156] BAT[157] BAT[158] BAT[159] QT[80] QT[81] QT[82] QT[83]
+   QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91] QT[92] QT[93] QT[94]
+   QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101] QT[102] QT[103] QT[104]
+   QT[105] QT[106] QT[107] QT[108] QT[109] QT[110] QT[111] QT[112] QT[113]
+   QT[114] QT[115] QT[116] QT[117] QT[118] QT[119] QT[120] QT[121] QT[122]
+   QT[123] QT[124] QT[125] QT[126] QT[127] QT[128] QT[129] QT[130] QT[131]
+   QT[132] QT[133] QT[134] QT[135] QT[136] QT[137] QT[138] QT[139] QT[140]
+   QT[141] QT[142] QT[143] QT[144] QT[145] QT[146] QT[147] QT[148] QT[149]
+   QT[150] QT[151] QT[152] QT[153] QT[154] QT[155] QT[156] QT[157] QT[158]
+   QT[159] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] VBN[21]
+   VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28] VBN[29] VBN[30]
+   VBN[31] VBN[32] VBN[33] VBN[34] VBN[35] VBN[36] VBN[37] VBN[38] VBN[39]
+   VBN[40] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28]
+   VBP[29] VBP[30] VBP[31] VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37]
+   VBP[38] VBP[39] VBP[40] VDDA[21] VDDA[22] VDDA[23] VDDA[24] VDDA[25]
+   VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31] VDDA[32] VDDA[33]
+   VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39] VDDA[40] VDDAIR2
+   VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2
+   VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2
+   VDDAIR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2
+   VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2
+   VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2
+   VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDP[21] VDDP[22] VDDP[23] VDDP[24]
+   VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32]
+   VDDP[33] VDDP[34] VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40]
+   VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27]
+   VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34]
+   VDDPI[35] VDDPI[36] VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VSS[21] VSS[22]
+   VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31]
+   VSS[32] VSS[33] VSS[34] VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40]
+   REWLRD[0] REWLRD[1] REWLRD[2] REWLRD[3] REWLWR[0] REWLWR[1] REWLWR[2]
+   REWLWR[3] SNPS_RF_DP_UHD_512x80_ary_rt_seg1
X_mm17a04_u_hdrf2p_edge4_dp VDDA[41] VDDP[41] VDDPI[41] VSS[41] VBP[41] VBN[41]
+   DMY_EDGE_RB[1] DMY_EDGE_RT[1] LOG0 LOG1 PGIOI VEDGE REWLRD[0] REWLRD[1]
+   REWLRD[2] REWLRD[3] REWLWR[0] REWLWR[1] REWLWR[2] REWLWR[3]
+   mm17a04_u_hdrf2p_edge4_dp
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_rt_a BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5]
+       BAB[6] BAB[7] BAB[8] BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14]
+       BAB[15] BAB[16] BAB[17] BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23]
+       BAB[24] BAB[25] BAB[26] BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32]
+       BAB[33] BAB[34] BAB[35] BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41]
+       BAB[42] BAB[43] BAB[44] BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50]
+       BAB[51] BAB[52] BAB[53] BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59]
+       BAB[60] BAB[61] BAB[62] BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68]
+       BAB[69] BAB[70] BAB[71] BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77]
+       BAB[78] BAB[79] BAB[80] BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86]
+       BAB[87] BAB[88] BAB[89] BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95]
+       BAB[96] BAB[97] BAB[98] BAB[99] BAB[100] BAB[101] BAB[102] BAB[103]
+       BAB[104] BAB[105] BAB[106] BAB[107] BAB[108] BAB[109] BAB[110] BAB[111]
+       BAB[112] BAB[113] BAB[114] BAB[115] BAB[116] BAB[117] BAB[118] BAB[119]
+       BAB[120] BAB[121] BAB[122] BAB[123] BAB[124] BAB[125] BAB[126] BAB[127]
+       BAB[128] BAB[129] BAB[130] BAB[131] BAB[132] BAB[133] BAB[134] BAB[135]
+       BAB[136] BAB[137] BAB[138] BAB[139] BAB[140] BAB[141] BAB[142] BAB[143]
+       BAB[144] BAB[145] BAB[146] BAB[147] BAB[148] BAB[149] BAB[150] BAB[151]
+       BAB[152] BAB[153] BAB[154] BAB[155] BAB[156] BAB[157] BAB[158] BAB[159]
+       BAT[0] BAT[1] BAT[2] BAT[3] BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9]
+       BAT[10] BAT[11] BAT[12] BAT[13] BAT[14] BAT[15] BAT[16] BAT[17] BAT[18]
+       BAT[19] BAT[20] BAT[21] BAT[22] BAT[23] BAT[24] BAT[25] BAT[26] BAT[27]
+       BAT[28] BAT[29] BAT[30] BAT[31] BAT[32] BAT[33] BAT[34] BAT[35] BAT[36]
+       BAT[37] BAT[38] BAT[39] BAT[40] BAT[41] BAT[42] BAT[43] BAT[44] BAT[45]
+       BAT[46] BAT[47] BAT[48] BAT[49] BAT[50] BAT[51] BAT[52] BAT[53] BAT[54]
+       BAT[55] BAT[56] BAT[57] BAT[58] BAT[59] BAT[60] BAT[61] BAT[62] BAT[63]
+       BAT[64] BAT[65] BAT[66] BAT[67] BAT[68] BAT[69] BAT[70] BAT[71] BAT[72]
+       BAT[73] BAT[74] BAT[75] BAT[76] BAT[77] BAT[78] BAT[79] BAT[80] BAT[81]
+       BAT[82] BAT[83] BAT[84] BAT[85] BAT[86] BAT[87] BAT[88] BAT[89] BAT[90]
+       BAT[91] BAT[92] BAT[93] BAT[94] BAT[95] BAT[96] BAT[97] BAT[98] BAT[99]
+       BAT[100] BAT[101] BAT[102] BAT[103] BAT[104] BAT[105] BAT[106] BAT[107]
+       BAT[108] BAT[109] BAT[110] BAT[111] BAT[112] BAT[113] BAT[114] BAT[115]
+       BAT[116] BAT[117] BAT[118] BAT[119] BAT[120] BAT[121] BAT[122] BAT[123]
+       BAT[124] BAT[125] BAT[126] BAT[127] BAT[128] BAT[129] BAT[130] BAT[131]
+       BAT[132] BAT[133] BAT[134] BAT[135] BAT[136] BAT[137] BAT[138] BAT[139]
+       BAT[140] BAT[141] BAT[142] BAT[143] BAT[144] BAT[145] BAT[146] BAT[147]
+       BAT[148] BAT[149] BAT[150] BAT[151] BAT[152] BAT[153] BAT[154] BAT[155]
+       BAT[156] BAT[157] BAT[158] BAT[159] DMY_EDGE_LB DMY_EDGE_LT
+       DMY_EDGE_RB[0] DMY_EDGE_RB[1] DMY_EDGE_RT[0] DMY_EDGE_RT[1] LCGTV LOG0
+       LOG1 PGIOI QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9]
+       QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17] QT[18] QT[19]
+       QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28] QT[29]
+       QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38] QT[39]
+       QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49]
+       QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59]
+       QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+       QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79]
+       QT[80] QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89]
+       QT[90] QT[91] QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99]
+       QT[100] QT[101] QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108]
+       QT[109] QT[110] QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117]
+       QT[118] QT[119] QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126]
+       QT[127] QT[128] QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135]
+       QT[136] QT[137] QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144]
+       QT[145] QT[146] QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153]
+       QT[154] QT[155] QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2]
+       RBL[3] RBL[4] RBL[5] RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12]
+       RBL[13] RBL[14] RBL[15] RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21]
+       RBL[22] RBL[23] RBL[24] RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30]
+       RBL[31] RBL[32] RBL[33] RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39]
+       RBL[40] RBL[41] RBL[42] RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48]
+       RBL[49] RBL[50] RBL[51] RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57]
+       RBL[58] RBL[59] RBL[60] RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66]
+       RBL[67] RBL[68] RBL[69] RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75]
+       RBL[76] RBL[77] RBL[78] RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84]
+       RBL[85] RBL[86] RBL[87] RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93]
+       RBL[94] RBL[95] RBL[96] RBL[97] RBL[98] RBL[99] RBL[100] RBL[101]
+       RBL[102] RBL[103] RBL[104] RBL[105] RBL[106] RBL[107] RBL[108] RBL[109]
+       RBL[110] RBL[111] RBL[112] RBL[113] RBL[114] RBL[115] RBL[116] RBL[117]
+       RBL[118] RBL[119] RBL[120] RBL[121] RBL[122] RBL[123] RBL[124] RBL[125]
+       RBL[126] RBL[127] RBL[128] RBL[129] RBL[130] RBL[131] RBL[132] RBL[133]
+       RBL[134] RBL[135] RBL[136] RBL[137] RBL[138] RBL[139] RBL[140] RBL[141]
+       RBL[142] RBL[143] RBL[144] RBL[145] RBL[146] RBL[147] RBL[148] RBL[149]
+       RBL[150] RBL[151] RBL[152] RBL[153] RBL[154] RBL[155] RBL[156] RBL[157]
+       RBL[158] RBL[159] RERASSB[0] RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3]
+       VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12]
+       VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20] VBN[21]
+       VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28] VBN[29] VBN[30]
+       VBN[31] VBN[32] VBN[33] VBN[34] VBN[35] VBN[36] VBN[37] VBN[38] VBN[39]
+       VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7]
+       VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+       VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+       VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32] VBP[33] VBP[34]
+       VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40] VBP[41] VDDA[0] VDDA[1]
+       VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10]
+       VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17] VDDA[18]
+       VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24] VDDA[25] VDDA[26]
+       VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31] VDDA[32] VDDA[33] VDDA[34]
+       VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39] VDDA[40] VDDA[41] VDDAIR1
+       VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+       VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+       VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20]
+       VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28]
+       VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34] VDDP[35] VDDP[36]
+       VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0] VDDPI[1] VDDPI[2]
+       VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+       VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17]
+       VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24]
+       VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31]
+       VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36] VDDPI[37] VDDPI[38]
+       VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF VDDWL_WR_REBUF VEDGE VSS[0]
+       VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+       VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19]
+       VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28]
+       VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34] VSS[35] VSS[36] VSS[37]
+       VSS[38] VSS[39] VSS[40] VSS[41] WLRD[0] WLRD[1] WLRD[2] WLRD[3] WLWR[0]
+       WLWR[1] WLWR[2] WLWR[3] WL_VSS
X_ary_rt_seg1_S0 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAT[0]
+   BAT[1] BAT[2] BAT[3] BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10]
+   BAT[11] BAT[12] BAT[13] BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19]
+   BAT[20] BAT[21] BAT[22] BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28]
+   BAT[29] BAT[30] BAT[31] BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37]
+   BAT[38] BAT[39] BAT[40] BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46]
+   BAT[47] BAT[48] BAT[49] BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55]
+   BAT[56] BAT[57] BAT[58] BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64]
+   BAT[65] BAT[66] BAT[67] BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73]
+   BAT[74] BAT[75] BAT[76] BAT[77] BAT[78] BAT[79] QT[0] QT[1] QT[2] QT[3]
+   QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] RBL[0]
+   RBL[1] RBL[2] RBL[3] RBL[4] RBL[5] RBL[6] RBL[7] RBL[8] RBL[9] RBL[10]
+   RBL[11] RBL[12] RBL[13] RBL[14] RBL[15] RBL[16] RBL[17] RBL[18] RBL[19]
+   RBL[20] RBL[21] RBL[22] RBL[23] RBL[24] RBL[25] RBL[26] RBL[27] RBL[28]
+   RBL[29] RBL[30] RBL[31] RBL[32] RBL[33] RBL[34] RBL[35] RBL[36] RBL[37]
+   RBL[38] RBL[39] RBL[40] RBL[41] RBL[42] RBL[43] RBL[44] RBL[45] RBL[46]
+   RBL[47] RBL[48] RBL[49] RBL[50] RBL[51] RBL[52] RBL[53] RBL[54] RBL[55]
+   RBL[56] RBL[57] RBL[58] RBL[59] RBL[60] RBL[61] RBL[62] RBL[63] RBL[64]
+   RBL[65] RBL[66] RBL[67] RBL[68] RBL[69] RBL[70] RBL[71] RBL[72] RBL[73]
+   RBL[74] RBL[75] RBL[76] RBL[77] RBL[78] RBL[79] VBN[0] VBN[1] VBN[2] VBN[3]
+   VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13]
+   VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VDDA[0] VDDA[1] VDDA[2]
+   VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11]
+   VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19]
+   VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1
+   VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1
+   VDDAIR1 VDDAIR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1
+   VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1
+   VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1
+   VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDPI[0] VDDPI[1]
+   VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9]
+   VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16]
+   VDDPI[17] VDDPI[18] VDDPI[19] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+   VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15]
+   VSS[16] VSS[17] VSS[18] VSS[19] WLRD[0] WLRD[1] WLRD[2] WLRD[3] WLWR[0]
+   WLWR[1] WLWR[2] WLWR[3] SNPS_RF_DP_UHD_512x80_ary_rt_seg1
X_mm17a04_u_hdrf2p_x4rebuf_a VDDA[20] VDDP[20] VDDPI[20] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VSS[20] VBP[20] VBN[20] REWLRD[0] REWLRD[1] REWLRD[2]
+   REWLRD[3] REWLWR[0] REWLWR[1] REWLWR[2] REWLWR[3] DMY_EDGE_LB DMY_EDGE_LT
+   DMY_EDGE_RB[0] DMY_EDGE_RT[0] LCGTV RERASSB[0] RERASSB[1] WL_VSS WLRD[0]
+   WLRD[1] WLRD[2] WLRD[3] WLWR[0] WLWR[1] WLWR[2] WLWR[3]
+   mm17a04_u_hdrf2p_x4rebuf
X_ary_rt_seg1_F0 BAB[80] BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87]
+   BAB[88] BAB[89] BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96]
+   BAB[97] BAB[98] BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104]
+   BAB[105] BAB[106] BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112]
+   BAB[113] BAB[114] BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120]
+   BAB[121] BAB[122] BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128]
+   BAB[129] BAB[130] BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136]
+   BAB[137] BAB[138] BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144]
+   BAB[145] BAB[146] BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152]
+   BAB[153] BAB[154] BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[80]
+   BAT[81] BAT[82] BAT[83] BAT[84] BAT[85] BAT[86] BAT[87] BAT[88] BAT[89]
+   BAT[90] BAT[91] BAT[92] BAT[93] BAT[94] BAT[95] BAT[96] BAT[97] BAT[98]
+   BAT[99] BAT[100] BAT[101] BAT[102] BAT[103] BAT[104] BAT[105] BAT[106]
+   BAT[107] BAT[108] BAT[109] BAT[110] BAT[111] BAT[112] BAT[113] BAT[114]
+   BAT[115] BAT[116] BAT[117] BAT[118] BAT[119] BAT[120] BAT[121] BAT[122]
+   BAT[123] BAT[124] BAT[125] BAT[126] BAT[127] BAT[128] BAT[129] BAT[130]
+   BAT[131] BAT[132] BAT[133] BAT[134] BAT[135] BAT[136] BAT[137] BAT[138]
+   BAT[139] BAT[140] BAT[141] BAT[142] BAT[143] BAT[144] BAT[145] BAT[146]
+   BAT[147] BAT[148] BAT[149] BAT[150] BAT[151] BAT[152] BAT[153] BAT[154]
+   BAT[155] BAT[156] BAT[157] BAT[158] BAT[159] QT[80] QT[81] QT[82] QT[83]
+   QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91] QT[92] QT[93] QT[94]
+   QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101] QT[102] QT[103] QT[104]
+   QT[105] QT[106] QT[107] QT[108] QT[109] QT[110] QT[111] QT[112] QT[113]
+   QT[114] QT[115] QT[116] QT[117] QT[118] QT[119] QT[120] QT[121] QT[122]
+   QT[123] QT[124] QT[125] QT[126] QT[127] QT[128] QT[129] QT[130] QT[131]
+   QT[132] QT[133] QT[134] QT[135] QT[136] QT[137] QT[138] QT[139] QT[140]
+   QT[141] QT[142] QT[143] QT[144] QT[145] QT[146] QT[147] QT[148] QT[149]
+   QT[150] QT[151] QT[152] QT[153] QT[154] QT[155] QT[156] QT[157] QT[158]
+   QT[159] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] VBN[21]
+   VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28] VBN[29] VBN[30]
+   VBN[31] VBN[32] VBN[33] VBN[34] VBN[35] VBN[36] VBN[37] VBN[38] VBN[39]
+   VBN[40] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28]
+   VBP[29] VBP[30] VBP[31] VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37]
+   VBP[38] VBP[39] VBP[40] VDDA[21] VDDA[22] VDDA[23] VDDA[24] VDDA[25]
+   VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31] VDDA[32] VDDA[33]
+   VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39] VDDA[40] VDDAIR2
+   VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2
+   VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2
+   VDDAIR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2
+   VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2
+   VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2
+   VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDP[21] VDDP[22] VDDP[23] VDDP[24]
+   VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32]
+   VDDP[33] VDDP[34] VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40]
+   VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27]
+   VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34]
+   VDDPI[35] VDDPI[36] VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VSS[21] VSS[22]
+   VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31]
+   VSS[32] VSS[33] VSS[34] VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40]
+   REWLRD[0] REWLRD[1] REWLRD[2] REWLRD[3] REWLWR[0] REWLWR[1] REWLWR[2]
+   REWLWR[3] SNPS_RF_DP_UHD_512x80_ary_rt_seg1
X_mm17a04_u_hdrf2p_edge4_dp VDDA[41] VDDP[41] VDDPI[41] VSS[41] VBP[41] VBN[41]
+   DMY_EDGE_RB[1] DMY_EDGE_RT[1] LOG0 LOG1 PGIOI VEDGE REWLRD[0] REWLRD[1]
+   REWLRD[2] REWLRD[3] REWLWR[0] REWLWR[1] REWLWR[2] REWLWR[3]
+   mm17a04_u_hdrf2p_edge4_dp
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_rt_no_cut BAB[0] BAB[1] BAB[2] BAB[3] BAB[4]
+       BAB[5] BAB[6] BAB[7] BAB[8] BAB[9] BAB[10] BAB[11] BAB[12] BAB[13]
+       BAB[14] BAB[15] BAB[16] BAB[17] BAB[18] BAB[19] BAB[20] BAB[21] BAB[22]
+       BAB[23] BAB[24] BAB[25] BAB[26] BAB[27] BAB[28] BAB[29] BAB[30] BAB[31]
+       BAB[32] BAB[33] BAB[34] BAB[35] BAB[36] BAB[37] BAB[38] BAB[39] BAB[40]
+       BAB[41] BAB[42] BAB[43] BAB[44] BAB[45] BAB[46] BAB[47] BAB[48] BAB[49]
+       BAB[50] BAB[51] BAB[52] BAB[53] BAB[54] BAB[55] BAB[56] BAB[57] BAB[58]
+       BAB[59] BAB[60] BAB[61] BAB[62] BAB[63] BAB[64] BAB[65] BAB[66] BAB[67]
+       BAB[68] BAB[69] BAB[70] BAB[71] BAB[72] BAB[73] BAB[74] BAB[75] BAB[76]
+       BAB[77] BAB[78] BAB[79] BAB[80] BAB[81] BAB[82] BAB[83] BAB[84] BAB[85]
+       BAB[86] BAB[87] BAB[88] BAB[89] BAB[90] BAB[91] BAB[92] BAB[93] BAB[94]
+       BAB[95] BAB[96] BAB[97] BAB[98] BAB[99] BAB[100] BAB[101] BAB[102]
+       BAB[103] BAB[104] BAB[105] BAB[106] BAB[107] BAB[108] BAB[109] BAB[110]
+       BAB[111] BAB[112] BAB[113] BAB[114] BAB[115] BAB[116] BAB[117] BAB[118]
+       BAB[119] BAB[120] BAB[121] BAB[122] BAB[123] BAB[124] BAB[125] BAB[126]
+       BAB[127] BAB[128] BAB[129] BAB[130] BAB[131] BAB[132] BAB[133] BAB[134]
+       BAB[135] BAB[136] BAB[137] BAB[138] BAB[139] BAB[140] BAB[141] BAB[142]
+       BAB[143] BAB[144] BAB[145] BAB[146] BAB[147] BAB[148] BAB[149] BAB[150]
+       BAB[151] BAB[152] BAB[153] BAB[154] BAB[155] BAB[156] BAB[157] BAB[158]
+       BAB[159] BAT[0] BAT[1] BAT[2] BAT[3] BAT[4] BAT[5] BAT[6] BAT[7] BAT[8]
+       BAT[9] BAT[10] BAT[11] BAT[12] BAT[13] BAT[14] BAT[15] BAT[16] BAT[17]
+       BAT[18] BAT[19] BAT[20] BAT[21] BAT[22] BAT[23] BAT[24] BAT[25] BAT[26]
+       BAT[27] BAT[28] BAT[29] BAT[30] BAT[31] BAT[32] BAT[33] BAT[34] BAT[35]
+       BAT[36] BAT[37] BAT[38] BAT[39] BAT[40] BAT[41] BAT[42] BAT[43] BAT[44]
+       BAT[45] BAT[46] BAT[47] BAT[48] BAT[49] BAT[50] BAT[51] BAT[52] BAT[53]
+       BAT[54] BAT[55] BAT[56] BAT[57] BAT[58] BAT[59] BAT[60] BAT[61] BAT[62]
+       BAT[63] BAT[64] BAT[65] BAT[66] BAT[67] BAT[68] BAT[69] BAT[70] BAT[71]
+       BAT[72] BAT[73] BAT[74] BAT[75] BAT[76] BAT[77] BAT[78] BAT[79] BAT[80]
+       BAT[81] BAT[82] BAT[83] BAT[84] BAT[85] BAT[86] BAT[87] BAT[88] BAT[89]
+       BAT[90] BAT[91] BAT[92] BAT[93] BAT[94] BAT[95] BAT[96] BAT[97] BAT[98]
+       BAT[99] BAT[100] BAT[101] BAT[102] BAT[103] BAT[104] BAT[105] BAT[106]
+       BAT[107] BAT[108] BAT[109] BAT[110] BAT[111] BAT[112] BAT[113] BAT[114]
+       BAT[115] BAT[116] BAT[117] BAT[118] BAT[119] BAT[120] BAT[121] BAT[122]
+       BAT[123] BAT[124] BAT[125] BAT[126] BAT[127] BAT[128] BAT[129] BAT[130]
+       BAT[131] BAT[132] BAT[133] BAT[134] BAT[135] BAT[136] BAT[137] BAT[138]
+       BAT[139] BAT[140] BAT[141] BAT[142] BAT[143] BAT[144] BAT[145] BAT[146]
+       BAT[147] BAT[148] BAT[149] BAT[150] BAT[151] BAT[152] BAT[153] BAT[154]
+       BAT[155] BAT[156] BAT[157] BAT[158] BAT[159] DMY_EDGE_LT[1]
+       DMY_EDGE_LT[32] DMY_EDGE_RT[2] DMY_EDGE_RT[3] DMY_EDGE_RT[64]
+       DMY_EDGE_RT[65] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2] QT[3] QT[4]
+       QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15]
+       QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+       QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35]
+       QT[36] QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45]
+       QT[46] QT[47] QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55]
+       QT[56] QT[57] QT[58] QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65]
+       QT[66] QT[67] QT[68] QT[69] QT[70] QT[71] QT[72] QT[73] QT[74] QT[75]
+       QT[76] QT[77] QT[78] QT[79] QT[80] QT[81] QT[82] QT[83] QT[84] QT[85]
+       QT[86] QT[87] QT[88] QT[89] QT[90] QT[91] QT[92] QT[93] QT[94] QT[95]
+       QT[96] QT[97] QT[98] QT[99] QT[100] QT[101] QT[102] QT[103] QT[104]
+       QT[105] QT[106] QT[107] QT[108] QT[109] QT[110] QT[111] QT[112] QT[113]
+       QT[114] QT[115] QT[116] QT[117] QT[118] QT[119] QT[120] QT[121] QT[122]
+       QT[123] QT[124] QT[125] QT[126] QT[127] QT[128] QT[129] QT[130] QT[131]
+       QT[132] QT[133] QT[134] QT[135] QT[136] QT[137] QT[138] QT[139] QT[140]
+       QT[141] QT[142] QT[143] QT[144] QT[145] QT[146] QT[147] QT[148] QT[149]
+       QT[150] QT[151] QT[152] QT[153] QT[154] QT[155] QT[156] QT[157] QT[158]
+       QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5] RBL[6] RBL[7] RBL[8]
+       RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15] RBL[16] RBL[17]
+       RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24] RBL[25] RBL[26]
+       RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33] RBL[34] RBL[35]
+       RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42] RBL[43] RBL[44]
+       RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51] RBL[52] RBL[53]
+       RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60] RBL[61] RBL[62]
+       RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69] RBL[70] RBL[71]
+       RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78] RBL[79] RBL[80]
+       RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87] RBL[88] RBL[89]
+       RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96] RBL[97] RBL[98]
+       RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104] RBL[105] RBL[106]
+       RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112] RBL[113] RBL[114]
+       RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120] RBL[121] RBL[122]
+       RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128] RBL[129] RBL[130]
+       RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136] RBL[137] RBL[138]
+       RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144] RBL[145] RBL[146]
+       RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152] RBL[153] RBL[154]
+       RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0] RERASSB[1]
+       VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+       VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18]
+       VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27]
+       VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35] VBN[36]
+       VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3]
+       VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+       VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21]
+       VBP[22] VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30]
+       VBP[31] VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39]
+       VBP[40] VBP[41] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6]
+       VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+       VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22]
+       VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30]
+       VDDA[31] VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38]
+       VDDA[39] VDDA[40] VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2
+       VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8]
+       VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16]
+       VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24]
+       VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32]
+       VDDP[33] VDDP[34] VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40]
+       VDDP[41] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6]
+       VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13]
+       VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20]
+       VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27]
+       VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34]
+       VDDPI[35] VDDPI[36] VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41]
+       VDDWL_RD_REBUF VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4]
+       VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13]
+       VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22]
+       VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31]
+       VSS[32] VSS[33] VSS[34] VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40]
+       VSS[41] WLRD[0] WLRD[1] WLRD[2] WLRD[3] WLRD[4] WLRD[5] WLRD[6] WLRD[7]
+       WLRD[8] WLRD[9] WLRD[10] WLRD[11] WLRD[12] WLRD[13] WLRD[14] WLRD[15]
+       WLRD[16] WLRD[17] WLRD[18] WLRD[19] WLRD[20] WLRD[21] WLRD[22] WLRD[23]
+       WLRD[24] WLRD[25] WLRD[26] WLRD[27] WLRD[28] WLRD[29] WLRD[30] WLRD[31]
+       WLRD[32] WLRD[33] WLRD[34] WLRD[35] WLRD[36] WLRD[37] WLRD[38] WLRD[39]
+       WLRD[40] WLRD[41] WLRD[42] WLRD[43] WLRD[44] WLRD[45] WLRD[46] WLRD[47]
+       WLRD[48] WLRD[49] WLRD[50] WLRD[51] WLRD[52] WLRD[53] WLRD[54] WLRD[55]
+       WLRD[56] WLRD[57] WLRD[58] WLRD[59] WLRD[60] WLRD[61] WLRD[62] WLRD[63]
+       WLRD[64] WLRD[65] WLRD[66] WLRD[67] WLRD[68] WLRD[69] WLRD[70] WLRD[71]
+       WLRD[72] WLRD[73] WLRD[74] WLRD[75] WLRD[76] WLRD[77] WLRD[78] WLRD[79]
+       WLRD[80] WLRD[81] WLRD[82] WLRD[83] WLRD[84] WLRD[85] WLRD[86] WLRD[87]
+       WLRD[88] WLRD[89] WLRD[90] WLRD[91] WLRD[92] WLRD[93] WLRD[94] WLRD[95]
+       WLRD[96] WLRD[97] WLRD[98] WLRD[99] WLRD[100] WLRD[101] WLRD[102]
+       WLRD[103] WLRD[104] WLRD[105] WLRD[106] WLRD[107] WLRD[108] WLRD[109]
+       WLRD[110] WLRD[111] WLRD[112] WLRD[113] WLRD[114] WLRD[115] WLRD[116]
+       WLRD[117] WLRD[118] WLRD[119] WLRD[120] WLRD[121] WLRD[122] WLRD[123]
+       WLRD[124] WLRD[125] WLRD[126] WLRD[127] WLWR[0] WLWR[1] WLWR[2] WLWR[3]
+       WLWR[4] WLWR[5] WLWR[6] WLWR[7] WLWR[8] WLWR[9] WLWR[10] WLWR[11]
+       WLWR[12] WLWR[13] WLWR[14] WLWR[15] WLWR[16] WLWR[17] WLWR[18] WLWR[19]
+       WLWR[20] WLWR[21] WLWR[22] WLWR[23] WLWR[24] WLWR[25] WLWR[26] WLWR[27]
+       WLWR[28] WLWR[29] WLWR[30] WLWR[31] WLWR[32] WLWR[33] WLWR[34] WLWR[35]
+       WLWR[36] WLWR[37] WLWR[38] WLWR[39] WLWR[40] WLWR[41] WLWR[42] WLWR[43]
+       WLWR[44] WLWR[45] WLWR[46] WLWR[47] WLWR[48] WLWR[49] WLWR[50] WLWR[51]
+       WLWR[52] WLWR[53] WLWR[54] WLWR[55] WLWR[56] WLWR[57] WLWR[58] WLWR[59]
+       WLWR[60] WLWR[61] WLWR[62] WLWR[63] WLWR[64] WLWR[65] WLWR[66] WLWR[67]
+       WLWR[68] WLWR[69] WLWR[70] WLWR[71] WLWR[72] WLWR[73] WLWR[74] WLWR[75]
+       WLWR[76] WLWR[77] WLWR[78] WLWR[79] WLWR[80] WLWR[81] WLWR[82] WLWR[83]
+       WLWR[84] WLWR[85] WLWR[86] WLWR[87] WLWR[88] WLWR[89] WLWR[90] WLWR[91]
+       WLWR[92] WLWR[93] WLWR[94] WLWR[95] WLWR[96] WLWR[97] WLWR[98] WLWR[99]
+       WLWR[100] WLWR[101] WLWR[102] WLWR[103] WLWR[104] WLWR[105] WLWR[106]
+       WLWR[107] WLWR[108] WLWR[109] WLWR[110] WLWR[111] WLWR[112] WLWR[113]
+       WLWR[114] WLWR[115] WLWR[116] WLWR[117] WLWR[118] WLWR[119] WLWR[120]
+       WLWR[121] WLWR[122] WLWR[123] WLWR[124] WLWR[125] WLWR[126] WLWR[127]
+       WL_VSS
X_ary_rt_b_S0 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[1] DMY_EDGE_LT[0] DMY_EDGE_RT[2] DMY_EDGE_RT[3] DMY_EDGE_RT[0]
+   DMY_EDGE_RT[1] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2] QT[3] QT[4] QT[5]
+   QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16]
+   QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27]
+   QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38]
+   QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49]
+   QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60]
+   QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70] QT[71]
+   QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80] QT[81] QT[82]
+   QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91] QT[92] QT[93]
+   QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101] QT[102] QT[103]
+   QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110] QT[111] QT[112]
+   QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119] QT[120] QT[121]
+   QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128] QT[129] QT[130]
+   QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137] QT[138] QT[139]
+   QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146] QT[147] QT[148]
+   QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155] QT[156] QT[157]
+   QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5] RBL[6] RBL[7]
+   RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15] RBL[16]
+   RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24] RBL[25]
+   RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33] RBL[34]
+   RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42] RBL[43]
+   RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51] RBL[52]
+   RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60] RBL[61]
+   RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69] RBL[70]
+   RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78] RBL[79]
+   RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87] RBL[88]
+   RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96] RBL[97]
+   RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104] RBL[105]
+   RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112] RBL[113]
+   RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120] RBL[121]
+   RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128] RBL[129]
+   RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136] RBL[137]
+   RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144] RBL[145]
+   RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152] RBL[153]
+   RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0] RERASSB[1]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18]
+   VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27]
+   VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35] VBN[36]
+   VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4]
+   VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14]
+   VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23]
+   VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32]
+   VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40] VBP[41]
+   VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8]
+   VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16]
+   VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24]
+   VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31] VDDA[32]
+   VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39] VDDA[40]
+   VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1] VDDP[2]
+   VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11]
+   VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19]
+   VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27]
+   VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34] VDDP[35]
+   VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0] VDDPI[1]
+   VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9]
+   VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16]
+   VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23]
+   VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30]
+   VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36] VDDPI[37]
+   VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF VDDWL_WR_REBUF VEDGE
+   VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9]
+   VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18]
+   VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27]
+   VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34] VSS[35] VSS[36]
+   VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[0] WLRD[1] WLRD[2] WLRD[3]
+   WLWR[0] WLWR[1] WLWR[2] WLWR[3] WL_VSS SNPS_RF_DP_UHD_512x80_ary_rt_b
X_ary_rt_a_S0 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[0] DMY_EDGE_LT[2] DMY_EDGE_RT[0] DMY_EDGE_RT[1] DMY_EDGE_RT[4]
+   DMY_EDGE_RT[5] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2] QT[3] QT[4] QT[5]
+   QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16]
+   QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27]
+   QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38]
+   QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49]
+   QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60]
+   QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70] QT[71]
+   QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80] QT[81] QT[82]
+   QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91] QT[92] QT[93]
+   QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101] QT[102] QT[103]
+   QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110] QT[111] QT[112]
+   QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119] QT[120] QT[121]
+   QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128] QT[129] QT[130]
+   QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137] QT[138] QT[139]
+   QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146] QT[147] QT[148]
+   QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155] QT[156] QT[157]
+   QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5] RBL[6] RBL[7]
+   RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15] RBL[16]
+   RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24] RBL[25]
+   RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33] RBL[34]
+   RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42] RBL[43]
+   RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51] RBL[52]
+   RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60] RBL[61]
+   RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69] RBL[70]
+   RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78] RBL[79]
+   RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87] RBL[88]
+   RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96] RBL[97]
+   RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104] RBL[105]
+   RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112] RBL[113]
+   RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120] RBL[121]
+   RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128] RBL[129]
+   RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136] RBL[137]
+   RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144] RBL[145]
+   RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152] RBL[153]
+   RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0] RERASSB[1]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18]
+   VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27]
+   VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35] VBN[36]
+   VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4]
+   VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14]
+   VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23]
+   VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32]
+   VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40] VBP[41]
+   VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8]
+   VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16]
+   VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24]
+   VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31] VDDA[32]
+   VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39] VDDA[40]
+   VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1] VDDP[2]
+   VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11]
+   VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19]
+   VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27]
+   VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34] VDDP[35]
+   VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0] VDDPI[1]
+   VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9]
+   VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16]
+   VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23]
+   VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30]
+   VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36] VDDPI[37]
+   VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF VDDWL_WR_REBUF VEDGE
+   VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9]
+   VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18]
+   VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27]
+   VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34] VSS[35] VSS[36]
+   VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[4] WLRD[5] WLRD[6] WLRD[7]
+   WLWR[4] WLWR[5] WLWR[6] WLWR[7] WL_VSS SNPS_RF_DP_UHD_512x80_ary_rt_a
X_ary_rt_b_S1 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[2] DMY_EDGE_LT[3] DMY_EDGE_RT[4] DMY_EDGE_RT[5] DMY_EDGE_RT[6]
+   DMY_EDGE_RT[7] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2] QT[3] QT[4] QT[5]
+   QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16]
+   QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27]
+   QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38]
+   QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49]
+   QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60]
+   QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70] QT[71]
+   QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80] QT[81] QT[82]
+   QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91] QT[92] QT[93]
+   QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101] QT[102] QT[103]
+   QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110] QT[111] QT[112]
+   QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119] QT[120] QT[121]
+   QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128] QT[129] QT[130]
+   QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137] QT[138] QT[139]
+   QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146] QT[147] QT[148]
+   QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155] QT[156] QT[157]
+   QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5] RBL[6] RBL[7]
+   RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15] RBL[16]
+   RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24] RBL[25]
+   RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33] RBL[34]
+   RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42] RBL[43]
+   RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51] RBL[52]
+   RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60] RBL[61]
+   RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69] RBL[70]
+   RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78] RBL[79]
+   RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87] RBL[88]
+   RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96] RBL[97]
+   RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104] RBL[105]
+   RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112] RBL[113]
+   RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120] RBL[121]
+   RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128] RBL[129]
+   RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136] RBL[137]
+   RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144] RBL[145]
+   RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152] RBL[153]
+   RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0] RERASSB[1]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18]
+   VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27]
+   VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35] VBN[36]
+   VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4]
+   VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14]
+   VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23]
+   VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32]
+   VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40] VBP[41]
+   VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8]
+   VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16]
+   VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24]
+   VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31] VDDA[32]
+   VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39] VDDA[40]
+   VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1] VDDP[2]
+   VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11]
+   VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19]
+   VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27]
+   VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34] VDDP[35]
+   VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0] VDDPI[1]
+   VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9]
+   VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16]
+   VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23]
+   VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30]
+   VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36] VDDPI[37]
+   VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF VDDWL_WR_REBUF VEDGE
+   VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9]
+   VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18]
+   VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27]
+   VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34] VSS[35] VSS[36]
+   VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[8] WLRD[9] WLRD[10] WLRD[11]
+   WLWR[8] WLWR[9] WLWR[10] WLWR[11] WL_VSS SNPS_RF_DP_UHD_512x80_ary_rt_b
X_ary_rt_a_S1 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[3] DMY_EDGE_LT[4] DMY_EDGE_RT[6] DMY_EDGE_RT[7] DMY_EDGE_RT[8]
+   DMY_EDGE_RT[9] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2] QT[3] QT[4] QT[5]
+   QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16]
+   QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27]
+   QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38]
+   QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49]
+   QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60]
+   QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70] QT[71]
+   QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80] QT[81] QT[82]
+   QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91] QT[92] QT[93]
+   QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101] QT[102] QT[103]
+   QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110] QT[111] QT[112]
+   QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119] QT[120] QT[121]
+   QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128] QT[129] QT[130]
+   QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137] QT[138] QT[139]
+   QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146] QT[147] QT[148]
+   QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155] QT[156] QT[157]
+   QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5] RBL[6] RBL[7]
+   RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15] RBL[16]
+   RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24] RBL[25]
+   RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33] RBL[34]
+   RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42] RBL[43]
+   RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51] RBL[52]
+   RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60] RBL[61]
+   RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69] RBL[70]
+   RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78] RBL[79]
+   RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87] RBL[88]
+   RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96] RBL[97]
+   RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104] RBL[105]
+   RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112] RBL[113]
+   RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120] RBL[121]
+   RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128] RBL[129]
+   RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136] RBL[137]
+   RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144] RBL[145]
+   RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152] RBL[153]
+   RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0] RERASSB[1]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18]
+   VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27]
+   VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35] VBN[36]
+   VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4]
+   VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14]
+   VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23]
+   VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32]
+   VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40] VBP[41]
+   VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8]
+   VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16]
+   VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24]
+   VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31] VDDA[32]
+   VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39] VDDA[40]
+   VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1] VDDP[2]
+   VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11]
+   VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19]
+   VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27]
+   VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34] VDDP[35]
+   VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0] VDDPI[1]
+   VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9]
+   VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16]
+   VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23]
+   VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30]
+   VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36] VDDPI[37]
+   VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF VDDWL_WR_REBUF VEDGE
+   VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9]
+   VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18]
+   VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27]
+   VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34] VSS[35] VSS[36]
+   VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[12] WLRD[13] WLRD[14] WLRD[15]
+   WLWR[12] WLWR[13] WLWR[14] WLWR[15] WL_VSS SNPS_RF_DP_UHD_512x80_ary_rt_a
X_ary_rt_b_S2 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[4] DMY_EDGE_LT[5] DMY_EDGE_RT[8] DMY_EDGE_RT[9] DMY_EDGE_RT[10]
+   DMY_EDGE_RT[11] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2] QT[3] QT[4] QT[5]
+   QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16]
+   QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27]
+   QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38]
+   QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49]
+   QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60]
+   QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70] QT[71]
+   QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80] QT[81] QT[82]
+   QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91] QT[92] QT[93]
+   QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101] QT[102] QT[103]
+   QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110] QT[111] QT[112]
+   QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119] QT[120] QT[121]
+   QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128] QT[129] QT[130]
+   QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137] QT[138] QT[139]
+   QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146] QT[147] QT[148]
+   QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155] QT[156] QT[157]
+   QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5] RBL[6] RBL[7]
+   RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15] RBL[16]
+   RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24] RBL[25]
+   RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33] RBL[34]
+   RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42] RBL[43]
+   RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51] RBL[52]
+   RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60] RBL[61]
+   RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69] RBL[70]
+   RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78] RBL[79]
+   RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87] RBL[88]
+   RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96] RBL[97]
+   RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104] RBL[105]
+   RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112] RBL[113]
+   RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120] RBL[121]
+   RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128] RBL[129]
+   RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136] RBL[137]
+   RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144] RBL[145]
+   RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152] RBL[153]
+   RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0] RERASSB[1]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18]
+   VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27]
+   VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35] VBN[36]
+   VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4]
+   VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14]
+   VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23]
+   VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32]
+   VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40] VBP[41]
+   VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8]
+   VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16]
+   VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24]
+   VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31] VDDA[32]
+   VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39] VDDA[40]
+   VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1] VDDP[2]
+   VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11]
+   VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19]
+   VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27]
+   VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34] VDDP[35]
+   VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0] VDDPI[1]
+   VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9]
+   VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16]
+   VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23]
+   VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30]
+   VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36] VDDPI[37]
+   VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF VDDWL_WR_REBUF VEDGE
+   VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9]
+   VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18]
+   VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27]
+   VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34] VSS[35] VSS[36]
+   VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[16] WLRD[17] WLRD[18] WLRD[19]
+   WLWR[16] WLWR[17] WLWR[18] WLWR[19] WL_VSS SNPS_RF_DP_UHD_512x80_ary_rt_b
X_ary_rt_a_S2 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[5] DMY_EDGE_LT[6] DMY_EDGE_RT[10] DMY_EDGE_RT[11]
+   DMY_EDGE_RT[12] DMY_EDGE_RT[13] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+   QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91]
+   QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101]
+   QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110]
+   QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119]
+   QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128]
+   QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137]
+   QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146]
+   QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155]
+   QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5]
+   RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+   RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+   RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+   RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+   RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+   RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+   RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+   RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+   RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0]
+   RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+   VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+   VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+   VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+   VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+   VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40]
+   VBP[41] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+   VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23]
+   VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31]
+   VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39]
+   VDDA[40] VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+   VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+   VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+   VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+   VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34]
+   VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[20] WLRD[21]
+   WLRD[22] WLRD[23] WLWR[20] WLWR[21] WLWR[22] WLWR[23] WL_VSS
+   SNPS_RF_DP_UHD_512x80_ary_rt_a
X_ary_rt_b_S3 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[6] DMY_EDGE_LT[7] DMY_EDGE_RT[12] DMY_EDGE_RT[13]
+   DMY_EDGE_RT[14] DMY_EDGE_RT[15] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+   QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91]
+   QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101]
+   QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110]
+   QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119]
+   QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128]
+   QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137]
+   QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146]
+   QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155]
+   QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5]
+   RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+   RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+   RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+   RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+   RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+   RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+   RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+   RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+   RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0]
+   RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+   VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+   VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+   VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+   VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+   VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40]
+   VBP[41] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+   VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23]
+   VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31]
+   VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39]
+   VDDA[40] VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+   VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+   VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+   VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+   VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34]
+   VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[24] WLRD[25]
+   WLRD[26] WLRD[27] WLWR[24] WLWR[25] WLWR[26] WLWR[27] WL_VSS
+   SNPS_RF_DP_UHD_512x80_ary_rt_b
X_ary_rt_a_S3 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[7] DMY_EDGE_LT[8] DMY_EDGE_RT[14] DMY_EDGE_RT[15]
+   DMY_EDGE_RT[16] DMY_EDGE_RT[17] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+   QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91]
+   QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101]
+   QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110]
+   QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119]
+   QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128]
+   QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137]
+   QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146]
+   QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155]
+   QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5]
+   RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+   RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+   RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+   RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+   RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+   RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+   RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+   RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+   RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0]
+   RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+   VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+   VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+   VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+   VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+   VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40]
+   VBP[41] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+   VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23]
+   VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31]
+   VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39]
+   VDDA[40] VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+   VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+   VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+   VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+   VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34]
+   VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[28] WLRD[29]
+   WLRD[30] WLRD[31] WLWR[28] WLWR[29] WLWR[30] WLWR[31] WL_VSS
+   SNPS_RF_DP_UHD_512x80_ary_rt_a
X_ary_rt_b_S4 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[8] DMY_EDGE_LT[9] DMY_EDGE_RT[16] DMY_EDGE_RT[17]
+   DMY_EDGE_RT[18] DMY_EDGE_RT[19] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+   QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91]
+   QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101]
+   QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110]
+   QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119]
+   QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128]
+   QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137]
+   QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146]
+   QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155]
+   QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5]
+   RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+   RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+   RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+   RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+   RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+   RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+   RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+   RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+   RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0]
+   RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+   VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+   VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+   VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+   VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+   VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40]
+   VBP[41] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+   VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23]
+   VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31]
+   VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39]
+   VDDA[40] VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+   VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+   VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+   VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+   VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34]
+   VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[32] WLRD[33]
+   WLRD[34] WLRD[35] WLWR[32] WLWR[33] WLWR[34] WLWR[35] WL_VSS
+   SNPS_RF_DP_UHD_512x80_ary_rt_b
X_ary_rt_a_S4 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[9] DMY_EDGE_LT[10] DMY_EDGE_RT[18] DMY_EDGE_RT[19]
+   DMY_EDGE_RT[20] DMY_EDGE_RT[21] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+   QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91]
+   QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101]
+   QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110]
+   QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119]
+   QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128]
+   QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137]
+   QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146]
+   QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155]
+   QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5]
+   RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+   RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+   RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+   RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+   RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+   RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+   RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+   RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+   RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0]
+   RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+   VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+   VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+   VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+   VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+   VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40]
+   VBP[41] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+   VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23]
+   VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31]
+   VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39]
+   VDDA[40] VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+   VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+   VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+   VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+   VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34]
+   VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[36] WLRD[37]
+   WLRD[38] WLRD[39] WLWR[36] WLWR[37] WLWR[38] WLWR[39] WL_VSS
+   SNPS_RF_DP_UHD_512x80_ary_rt_a
X_ary_rt_b_S5 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[10] DMY_EDGE_LT[11] DMY_EDGE_RT[20] DMY_EDGE_RT[21]
+   DMY_EDGE_RT[22] DMY_EDGE_RT[23] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+   QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91]
+   QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101]
+   QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110]
+   QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119]
+   QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128]
+   QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137]
+   QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146]
+   QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155]
+   QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5]
+   RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+   RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+   RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+   RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+   RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+   RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+   RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+   RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+   RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0]
+   RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+   VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+   VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+   VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+   VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+   VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40]
+   VBP[41] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+   VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23]
+   VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31]
+   VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39]
+   VDDA[40] VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+   VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+   VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+   VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+   VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34]
+   VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[40] WLRD[41]
+   WLRD[42] WLRD[43] WLWR[40] WLWR[41] WLWR[42] WLWR[43] WL_VSS
+   SNPS_RF_DP_UHD_512x80_ary_rt_b
X_ary_rt_a_S5 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[11] DMY_EDGE_LT[12] DMY_EDGE_RT[22] DMY_EDGE_RT[23]
+   DMY_EDGE_RT[24] DMY_EDGE_RT[25] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+   QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91]
+   QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101]
+   QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110]
+   QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119]
+   QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128]
+   QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137]
+   QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146]
+   QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155]
+   QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5]
+   RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+   RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+   RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+   RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+   RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+   RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+   RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+   RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+   RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0]
+   RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+   VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+   VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+   VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+   VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+   VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40]
+   VBP[41] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+   VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23]
+   VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31]
+   VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39]
+   VDDA[40] VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+   VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+   VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+   VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+   VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34]
+   VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[44] WLRD[45]
+   WLRD[46] WLRD[47] WLWR[44] WLWR[45] WLWR[46] WLWR[47] WL_VSS
+   SNPS_RF_DP_UHD_512x80_ary_rt_a
X_ary_rt_b_S6 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[12] DMY_EDGE_LT[13] DMY_EDGE_RT[24] DMY_EDGE_RT[25]
+   DMY_EDGE_RT[26] DMY_EDGE_RT[27] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+   QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91]
+   QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101]
+   QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110]
+   QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119]
+   QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128]
+   QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137]
+   QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146]
+   QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155]
+   QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5]
+   RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+   RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+   RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+   RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+   RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+   RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+   RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+   RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+   RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0]
+   RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+   VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+   VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+   VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+   VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+   VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40]
+   VBP[41] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+   VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23]
+   VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31]
+   VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39]
+   VDDA[40] VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+   VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+   VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+   VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+   VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34]
+   VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[48] WLRD[49]
+   WLRD[50] WLRD[51] WLWR[48] WLWR[49] WLWR[50] WLWR[51] WL_VSS
+   SNPS_RF_DP_UHD_512x80_ary_rt_b
X_ary_rt_a_S6 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[13] DMY_EDGE_LT[14] DMY_EDGE_RT[26] DMY_EDGE_RT[27]
+   DMY_EDGE_RT[28] DMY_EDGE_RT[29] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+   QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91]
+   QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101]
+   QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110]
+   QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119]
+   QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128]
+   QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137]
+   QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146]
+   QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155]
+   QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5]
+   RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+   RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+   RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+   RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+   RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+   RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+   RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+   RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+   RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0]
+   RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+   VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+   VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+   VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+   VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+   VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40]
+   VBP[41] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+   VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23]
+   VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31]
+   VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39]
+   VDDA[40] VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+   VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+   VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+   VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+   VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34]
+   VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[52] WLRD[53]
+   WLRD[54] WLRD[55] WLWR[52] WLWR[53] WLWR[54] WLWR[55] WL_VSS
+   SNPS_RF_DP_UHD_512x80_ary_rt_a
X_ary_rt_b_S7 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[14] DMY_EDGE_LT[15] DMY_EDGE_RT[28] DMY_EDGE_RT[29]
+   DMY_EDGE_RT[30] DMY_EDGE_RT[31] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+   QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91]
+   QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101]
+   QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110]
+   QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119]
+   QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128]
+   QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137]
+   QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146]
+   QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155]
+   QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5]
+   RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+   RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+   RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+   RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+   RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+   RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+   RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+   RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+   RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0]
+   RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+   VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+   VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+   VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+   VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+   VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40]
+   VBP[41] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+   VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23]
+   VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31]
+   VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39]
+   VDDA[40] VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+   VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+   VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+   VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+   VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34]
+   VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[56] WLRD[57]
+   WLRD[58] WLRD[59] WLWR[56] WLWR[57] WLWR[58] WLWR[59] WL_VSS
+   SNPS_RF_DP_UHD_512x80_ary_rt_b
X_ary_rt_a_S7 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[15] DMY_EDGE_LT[16] DMY_EDGE_RT[30] DMY_EDGE_RT[31]
+   DMY_EDGE_RT[32] DMY_EDGE_RT[33] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+   QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91]
+   QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101]
+   QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110]
+   QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119]
+   QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128]
+   QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137]
+   QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146]
+   QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155]
+   QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5]
+   RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+   RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+   RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+   RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+   RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+   RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+   RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+   RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+   RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0]
+   RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+   VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+   VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+   VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+   VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+   VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40]
+   VBP[41] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+   VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23]
+   VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31]
+   VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39]
+   VDDA[40] VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+   VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+   VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+   VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+   VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34]
+   VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[60] WLRD[61]
+   WLRD[62] WLRD[63] WLWR[60] WLWR[61] WLWR[62] WLWR[63] WL_VSS
+   SNPS_RF_DP_UHD_512x80_ary_rt_a
X_ary_rt_b_F7 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[16] DMY_EDGE_LT[17] DMY_EDGE_RT[32] DMY_EDGE_RT[33]
+   DMY_EDGE_RT[34] DMY_EDGE_RT[35] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+   QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91]
+   QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101]
+   QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110]
+   QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119]
+   QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128]
+   QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137]
+   QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146]
+   QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155]
+   QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5]
+   RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+   RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+   RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+   RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+   RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+   RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+   RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+   RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+   RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0]
+   RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+   VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+   VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+   VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+   VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+   VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40]
+   VBP[41] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+   VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23]
+   VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31]
+   VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39]
+   VDDA[40] VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+   VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+   VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+   VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+   VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34]
+   VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[64] WLRD[65]
+   WLRD[66] WLRD[67] WLWR[64] WLWR[65] WLWR[66] WLWR[67] WL_VSS
+   SNPS_RF_DP_UHD_512x80_ary_rt_b
X_ary_rt_a_F7 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[17] DMY_EDGE_LT[18] DMY_EDGE_RT[34] DMY_EDGE_RT[35]
+   DMY_EDGE_RT[36] DMY_EDGE_RT[37] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+   QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91]
+   QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101]
+   QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110]
+   QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119]
+   QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128]
+   QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137]
+   QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146]
+   QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155]
+   QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5]
+   RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+   RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+   RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+   RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+   RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+   RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+   RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+   RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+   RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0]
+   RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+   VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+   VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+   VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+   VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+   VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40]
+   VBP[41] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+   VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23]
+   VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31]
+   VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39]
+   VDDA[40] VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+   VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+   VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+   VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+   VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34]
+   VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[68] WLRD[69]
+   WLRD[70] WLRD[71] WLWR[68] WLWR[69] WLWR[70] WLWR[71] WL_VSS
+   SNPS_RF_DP_UHD_512x80_ary_rt_a
X_ary_rt_b_F6 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[18] DMY_EDGE_LT[19] DMY_EDGE_RT[36] DMY_EDGE_RT[37]
+   DMY_EDGE_RT[38] DMY_EDGE_RT[39] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+   QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91]
+   QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101]
+   QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110]
+   QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119]
+   QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128]
+   QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137]
+   QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146]
+   QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155]
+   QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5]
+   RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+   RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+   RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+   RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+   RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+   RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+   RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+   RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+   RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0]
+   RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+   VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+   VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+   VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+   VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+   VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40]
+   VBP[41] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+   VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23]
+   VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31]
+   VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39]
+   VDDA[40] VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+   VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+   VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+   VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+   VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34]
+   VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[72] WLRD[73]
+   WLRD[74] WLRD[75] WLWR[72] WLWR[73] WLWR[74] WLWR[75] WL_VSS
+   SNPS_RF_DP_UHD_512x80_ary_rt_b
X_ary_rt_a_F6 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[19] DMY_EDGE_LT[20] DMY_EDGE_RT[38] DMY_EDGE_RT[39]
+   DMY_EDGE_RT[40] DMY_EDGE_RT[41] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+   QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91]
+   QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101]
+   QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110]
+   QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119]
+   QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128]
+   QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137]
+   QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146]
+   QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155]
+   QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5]
+   RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+   RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+   RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+   RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+   RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+   RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+   RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+   RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+   RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0]
+   RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+   VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+   VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+   VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+   VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+   VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40]
+   VBP[41] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+   VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23]
+   VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31]
+   VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39]
+   VDDA[40] VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+   VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+   VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+   VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+   VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34]
+   VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[76] WLRD[77]
+   WLRD[78] WLRD[79] WLWR[76] WLWR[77] WLWR[78] WLWR[79] WL_VSS
+   SNPS_RF_DP_UHD_512x80_ary_rt_a
X_ary_rt_b_F5 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[20] DMY_EDGE_LT[21] DMY_EDGE_RT[40] DMY_EDGE_RT[41]
+   DMY_EDGE_RT[42] DMY_EDGE_RT[43] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+   QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91]
+   QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101]
+   QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110]
+   QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119]
+   QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128]
+   QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137]
+   QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146]
+   QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155]
+   QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5]
+   RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+   RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+   RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+   RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+   RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+   RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+   RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+   RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+   RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0]
+   RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+   VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+   VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+   VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+   VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+   VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40]
+   VBP[41] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+   VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23]
+   VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31]
+   VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39]
+   VDDA[40] VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+   VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+   VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+   VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+   VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34]
+   VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[80] WLRD[81]
+   WLRD[82] WLRD[83] WLWR[80] WLWR[81] WLWR[82] WLWR[83] WL_VSS
+   SNPS_RF_DP_UHD_512x80_ary_rt_b
X_ary_rt_a_F5 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[21] DMY_EDGE_LT[22] DMY_EDGE_RT[42] DMY_EDGE_RT[43]
+   DMY_EDGE_RT[44] DMY_EDGE_RT[45] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+   QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91]
+   QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101]
+   QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110]
+   QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119]
+   QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128]
+   QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137]
+   QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146]
+   QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155]
+   QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5]
+   RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+   RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+   RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+   RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+   RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+   RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+   RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+   RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+   RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0]
+   RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+   VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+   VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+   VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+   VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+   VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40]
+   VBP[41] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+   VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23]
+   VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31]
+   VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39]
+   VDDA[40] VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+   VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+   VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+   VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+   VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34]
+   VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[84] WLRD[85]
+   WLRD[86] WLRD[87] WLWR[84] WLWR[85] WLWR[86] WLWR[87] WL_VSS
+   SNPS_RF_DP_UHD_512x80_ary_rt_a
X_ary_rt_b_F4 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[22] DMY_EDGE_LT[23] DMY_EDGE_RT[44] DMY_EDGE_RT[45]
+   DMY_EDGE_RT[46] DMY_EDGE_RT[47] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+   QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91]
+   QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101]
+   QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110]
+   QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119]
+   QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128]
+   QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137]
+   QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146]
+   QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155]
+   QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5]
+   RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+   RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+   RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+   RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+   RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+   RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+   RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+   RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+   RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0]
+   RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+   VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+   VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+   VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+   VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+   VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40]
+   VBP[41] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+   VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23]
+   VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31]
+   VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39]
+   VDDA[40] VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+   VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+   VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+   VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+   VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34]
+   VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[88] WLRD[89]
+   WLRD[90] WLRD[91] WLWR[88] WLWR[89] WLWR[90] WLWR[91] WL_VSS
+   SNPS_RF_DP_UHD_512x80_ary_rt_b
X_ary_rt_a_F4 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[23] DMY_EDGE_LT[24] DMY_EDGE_RT[46] DMY_EDGE_RT[47]
+   DMY_EDGE_RT[48] DMY_EDGE_RT[49] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+   QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91]
+   QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101]
+   QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110]
+   QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119]
+   QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128]
+   QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137]
+   QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146]
+   QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155]
+   QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5]
+   RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+   RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+   RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+   RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+   RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+   RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+   RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+   RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+   RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0]
+   RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+   VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+   VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+   VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+   VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+   VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40]
+   VBP[41] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+   VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23]
+   VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31]
+   VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39]
+   VDDA[40] VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+   VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+   VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+   VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+   VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34]
+   VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[92] WLRD[93]
+   WLRD[94] WLRD[95] WLWR[92] WLWR[93] WLWR[94] WLWR[95] WL_VSS
+   SNPS_RF_DP_UHD_512x80_ary_rt_a
X_ary_rt_b_F3 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[24] DMY_EDGE_LT[25] DMY_EDGE_RT[48] DMY_EDGE_RT[49]
+   DMY_EDGE_RT[50] DMY_EDGE_RT[51] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+   QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91]
+   QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101]
+   QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110]
+   QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119]
+   QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128]
+   QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137]
+   QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146]
+   QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155]
+   QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5]
+   RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+   RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+   RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+   RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+   RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+   RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+   RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+   RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+   RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0]
+   RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+   VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+   VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+   VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+   VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+   VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40]
+   VBP[41] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+   VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23]
+   VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31]
+   VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39]
+   VDDA[40] VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+   VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+   VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+   VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+   VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34]
+   VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[96] WLRD[97]
+   WLRD[98] WLRD[99] WLWR[96] WLWR[97] WLWR[98] WLWR[99] WL_VSS
+   SNPS_RF_DP_UHD_512x80_ary_rt_b
X_ary_rt_a_F3 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[25] DMY_EDGE_LT[26] DMY_EDGE_RT[50] DMY_EDGE_RT[51]
+   DMY_EDGE_RT[52] DMY_EDGE_RT[53] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+   QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91]
+   QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101]
+   QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110]
+   QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119]
+   QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128]
+   QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137]
+   QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146]
+   QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155]
+   QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5]
+   RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+   RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+   RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+   RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+   RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+   RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+   RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+   RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+   RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0]
+   RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+   VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+   VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+   VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+   VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+   VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40]
+   VBP[41] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+   VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23]
+   VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31]
+   VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39]
+   VDDA[40] VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+   VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+   VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+   VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+   VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34]
+   VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[100] WLRD[101]
+   WLRD[102] WLRD[103] WLWR[100] WLWR[101] WLWR[102] WLWR[103] WL_VSS
+   SNPS_RF_DP_UHD_512x80_ary_rt_a
X_ary_rt_b_F2 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[26] DMY_EDGE_LT[27] DMY_EDGE_RT[52] DMY_EDGE_RT[53]
+   DMY_EDGE_RT[54] DMY_EDGE_RT[55] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+   QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91]
+   QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101]
+   QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110]
+   QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119]
+   QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128]
+   QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137]
+   QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146]
+   QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155]
+   QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5]
+   RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+   RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+   RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+   RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+   RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+   RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+   RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+   RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+   RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0]
+   RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+   VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+   VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+   VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+   VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+   VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40]
+   VBP[41] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+   VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23]
+   VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31]
+   VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39]
+   VDDA[40] VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+   VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+   VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+   VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+   VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34]
+   VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[104] WLRD[105]
+   WLRD[106] WLRD[107] WLWR[104] WLWR[105] WLWR[106] WLWR[107] WL_VSS
+   SNPS_RF_DP_UHD_512x80_ary_rt_b
X_ary_rt_a_F2 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[27] DMY_EDGE_LT[28] DMY_EDGE_RT[54] DMY_EDGE_RT[55]
+   DMY_EDGE_RT[56] DMY_EDGE_RT[57] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+   QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91]
+   QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101]
+   QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110]
+   QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119]
+   QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128]
+   QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137]
+   QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146]
+   QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155]
+   QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5]
+   RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+   RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+   RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+   RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+   RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+   RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+   RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+   RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+   RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0]
+   RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+   VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+   VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+   VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+   VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+   VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40]
+   VBP[41] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+   VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23]
+   VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31]
+   VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39]
+   VDDA[40] VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+   VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+   VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+   VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+   VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34]
+   VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[108] WLRD[109]
+   WLRD[110] WLRD[111] WLWR[108] WLWR[109] WLWR[110] WLWR[111] WL_VSS
+   SNPS_RF_DP_UHD_512x80_ary_rt_a
X_ary_rt_b_F1 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[28] DMY_EDGE_LT[29] DMY_EDGE_RT[56] DMY_EDGE_RT[57]
+   DMY_EDGE_RT[58] DMY_EDGE_RT[59] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+   QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91]
+   QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101]
+   QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110]
+   QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119]
+   QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128]
+   QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137]
+   QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146]
+   QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155]
+   QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5]
+   RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+   RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+   RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+   RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+   RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+   RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+   RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+   RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+   RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0]
+   RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+   VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+   VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+   VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+   VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+   VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40]
+   VBP[41] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+   VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23]
+   VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31]
+   VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39]
+   VDDA[40] VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+   VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+   VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+   VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+   VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34]
+   VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[112] WLRD[113]
+   WLRD[114] WLRD[115] WLWR[112] WLWR[113] WLWR[114] WLWR[115] WL_VSS
+   SNPS_RF_DP_UHD_512x80_ary_rt_b
X_ary_rt_a_F1 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[29] DMY_EDGE_LT[30] DMY_EDGE_RT[58] DMY_EDGE_RT[59]
+   DMY_EDGE_RT[60] DMY_EDGE_RT[61] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+   QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91]
+   QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101]
+   QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110]
+   QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119]
+   QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128]
+   QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137]
+   QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146]
+   QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155]
+   QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5]
+   RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+   RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+   RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+   RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+   RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+   RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+   RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+   RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+   RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0]
+   RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+   VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+   VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+   VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+   VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+   VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40]
+   VBP[41] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+   VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23]
+   VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31]
+   VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39]
+   VDDA[40] VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+   VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+   VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+   VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+   VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34]
+   VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[116] WLRD[117]
+   WLRD[118] WLRD[119] WLWR[116] WLWR[117] WLWR[118] WLWR[119] WL_VSS
+   SNPS_RF_DP_UHD_512x80_ary_rt_a
X_ary_rt_b_F0 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[30] DMY_EDGE_LT[31] DMY_EDGE_RT[60] DMY_EDGE_RT[61]
+   DMY_EDGE_RT[62] DMY_EDGE_RT[63] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+   QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91]
+   QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101]
+   QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110]
+   QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119]
+   QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128]
+   QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137]
+   QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146]
+   QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155]
+   QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5]
+   RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+   RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+   RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+   RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+   RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+   RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+   RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+   RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+   RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0]
+   RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+   VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+   VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+   VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+   VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+   VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40]
+   VBP[41] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+   VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23]
+   VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31]
+   VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39]
+   VDDA[40] VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+   VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+   VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+   VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+   VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34]
+   VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[120] WLRD[121]
+   WLRD[122] WLRD[123] WLWR[120] WLWR[121] WLWR[122] WLWR[123] WL_VSS
+   SNPS_RF_DP_UHD_512x80_ary_rt_b
X_ary_rt_a_F0 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[31] DMY_EDGE_LT[32] DMY_EDGE_RT[62] DMY_EDGE_RT[63]
+   DMY_EDGE_RT[64] DMY_EDGE_RT[65] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+   QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91]
+   QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101]
+   QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110]
+   QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119]
+   QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128]
+   QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137]
+   QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146]
+   QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155]
+   QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5]
+   RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+   RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+   RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+   RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+   RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+   RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+   RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+   RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+   RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0]
+   RERASSB[1] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+   VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26]
+   VBN[27] VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35]
+   VBN[36] VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+   VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22]
+   VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31]
+   VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40]
+   VBP[41] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15]
+   VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23]
+   VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31]
+   VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39]
+   VDDA[40] VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26]
+   VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34]
+   VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+   VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22]
+   VDDPI[23] VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29]
+   VDDPI[30] VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36]
+   VDDPI[37] VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25]
+   VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34]
+   VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD[124] WLRD[125]
+   WLRD[126] WLRD[127] WLWR[124] WLWR[125] WLWR[126] WLWR[127] WL_VSS
+   SNPS_RF_DP_UHD_512x80_ary_rt_a
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_right BAB[0] BAB[1] BAB[2] BAB[3] BAB[4]
+       BAB[5] BAB[6] BAB[7] BAB[8] BAB[9] BAB[10] BAB[11] BAB[12] BAB[13]
+       BAB[14] BAB[15] BAB[16] BAB[17] BAB[18] BAB[19] BAB[20] BAB[21] BAB[22]
+       BAB[23] BAB[24] BAB[25] BAB[26] BAB[27] BAB[28] BAB[29] BAB[30] BAB[31]
+       BAB[32] BAB[33] BAB[34] BAB[35] BAB[36] BAB[37] BAB[38] BAB[39] BAB[40]
+       BAB[41] BAB[42] BAB[43] BAB[44] BAB[45] BAB[46] BAB[47] BAB[48] BAB[49]
+       BAB[50] BAB[51] BAB[52] BAB[53] BAB[54] BAB[55] BAB[56] BAB[57] BAB[58]
+       BAB[59] BAB[60] BAB[61] BAB[62] BAB[63] BAB[64] BAB[65] BAB[66] BAB[67]
+       BAB[68] BAB[69] BAB[70] BAB[71] BAB[72] BAB[73] BAB[74] BAB[75] BAB[76]
+       BAB[77] BAB[78] BAB[79] BAB[80] BAB[81] BAB[82] BAB[83] BAB[84] BAB[85]
+       BAB[86] BAB[87] BAB[88] BAB[89] BAB[90] BAB[91] BAB[92] BAB[93] BAB[94]
+       BAB[95] BAB[96] BAB[97] BAB[98] BAB[99] BAB[100] BAB[101] BAB[102]
+       BAB[103] BAB[104] BAB[105] BAB[106] BAB[107] BAB[108] BAB[109] BAB[110]
+       BAB[111] BAB[112] BAB[113] BAB[114] BAB[115] BAB[116] BAB[117] BAB[118]
+       BAB[119] BAB[120] BAB[121] BAB[122] BAB[123] BAB[124] BAB[125] BAB[126]
+       BAB[127] BAB[128] BAB[129] BAB[130] BAB[131] BAB[132] BAB[133] BAB[134]
+       BAB[135] BAB[136] BAB[137] BAB[138] BAB[139] BAB[140] BAB[141] BAB[142]
+       BAB[143] BAB[144] BAB[145] BAB[146] BAB[147] BAB[148] BAB[149] BAB[150]
+       BAB[151] BAB[152] BAB[153] BAB[154] BAB[155] BAB[156] BAB[157] BAB[158]
+       BAB[159] BAT[0] BAT[1] BAT[2] BAT[3] BAT[4] BAT[5] BAT[6] BAT[7] BAT[8]
+       BAT[9] BAT[10] BAT[11] BAT[12] BAT[13] BAT[14] BAT[15] BAT[16] BAT[17]
+       BAT[18] BAT[19] BAT[20] BAT[21] BAT[22] BAT[23] BAT[24] BAT[25] BAT[26]
+       BAT[27] BAT[28] BAT[29] BAT[30] BAT[31] BAT[32] BAT[33] BAT[34] BAT[35]
+       BAT[36] BAT[37] BAT[38] BAT[39] BAT[40] BAT[41] BAT[42] BAT[43] BAT[44]
+       BAT[45] BAT[46] BAT[47] BAT[48] BAT[49] BAT[50] BAT[51] BAT[52] BAT[53]
+       BAT[54] BAT[55] BAT[56] BAT[57] BAT[58] BAT[59] BAT[60] BAT[61] BAT[62]
+       BAT[63] BAT[64] BAT[65] BAT[66] BAT[67] BAT[68] BAT[69] BAT[70] BAT[71]
+       BAT[72] BAT[73] BAT[74] BAT[75] BAT[76] BAT[77] BAT[78] BAT[79] BAT[80]
+       BAT[81] BAT[82] BAT[83] BAT[84] BAT[85] BAT[86] BAT[87] BAT[88] BAT[89]
+       BAT[90] BAT[91] BAT[92] BAT[93] BAT[94] BAT[95] BAT[96] BAT[97] BAT[98]
+       BAT[99] BAT[100] BAT[101] BAT[102] BAT[103] BAT[104] BAT[105] BAT[106]
+       BAT[107] BAT[108] BAT[109] BAT[110] BAT[111] BAT[112] BAT[113] BAT[114]
+       BAT[115] BAT[116] BAT[117] BAT[118] BAT[119] BAT[120] BAT[121] BAT[122]
+       BAT[123] BAT[124] BAT[125] BAT[126] BAT[127] BAT[128] BAT[129] BAT[130]
+       BAT[131] BAT[132] BAT[133] BAT[134] BAT[135] BAT[136] BAT[137] BAT[138]
+       BAT[139] BAT[140] BAT[141] BAT[142] BAT[143] BAT[144] BAT[145] BAT[146]
+       BAT[147] BAT[148] BAT[149] BAT[150] BAT[151] BAT[152] BAT[153] BAT[154]
+       BAT[155] BAT[156] BAT[157] BAT[158] BAT[159] DMY_EDGE_LT[0]
+       DMY_EDGE_LT[1] DMY_EDGE_RT[0] DMY_EDGE_RT[1] DMY_EDGE_RT[2]
+       DMY_EDGE_RT[3] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2] QT[3] QT[4] QT[5]
+       QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16]
+       QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26]
+       QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+       QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46]
+       QT[47] QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56]
+       QT[57] QT[58] QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66]
+       QT[67] QT[68] QT[69] QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76]
+       QT[77] QT[78] QT[79] QT[80] QT[81] QT[82] QT[83] QT[84] QT[85] QT[86]
+       QT[87] QT[88] QT[89] QT[90] QT[91] QT[92] QT[93] QT[94] QT[95] QT[96]
+       QT[97] QT[98] QT[99] QT[100] QT[101] QT[102] QT[103] QT[104] QT[105]
+       QT[106] QT[107] QT[108] QT[109] QT[110] QT[111] QT[112] QT[113] QT[114]
+       QT[115] QT[116] QT[117] QT[118] QT[119] QT[120] QT[121] QT[122] QT[123]
+       QT[124] QT[125] QT[126] QT[127] QT[128] QT[129] QT[130] QT[131] QT[132]
+       QT[133] QT[134] QT[135] QT[136] QT[137] QT[138] QT[139] QT[140] QT[141]
+       QT[142] QT[143] QT[144] QT[145] QT[146] QT[147] QT[148] QT[149] QT[150]
+       QT[151] QT[152] QT[153] QT[154] QT[155] QT[156] QT[157] QT[158] QT[159]
+       RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5] RBL[6] RBL[7] RBL[8] RBL[9]
+       RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15] RBL[16] RBL[17] RBL[18]
+       RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24] RBL[25] RBL[26] RBL[27]
+       RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33] RBL[34] RBL[35] RBL[36]
+       RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42] RBL[43] RBL[44] RBL[45]
+       RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51] RBL[52] RBL[53] RBL[54]
+       RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60] RBL[61] RBL[62] RBL[63]
+       RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69] RBL[70] RBL[71] RBL[72]
+       RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78] RBL[79] RBL[80] RBL[81]
+       RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87] RBL[88] RBL[89] RBL[90]
+       RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96] RBL[97] RBL[98] RBL[99]
+       RBL[100] RBL[101] RBL[102] RBL[103] RBL[104] RBL[105] RBL[106] RBL[107]
+       RBL[108] RBL[109] RBL[110] RBL[111] RBL[112] RBL[113] RBL[114] RBL[115]
+       RBL[116] RBL[117] RBL[118] RBL[119] RBL[120] RBL[121] RBL[122] RBL[123]
+       RBL[124] RBL[125] RBL[126] RBL[127] RBL[128] RBL[129] RBL[130] RBL[131]
+       RBL[132] RBL[133] RBL[134] RBL[135] RBL[136] RBL[137] RBL[138] RBL[139]
+       RBL[140] RBL[141] RBL[142] RBL[143] RBL[144] RBL[145] RBL[146] RBL[147]
+       RBL[148] RBL[149] RBL[150] RBL[151] RBL[152] RBL[153] RBL[154] RBL[155]
+       RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0] RERASSB[1] VBN[0] VBN[1]
+       VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11]
+       VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20]
+       VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28] VBN[29]
+       VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35] VBN[36] VBN[37] VBN[38]
+       VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+       VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15]
+       VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24]
+       VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32] VBP[33]
+       VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40] VBP[41] VDDA[0]
+       VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9]
+       VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17]
+       VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24] VDDA[25]
+       VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31] VDDA[32] VDDA[33]
+       VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39] VDDA[40] VDDA[41]
+       VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+       VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11]
+       VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19]
+       VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27]
+       VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34] VDDP[35]
+       VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0] VDDPI[1]
+       VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9]
+       VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16]
+       VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23]
+       VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30]
+       VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36] VDDPI[37]
+       VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF VDDWL_WR_REBUF
+       VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+       VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17]
+       VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26]
+       VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34] VSS[35]
+       VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD_H[0] WLRD_H[1]
+       WLRD_H[2] WLRD_H[3] WLRD_H[4] WLRD_H[5] WLRD_H[6] WLRD_H[7] WLRD_H[8]
+       WLRD_H[9] WLRD_H[10] WLRD_H[11] WLRD_H[12] WLRD_H[13] WLRD_H[14]
+       WLRD_H[15] WLRD_H[16] WLRD_H[17] WLRD_H[18] WLRD_H[19] WLRD_H[20]
+       WLRD_H[21] WLRD_H[22] WLRD_H[23] WLRD_H[24] WLRD_H[25] WLRD_H[26]
+       WLRD_H[27] WLRD_H[28] WLRD_H[29] WLRD_H[30] WLRD_H[31] WLRD_H[32]
+       WLRD_H[33] WLRD_H[34] WLRD_H[35] WLRD_H[36] WLRD_H[37] WLRD_H[38]
+       WLRD_H[39] WLRD_H[40] WLRD_H[41] WLRD_H[42] WLRD_H[43] WLRD_H[44]
+       WLRD_H[45] WLRD_H[46] WLRD_H[47] WLRD_H[48] WLRD_H[49] WLRD_H[50]
+       WLRD_H[51] WLRD_H[52] WLRD_H[53] WLRD_H[54] WLRD_H[55] WLRD_H[56]
+       WLRD_H[57] WLRD_H[58] WLRD_H[59] WLRD_H[60] WLRD_H[61] WLRD_H[62]
+       WLRD_H[63] WLRD_H[64] WLRD_H[65] WLRD_H[66] WLRD_H[67] WLRD_H[68]
+       WLRD_H[69] WLRD_H[70] WLRD_H[71] WLRD_H[72] WLRD_H[73] WLRD_H[74]
+       WLRD_H[75] WLRD_H[76] WLRD_H[77] WLRD_H[78] WLRD_H[79] WLRD_H[80]
+       WLRD_H[81] WLRD_H[82] WLRD_H[83] WLRD_H[84] WLRD_H[85] WLRD_H[86]
+       WLRD_H[87] WLRD_H[88] WLRD_H[89] WLRD_H[90] WLRD_H[91] WLRD_H[92]
+       WLRD_H[93] WLRD_H[94] WLRD_H[95] WLRD_H[96] WLRD_H[97] WLRD_H[98]
+       WLRD_H[99] WLRD_H[100] WLRD_H[101] WLRD_H[102] WLRD_H[103] WLRD_H[104]
+       WLRD_H[105] WLRD_H[106] WLRD_H[107] WLRD_H[108] WLRD_H[109] WLRD_H[110]
+       WLRD_H[111] WLRD_H[112] WLRD_H[113] WLRD_H[114] WLRD_H[115] WLRD_H[116]
+       WLRD_H[117] WLRD_H[118] WLRD_H[119] WLRD_H[120] WLRD_H[121] WLRD_H[122]
+       WLRD_H[123] WLRD_H[124] WLRD_H[125] WLRD_H[126] WLRD_H[127] WLWR_H[0]
+       WLWR_H[1] WLWR_H[2] WLWR_H[3] WLWR_H[4] WLWR_H[5] WLWR_H[6] WLWR_H[7]
+       WLWR_H[8] WLWR_H[9] WLWR_H[10] WLWR_H[11] WLWR_H[12] WLWR_H[13]
+       WLWR_H[14] WLWR_H[15] WLWR_H[16] WLWR_H[17] WLWR_H[18] WLWR_H[19]
+       WLWR_H[20] WLWR_H[21] WLWR_H[22] WLWR_H[23] WLWR_H[24] WLWR_H[25]
+       WLWR_H[26] WLWR_H[27] WLWR_H[28] WLWR_H[29] WLWR_H[30] WLWR_H[31]
+       WLWR_H[32] WLWR_H[33] WLWR_H[34] WLWR_H[35] WLWR_H[36] WLWR_H[37]
+       WLWR_H[38] WLWR_H[39] WLWR_H[40] WLWR_H[41] WLWR_H[42] WLWR_H[43]
+       WLWR_H[44] WLWR_H[45] WLWR_H[46] WLWR_H[47] WLWR_H[48] WLWR_H[49]
+       WLWR_H[50] WLWR_H[51] WLWR_H[52] WLWR_H[53] WLWR_H[54] WLWR_H[55]
+       WLWR_H[56] WLWR_H[57] WLWR_H[58] WLWR_H[59] WLWR_H[60] WLWR_H[61]
+       WLWR_H[62] WLWR_H[63] WLWR_H[64] WLWR_H[65] WLWR_H[66] WLWR_H[67]
+       WLWR_H[68] WLWR_H[69] WLWR_H[70] WLWR_H[71] WLWR_H[72] WLWR_H[73]
+       WLWR_H[74] WLWR_H[75] WLWR_H[76] WLWR_H[77] WLWR_H[78] WLWR_H[79]
+       WLWR_H[80] WLWR_H[81] WLWR_H[82] WLWR_H[83] WLWR_H[84] WLWR_H[85]
+       WLWR_H[86] WLWR_H[87] WLWR_H[88] WLWR_H[89] WLWR_H[90] WLWR_H[91]
+       WLWR_H[92] WLWR_H[93] WLWR_H[94] WLWR_H[95] WLWR_H[96] WLWR_H[97]
+       WLWR_H[98] WLWR_H[99] WLWR_H[100] WLWR_H[101] WLWR_H[102] WLWR_H[103]
+       WLWR_H[104] WLWR_H[105] WLWR_H[106] WLWR_H[107] WLWR_H[108] WLWR_H[109]
+       WLWR_H[110] WLWR_H[111] WLWR_H[112] WLWR_H[113] WLWR_H[114] WLWR_H[115]
+       WLWR_H[116] WLWR_H[117] WLWR_H[118] WLWR_H[119] WLWR_H[120] WLWR_H[121]
+       WLWR_H[122] WLWR_H[123] WLWR_H[124] WLWR_H[125] WLWR_H[126] WLWR_H[127]
+       WL_VSS
X_ary_rt_no_cut BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[0] DMY_EDGE_LT[1] DMY_EDGE_RT[0] DMY_EDGE_RT[1] DMY_EDGE_RT[2]
+   DMY_EDGE_RT[3] LCGTV LOG0 LOG1 PGIOI QT[0] QT[1] QT[2] QT[3] QT[4] QT[5]
+   QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16]
+   QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27]
+   QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38]
+   QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49]
+   QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60]
+   QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70] QT[71]
+   QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80] QT[81] QT[82]
+   QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91] QT[92] QT[93]
+   QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101] QT[102] QT[103]
+   QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110] QT[111] QT[112]
+   QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119] QT[120] QT[121]
+   QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128] QT[129] QT[130]
+   QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137] QT[138] QT[139]
+   QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146] QT[147] QT[148]
+   QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155] QT[156] QT[157]
+   QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5] RBL[6] RBL[7]
+   RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15] RBL[16]
+   RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24] RBL[25]
+   RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33] RBL[34]
+   RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42] RBL[43]
+   RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51] RBL[52]
+   RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60] RBL[61]
+   RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69] RBL[70]
+   RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78] RBL[79]
+   RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87] RBL[88]
+   RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96] RBL[97]
+   RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104] RBL[105]
+   RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112] RBL[113]
+   RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120] RBL[121]
+   RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128] RBL[129]
+   RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136] RBL[137]
+   RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144] RBL[145]
+   RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152] RBL[153]
+   RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0] RERASSB[1]
+   VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+   VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18]
+   VBN[19] VBN[20] VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27]
+   VBN[28] VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35] VBN[36]
+   VBN[37] VBN[38] VBN[39] VBN[40] VBN[41] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4]
+   VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14]
+   VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23]
+   VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32]
+   VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40] VBP[41]
+   VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8]
+   VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16]
+   VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24]
+   VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31] VDDA[32]
+   VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39] VDDA[40]
+   VDDA[41] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[0] VDDP[1] VDDP[2]
+   VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11]
+   VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19]
+   VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27]
+   VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34] VDDP[35]
+   VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDPI[0] VDDPI[1]
+   VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9]
+   VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16]
+   VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23]
+   VDDPI[24] VDDPI[25] VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30]
+   VDDPI[31] VDDPI[32] VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36] VDDPI[37]
+   VDDPI[38] VDDPI[39] VDDPI[40] VDDPI[41] VDDWL_RD_REBUF VDDWL_WR_REBUF VEDGE
+   VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9]
+   VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18]
+   VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27]
+   VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34] VSS[35] VSS[36]
+   VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] WLRD_H[0] WLRD_H[1] WLRD_H[2]
+   WLRD_H[3] WLRD_H[4] WLRD_H[5] WLRD_H[6] WLRD_H[7] WLRD_H[8] WLRD_H[9]
+   WLRD_H[10] WLRD_H[11] WLRD_H[12] WLRD_H[13] WLRD_H[14] WLRD_H[15] WLRD_H[16]
+   WLRD_H[17] WLRD_H[18] WLRD_H[19] WLRD_H[20] WLRD_H[21] WLRD_H[22] WLRD_H[23]
+   WLRD_H[24] WLRD_H[25] WLRD_H[26] WLRD_H[27] WLRD_H[28] WLRD_H[29] WLRD_H[30]
+   WLRD_H[31] WLRD_H[32] WLRD_H[33] WLRD_H[34] WLRD_H[35] WLRD_H[36] WLRD_H[37]
+   WLRD_H[38] WLRD_H[39] WLRD_H[40] WLRD_H[41] WLRD_H[42] WLRD_H[43] WLRD_H[44]
+   WLRD_H[45] WLRD_H[46] WLRD_H[47] WLRD_H[48] WLRD_H[49] WLRD_H[50] WLRD_H[51]
+   WLRD_H[52] WLRD_H[53] WLRD_H[54] WLRD_H[55] WLRD_H[56] WLRD_H[57] WLRD_H[58]
+   WLRD_H[59] WLRD_H[60] WLRD_H[61] WLRD_H[62] WLRD_H[63] WLRD_H[64] WLRD_H[65]
+   WLRD_H[66] WLRD_H[67] WLRD_H[68] WLRD_H[69] WLRD_H[70] WLRD_H[71] WLRD_H[72]
+   WLRD_H[73] WLRD_H[74] WLRD_H[75] WLRD_H[76] WLRD_H[77] WLRD_H[78] WLRD_H[79]
+   WLRD_H[80] WLRD_H[81] WLRD_H[82] WLRD_H[83] WLRD_H[84] WLRD_H[85] WLRD_H[86]
+   WLRD_H[87] WLRD_H[88] WLRD_H[89] WLRD_H[90] WLRD_H[91] WLRD_H[92] WLRD_H[93]
+   WLRD_H[94] WLRD_H[95] WLRD_H[96] WLRD_H[97] WLRD_H[98] WLRD_H[99]
+   WLRD_H[100] WLRD_H[101] WLRD_H[102] WLRD_H[103] WLRD_H[104] WLRD_H[105]
+   WLRD_H[106] WLRD_H[107] WLRD_H[108] WLRD_H[109] WLRD_H[110] WLRD_H[111]
+   WLRD_H[112] WLRD_H[113] WLRD_H[114] WLRD_H[115] WLRD_H[116] WLRD_H[117]
+   WLRD_H[118] WLRD_H[119] WLRD_H[120] WLRD_H[121] WLRD_H[122] WLRD_H[123]
+   WLRD_H[124] WLRD_H[125] WLRD_H[126] WLRD_H[127] WLWR_H[0] WLWR_H[1]
+   WLWR_H[2] WLWR_H[3] WLWR_H[4] WLWR_H[5] WLWR_H[6] WLWR_H[7] WLWR_H[8]
+   WLWR_H[9] WLWR_H[10] WLWR_H[11] WLWR_H[12] WLWR_H[13] WLWR_H[14] WLWR_H[15]
+   WLWR_H[16] WLWR_H[17] WLWR_H[18] WLWR_H[19] WLWR_H[20] WLWR_H[21] WLWR_H[22]
+   WLWR_H[23] WLWR_H[24] WLWR_H[25] WLWR_H[26] WLWR_H[27] WLWR_H[28] WLWR_H[29]
+   WLWR_H[30] WLWR_H[31] WLWR_H[32] WLWR_H[33] WLWR_H[34] WLWR_H[35] WLWR_H[36]
+   WLWR_H[37] WLWR_H[38] WLWR_H[39] WLWR_H[40] WLWR_H[41] WLWR_H[42] WLWR_H[43]
+   WLWR_H[44] WLWR_H[45] WLWR_H[46] WLWR_H[47] WLWR_H[48] WLWR_H[49] WLWR_H[50]
+   WLWR_H[51] WLWR_H[52] WLWR_H[53] WLWR_H[54] WLWR_H[55] WLWR_H[56] WLWR_H[57]
+   WLWR_H[58] WLWR_H[59] WLWR_H[60] WLWR_H[61] WLWR_H[62] WLWR_H[63] WLWR_H[64]
+   WLWR_H[65] WLWR_H[66] WLWR_H[67] WLWR_H[68] WLWR_H[69] WLWR_H[70] WLWR_H[71]
+   WLWR_H[72] WLWR_H[73] WLWR_H[74] WLWR_H[75] WLWR_H[76] WLWR_H[77] WLWR_H[78]
+   WLWR_H[79] WLWR_H[80] WLWR_H[81] WLWR_H[82] WLWR_H[83] WLWR_H[84] WLWR_H[85]
+   WLWR_H[86] WLWR_H[87] WLWR_H[88] WLWR_H[89] WLWR_H[90] WLWR_H[91] WLWR_H[92]
+   WLWR_H[93] WLWR_H[94] WLWR_H[95] WLWR_H[96] WLWR_H[97] WLWR_H[98] WLWR_H[99]
+   WLWR_H[100] WLWR_H[101] WLWR_H[102] WLWR_H[103] WLWR_H[104] WLWR_H[105]
+   WLWR_H[106] WLWR_H[107] WLWR_H[108] WLWR_H[109] WLWR_H[110] WLWR_H[111]
+   WLWR_H[112] WLWR_H[113] WLWR_H[114] WLWR_H[115] WLWR_H[116] WLWR_H[117]
+   WLWR_H[118] WLWR_H[119] WLWR_H[120] WLWR_H[121] WLWR_H[122] WLWR_H[123]
+   WLWR_H[124] WLWR_H[125] WLWR_H[126] WLWR_H[127] WL_VSS
+   SNPS_RF_DP_UHD_512x80_ary_rt_no_cut
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_r ARYSD BAB[0] BAB[1] BAB[2] BAB[3] BAB[4]
+       BAB[5] BAB[6] BAB[7] BAB[8] BAB[9] BAB[10] BAB[11] BAB[12] BAB[13]
+       BAB[14] BAB[15] BAB[16] BAB[17] BAB[18] BAB[19] BAB[20] BAB[21] BAB[22]
+       BAB[23] BAB[24] BAB[25] BAB[26] BAB[27] BAB[28] BAB[29] BAB[30] BAB[31]
+       BAB[32] BAB[33] BAB[34] BAB[35] BAB[36] BAB[37] BAB[38] BAB[39] BAB[40]
+       BAB[41] BAB[42] BAB[43] BAB[44] BAB[45] BAB[46] BAB[47] BAB[48] BAB[49]
+       BAB[50] BAB[51] BAB[52] BAB[53] BAB[54] BAB[55] BAB[56] BAB[57] BAB[58]
+       BAB[59] BAB[60] BAB[61] BAB[62] BAB[63] BAB[64] BAB[65] BAB[66] BAB[67]
+       BAB[68] BAB[69] BAB[70] BAB[71] BAB[72] BAB[73] BAB[74] BAB[75] BAB[76]
+       BAB[77] BAB[78] BAB[79] BAB[80] BAB[81] BAB[82] BAB[83] BAB[84] BAB[85]
+       BAB[86] BAB[87] BAB[88] BAB[89] BAB[90] BAB[91] BAB[92] BAB[93] BAB[94]
+       BAB[95] BAB[96] BAB[97] BAB[98] BAB[99] BAB[100] BAB[101] BAB[102]
+       BAB[103] BAB[104] BAB[105] BAB[106] BAB[107] BAB[108] BAB[109] BAB[110]
+       BAB[111] BAB[112] BAB[113] BAB[114] BAB[115] BAB[116] BAB[117] BAB[118]
+       BAB[119] BAB[120] BAB[121] BAB[122] BAB[123] BAB[124] BAB[125] BAB[126]
+       BAB[127] BAB[128] BAB[129] BAB[130] BAB[131] BAB[132] BAB[133] BAB[134]
+       BAB[135] BAB[136] BAB[137] BAB[138] BAB[139] BAB[140] BAB[141] BAB[142]
+       BAB[143] BAB[144] BAB[145] BAB[146] BAB[147] BAB[148] BAB[149] BAB[150]
+       BAB[151] BAB[152] BAB[153] BAB[154] BAB[155] BAB[156] BAB[157] BAB[158]
+       BAB[159] BAT[0] BAT[1] BAT[2] BAT[3] BAT[4] BAT[5] BAT[6] BAT[7] BAT[8]
+       BAT[9] BAT[10] BAT[11] BAT[12] BAT[13] BAT[14] BAT[15] BAT[16] BAT[17]
+       BAT[18] BAT[19] BAT[20] BAT[21] BAT[22] BAT[23] BAT[24] BAT[25] BAT[26]
+       BAT[27] BAT[28] BAT[29] BAT[30] BAT[31] BAT[32] BAT[33] BAT[34] BAT[35]
+       BAT[36] BAT[37] BAT[38] BAT[39] BAT[40] BAT[41] BAT[42] BAT[43] BAT[44]
+       BAT[45] BAT[46] BAT[47] BAT[48] BAT[49] BAT[50] BAT[51] BAT[52] BAT[53]
+       BAT[54] BAT[55] BAT[56] BAT[57] BAT[58] BAT[59] BAT[60] BAT[61] BAT[62]
+       BAT[63] BAT[64] BAT[65] BAT[66] BAT[67] BAT[68] BAT[69] BAT[70] BAT[71]
+       BAT[72] BAT[73] BAT[74] BAT[75] BAT[76] BAT[77] BAT[78] BAT[79] BAT[80]
+       BAT[81] BAT[82] BAT[83] BAT[84] BAT[85] BAT[86] BAT[87] BAT[88] BAT[89]
+       BAT[90] BAT[91] BAT[92] BAT[93] BAT[94] BAT[95] BAT[96] BAT[97] BAT[98]
+       BAT[99] BAT[100] BAT[101] BAT[102] BAT[103] BAT[104] BAT[105] BAT[106]
+       BAT[107] BAT[108] BAT[109] BAT[110] BAT[111] BAT[112] BAT[113] BAT[114]
+       BAT[115] BAT[116] BAT[117] BAT[118] BAT[119] BAT[120] BAT[121] BAT[122]
+       BAT[123] BAT[124] BAT[125] BAT[126] BAT[127] BAT[128] BAT[129] BAT[130]
+       BAT[131] BAT[132] BAT[133] BAT[134] BAT[135] BAT[136] BAT[137] BAT[138]
+       BAT[139] BAT[140] BAT[141] BAT[142] BAT[143] BAT[144] BAT[145] BAT[146]
+       BAT[147] BAT[148] BAT[149] BAT[150] BAT[151] BAT[152] BAT[153] BAT[154]
+       BAT[155] BAT[156] BAT[157] BAT[158] BAT[159] BKRDB BKRDB_128 CENDP
+       DEF1_RD DEF1_WR DMY_EDGE_LT[0] DMY_EDGE_LT[1] DMY_EDGE_LT[2]
+       DMY_EDGE_LT[3] DMY_EDGE_RT[0] DMY_EDGE_RT[1] DMY_EDGE_RT[2]
+       DMY_EDGE_RT[3] FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LCGTV[0]
+       LCGTV[1] LOG0[0] LOG0[1] LOG1[0] LOG1[1] LRWMEB LXADRB[0] LXADRB[1]
+       LXADRB[2] PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2]
+       PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2]
+       PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3] PGIOI QT[0] QT[1] QT[2]
+       QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13]
+       QT[14] QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23]
+       QT[24] QT[25] QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33]
+       QT[34] QT[35] QT[36] QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43]
+       QT[44] QT[45] QT[46] QT[47] QT[48] QT[49] QT[50] QT[51] QT[52] QT[53]
+       QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60] QT[61] QT[62] QT[63]
+       QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70] QT[71] QT[72] QT[73]
+       QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80] QT[81] QT[82] QT[83]
+       QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91] QT[92] QT[93]
+       QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101] QT[102]
+       QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110] QT[111]
+       QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119] QT[120]
+       QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128] QT[129]
+       QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137] QT[138]
+       QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146] QT[147]
+       QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155] QT[156]
+       QT[157] QT[158] QT[159] RASSB_H[0] RASSB_H[1] RBL[0] RBL[1] RBL[2]
+       RBL[3] RBL[4] RBL[5] RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12]
+       RBL[13] RBL[14] RBL[15] RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21]
+       RBL[22] RBL[23] RBL[24] RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30]
+       RBL[31] RBL[32] RBL[33] RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39]
+       RBL[40] RBL[41] RBL[42] RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48]
+       RBL[49] RBL[50] RBL[51] RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57]
+       RBL[58] RBL[59] RBL[60] RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66]
+       RBL[67] RBL[68] RBL[69] RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75]
+       RBL[76] RBL[77] RBL[78] RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84]
+       RBL[85] RBL[86] RBL[87] RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93]
+       RBL[94] RBL[95] RBL[96] RBL[97] RBL[98] RBL[99] RBL[100] RBL[101]
+       RBL[102] RBL[103] RBL[104] RBL[105] RBL[106] RBL[107] RBL[108] RBL[109]
+       RBL[110] RBL[111] RBL[112] RBL[113] RBL[114] RBL[115] RBL[116] RBL[117]
+       RBL[118] RBL[119] RBL[120] RBL[121] RBL[122] RBL[123] RBL[124] RBL[125]
+       RBL[126] RBL[127] RBL[128] RBL[129] RBL[130] RBL[131] RBL[132] RBL[133]
+       RBL[134] RBL[135] RBL[136] RBL[137] RBL[138] RBL[139] RBL[140] RBL[141]
+       RBL[142] RBL[143] RBL[144] RBL[145] RBL[146] RBL[147] RBL[148] RBL[149]
+       RBL[150] RBL[151] RBL[152] RBL[153] RBL[154] RBL[155] RBL[156] RBL[157]
+       RBL[158] RBL[159] RBLWA RDBL RERASSB[0] RERASSB[1] RFLOAT RFLT_RET
+       RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2]
+       RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB VBN[0] VBN[1] VBN[2] VBN[3]
+       VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12]
+       VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20] VBN[21]
+       VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28] VBN[29] VBN[30]
+       VBN[31] VBN[32] VBN[33] VBN[34] VBN[35] VBN[36] VBN[37] VBN[38] VBN[39]
+       VBN[40] VBN[41] VBN[42] VBN[43] VBN[44] VBP[0] VBP[1] VBP[2] VBP[3]
+       VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+       VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21]
+       VBP[22] VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30]
+       VBP[31] VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39]
+       VBP[40] VBP[41] VBP[42] VBP[43] VBP[44] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+       VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11]
+       VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19]
+       VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27]
+       VDDA[28] VDDA[29] VDDA[30] VDDA[31] VDDA[32] VDDA[33] VDDA[34] VDDA[35]
+       VDDA[36] VDDA[37] VDDA[38] VDDA[39] VDDA[40] VDDA[41] VDDA[42] VDDA[43]
+       VDDA[44] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDAPI VDDF VDDP[0]
+       VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9]
+       VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17]
+       VDDP[18] VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25]
+       VDDP[26] VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33]
+       VDDP[34] VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41]
+       VDDP[42] VDDP[43] VDDP[44] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+       VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+       VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18]
+       VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25]
+       VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31] VDDPI[32]
+       VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36] VDDPI[37] VDDPI[38] VDDPI[39]
+       VDDPI[40] VDDPI[41] VDDPI[42] VDDPI[43] VDDPI[44] VDDWL_RD
+       VDDWL_RD_REBUF VDDWL_WR VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3]
+       VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+       VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21]
+       VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27] VSS[28] VSS[29] VSS[30]
+       VSS[31] VSS[32] VSS[33] VSS[34] VSS[35] VSS[36] VSS[37] VSS[38] VSS[39]
+       VSS[40] VSS[41] VSS[42] VSS[43] VSS[44] VSSWL WCLKRD[0] WCLKRD[1]
+       WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT
+       WL_VSS XAWRB XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2]
+       YSELRD[3]
X_ary_cnt ARYSD BKRDB BKRDB_128 CENDP DEF1_RD DEF1_WR DMY_EDGE_LT[0]
+   DMY_EDGE_LT[1] FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LCGTV[0] LOG0[0]
+   LOG1[0] LRWMEB LXADRB[0] LXADRB[1] LXADRB[2] PAWRB[0] PAWRB[1] PAWRB[2]
+   PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2]
+   PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2]
+   PCWRB[3] RASSB_H[0] RASSB_H[1] RBLWA RDBL RFLOAT RFLT_RET RM3CNT RMTRD[0]
+   RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD
+   RWLB_WR T1TRD T1TWR TKEEPB VBN[0] VBN[1] VBN[2] VBP[0] VBP[1] VBP[2] VDDA[0]
+   VDDA[1] VDDA[2] VDDAPI VDDF VDDP[0] VDDP[1] VDDP[2] VDDPI[0] VDDPI[1]
+   VDDPI[2] VDDWL_RD VDDWL_WR VSS[0] VSS[1] VSS[2] VSSWL WCLKRD[0] WCLKRD[1]
+   WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT
+   WLRD_H[0] WLRD_H[1] WLRD_H[2] WLRD_H[3] WLRD_H[4] WLRD_H[5] WLRD_H[6]
+   WLRD_H[7] WLRD_H[8] WLRD_H[9] WLRD_H[10] WLRD_H[11] WLRD_H[12] WLRD_H[13]
+   WLRD_H[14] WLRD_H[15] WLRD_H[16] WLRD_H[17] WLRD_H[18] WLRD_H[19] WLRD_H[20]
+   WLRD_H[21] WLRD_H[22] WLRD_H[23] WLRD_H[24] WLRD_H[25] WLRD_H[26] WLRD_H[27]
+   WLRD_H[28] WLRD_H[29] WLRD_H[30] WLRD_H[31] WLRD_H[32] WLRD_H[33] WLRD_H[34]
+   WLRD_H[35] WLRD_H[36] WLRD_H[37] WLRD_H[38] WLRD_H[39] WLRD_H[40] WLRD_H[41]
+   WLRD_H[42] WLRD_H[43] WLRD_H[44] WLRD_H[45] WLRD_H[46] WLRD_H[47] WLRD_H[48]
+   WLRD_H[49] WLRD_H[50] WLRD_H[51] WLRD_H[52] WLRD_H[53] WLRD_H[54] WLRD_H[55]
+   WLRD_H[56] WLRD_H[57] WLRD_H[58] WLRD_H[59] WLRD_H[60] WLRD_H[61] WLRD_H[62]
+   WLRD_H[63] WLRD_H[64] WLRD_H[65] WLRD_H[66] WLRD_H[67] WLRD_H[68] WLRD_H[69]
+   WLRD_H[70] WLRD_H[71] WLRD_H[72] WLRD_H[73] WLRD_H[74] WLRD_H[75] WLRD_H[76]
+   WLRD_H[77] WLRD_H[78] WLRD_H[79] WLRD_H[80] WLRD_H[81] WLRD_H[82] WLRD_H[83]
+   WLRD_H[84] WLRD_H[85] WLRD_H[86] WLRD_H[87] WLRD_H[88] WLRD_H[89] WLRD_H[90]
+   WLRD_H[91] WLRD_H[92] WLRD_H[93] WLRD_H[94] WLRD_H[95] WLRD_H[96] WLRD_H[97]
+   WLRD_H[98] WLRD_H[99] WLRD_H[100] WLRD_H[101] WLRD_H[102] WLRD_H[103]
+   WLRD_H[104] WLRD_H[105] WLRD_H[106] WLRD_H[107] WLRD_H[108] WLRD_H[109]
+   WLRD_H[110] WLRD_H[111] WLRD_H[112] WLRD_H[113] WLRD_H[114] WLRD_H[115]
+   WLRD_H[116] WLRD_H[117] WLRD_H[118] WLRD_H[119] WLRD_H[120] WLRD_H[121]
+   WLRD_H[122] WLRD_H[123] WLRD_H[124] WLRD_H[125] WLRD_H[126] WLRD_H[127]
+   WLWR_H[0] WLWR_H[1] WLWR_H[2] WLWR_H[3] WLWR_H[4] WLWR_H[5] WLWR_H[6]
+   WLWR_H[7] WLWR_H[8] WLWR_H[9] WLWR_H[10] WLWR_H[11] WLWR_H[12] WLWR_H[13]
+   WLWR_H[14] WLWR_H[15] WLWR_H[16] WLWR_H[17] WLWR_H[18] WLWR_H[19] WLWR_H[20]
+   WLWR_H[21] WLWR_H[22] WLWR_H[23] WLWR_H[24] WLWR_H[25] WLWR_H[26] WLWR_H[27]
+   WLWR_H[28] WLWR_H[29] WLWR_H[30] WLWR_H[31] WLWR_H[32] WLWR_H[33] WLWR_H[34]
+   WLWR_H[35] WLWR_H[36] WLWR_H[37] WLWR_H[38] WLWR_H[39] WLWR_H[40] WLWR_H[41]
+   WLWR_H[42] WLWR_H[43] WLWR_H[44] WLWR_H[45] WLWR_H[46] WLWR_H[47] WLWR_H[48]
+   WLWR_H[49] WLWR_H[50] WLWR_H[51] WLWR_H[52] WLWR_H[53] WLWR_H[54] WLWR_H[55]
+   WLWR_H[56] WLWR_H[57] WLWR_H[58] WLWR_H[59] WLWR_H[60] WLWR_H[61] WLWR_H[62]
+   WLWR_H[63] WLWR_H[64] WLWR_H[65] WLWR_H[66] WLWR_H[67] WLWR_H[68] WLWR_H[69]
+   WLWR_H[70] WLWR_H[71] WLWR_H[72] WLWR_H[73] WLWR_H[74] WLWR_H[75] WLWR_H[76]
+   WLWR_H[77] WLWR_H[78] WLWR_H[79] WLWR_H[80] WLWR_H[81] WLWR_H[82] WLWR_H[83]
+   WLWR_H[84] WLWR_H[85] WLWR_H[86] WLWR_H[87] WLWR_H[88] WLWR_H[89] WLWR_H[90]
+   WLWR_H[91] WLWR_H[92] WLWR_H[93] WLWR_H[94] WLWR_H[95] WLWR_H[96] WLWR_H[97]
+   WLWR_H[98] WLWR_H[99] WLWR_H[100] WLWR_H[101] WLWR_H[102] WLWR_H[103]
+   WLWR_H[104] WLWR_H[105] WLWR_H[106] WLWR_H[107] WLWR_H[108] WLWR_H[109]
+   WLWR_H[110] WLWR_H[111] WLWR_H[112] WLWR_H[113] WLWR_H[114] WLWR_H[115]
+   WLWR_H[116] WLWR_H[117] WLWR_H[118] WLWR_H[119] WLWR_H[120] WLWR_H[121]
+   WLWR_H[122] WLWR_H[123] WLWR_H[124] WLWR_H[125] WLWR_H[126] WLWR_H[127]
+   XAWRB XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]
+   SNPS_RF_DP_UHD_512x80_ary_cnt
X_ary_right BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   DMY_EDGE_LT[2] DMY_EDGE_LT[3] DMY_EDGE_RT[0] DMY_EDGE_RT[1] DMY_EDGE_RT[2]
+   DMY_EDGE_RT[3] LCGTV[1] LOG0[1] LOG1[1] PGIOI QT[0] QT[1] QT[2] QT[3] QT[4]
+   QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15]
+   QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26]
+   QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37]
+   QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48]
+   QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59]
+   QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70]
+   QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80] QT[81]
+   QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91] QT[92]
+   QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101] QT[102]
+   QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110] QT[111]
+   QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119] QT[120]
+   QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128] QT[129]
+   QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137] QT[138]
+   QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146] QT[147]
+   QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155] QT[156]
+   QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5] RBL[6]
+   RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15] RBL[16]
+   RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24] RBL[25]
+   RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33] RBL[34]
+   RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42] RBL[43]
+   RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51] RBL[52]
+   RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60] RBL[61]
+   RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69] RBL[70]
+   RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78] RBL[79]
+   RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87] RBL[88]
+   RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96] RBL[97]
+   RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104] RBL[105]
+   RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112] RBL[113]
+   RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120] RBL[121]
+   RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128] RBL[129]
+   RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136] RBL[137]
+   RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144] RBL[145]
+   RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152] RBL[153]
+   RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RERASSB[0] RERASSB[1]
+   VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12]
+   VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20] VBN[21]
+   VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28] VBN[29] VBN[30]
+   VBN[31] VBN[32] VBN[33] VBN[34] VBN[35] VBN[36] VBN[37] VBN[38] VBN[39]
+   VBN[40] VBN[41] VBN[42] VBN[43] VBN[44] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7]
+   VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+   VBP[17] VBP[18] VBP[19] VBP[20] VBP[21] VBP[22] VBP[23] VBP[24] VBP[25]
+   VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32] VBP[33] VBP[34]
+   VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40] VBP[41] VBP[42] VBP[43]
+   VBP[44] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10]
+   VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17] VDDA[18]
+   VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24] VDDA[25] VDDA[26]
+   VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31] VDDA[32] VDDA[33] VDDA[34]
+   VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39] VDDA[40] VDDA[41] VDDA[42]
+   VDDA[43] VDDA[44] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+   VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDP[21]
+   VDDP[22] VDDP[23] VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDP[29]
+   VDDP[30] VDDP[31] VDDP[32] VDDP[33] VDDP[34] VDDP[35] VDDP[36] VDDP[37]
+   VDDP[38] VDDP[39] VDDP[40] VDDP[41] VDDP[42] VDDP[43] VDDP[44] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18]
+   VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25]
+   VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31] VDDPI[32]
+   VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36] VDDPI[37] VDDPI[38] VDDPI[39]
+   VDDPI[40] VDDPI[41] VDDPI[42] VDDPI[43] VDDPI[44] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VEDGE VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9]
+   VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18]
+   VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24] VSS[25] VSS[26] VSS[27]
+   VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33] VSS[34] VSS[35] VSS[36]
+   VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] VSS[42] VSS[43] VSS[44] WLRD_H[0]
+   WLRD_H[1] WLRD_H[2] WLRD_H[3] WLRD_H[4] WLRD_H[5] WLRD_H[6] WLRD_H[7]
+   WLRD_H[8] WLRD_H[9] WLRD_H[10] WLRD_H[11] WLRD_H[12] WLRD_H[13] WLRD_H[14]
+   WLRD_H[15] WLRD_H[16] WLRD_H[17] WLRD_H[18] WLRD_H[19] WLRD_H[20] WLRD_H[21]
+   WLRD_H[22] WLRD_H[23] WLRD_H[24] WLRD_H[25] WLRD_H[26] WLRD_H[27] WLRD_H[28]
+   WLRD_H[29] WLRD_H[30] WLRD_H[31] WLRD_H[32] WLRD_H[33] WLRD_H[34] WLRD_H[35]
+   WLRD_H[36] WLRD_H[37] WLRD_H[38] WLRD_H[39] WLRD_H[40] WLRD_H[41] WLRD_H[42]
+   WLRD_H[43] WLRD_H[44] WLRD_H[45] WLRD_H[46] WLRD_H[47] WLRD_H[48] WLRD_H[49]
+   WLRD_H[50] WLRD_H[51] WLRD_H[52] WLRD_H[53] WLRD_H[54] WLRD_H[55] WLRD_H[56]
+   WLRD_H[57] WLRD_H[58] WLRD_H[59] WLRD_H[60] WLRD_H[61] WLRD_H[62] WLRD_H[63]
+   WLRD_H[64] WLRD_H[65] WLRD_H[66] WLRD_H[67] WLRD_H[68] WLRD_H[69] WLRD_H[70]
+   WLRD_H[71] WLRD_H[72] WLRD_H[73] WLRD_H[74] WLRD_H[75] WLRD_H[76] WLRD_H[77]
+   WLRD_H[78] WLRD_H[79] WLRD_H[80] WLRD_H[81] WLRD_H[82] WLRD_H[83] WLRD_H[84]
+   WLRD_H[85] WLRD_H[86] WLRD_H[87] WLRD_H[88] WLRD_H[89] WLRD_H[90] WLRD_H[91]
+   WLRD_H[92] WLRD_H[93] WLRD_H[94] WLRD_H[95] WLRD_H[96] WLRD_H[97] WLRD_H[98]
+   WLRD_H[99] WLRD_H[100] WLRD_H[101] WLRD_H[102] WLRD_H[103] WLRD_H[104]
+   WLRD_H[105] WLRD_H[106] WLRD_H[107] WLRD_H[108] WLRD_H[109] WLRD_H[110]
+   WLRD_H[111] WLRD_H[112] WLRD_H[113] WLRD_H[114] WLRD_H[115] WLRD_H[116]
+   WLRD_H[117] WLRD_H[118] WLRD_H[119] WLRD_H[120] WLRD_H[121] WLRD_H[122]
+   WLRD_H[123] WLRD_H[124] WLRD_H[125] WLRD_H[126] WLRD_H[127] WLWR_H[0]
+   WLWR_H[1] WLWR_H[2] WLWR_H[3] WLWR_H[4] WLWR_H[5] WLWR_H[6] WLWR_H[7]
+   WLWR_H[8] WLWR_H[9] WLWR_H[10] WLWR_H[11] WLWR_H[12] WLWR_H[13] WLWR_H[14]
+   WLWR_H[15] WLWR_H[16] WLWR_H[17] WLWR_H[18] WLWR_H[19] WLWR_H[20] WLWR_H[21]
+   WLWR_H[22] WLWR_H[23] WLWR_H[24] WLWR_H[25] WLWR_H[26] WLWR_H[27] WLWR_H[28]
+   WLWR_H[29] WLWR_H[30] WLWR_H[31] WLWR_H[32] WLWR_H[33] WLWR_H[34] WLWR_H[35]
+   WLWR_H[36] WLWR_H[37] WLWR_H[38] WLWR_H[39] WLWR_H[40] WLWR_H[41] WLWR_H[42]
+   WLWR_H[43] WLWR_H[44] WLWR_H[45] WLWR_H[46] WLWR_H[47] WLWR_H[48] WLWR_H[49]
+   WLWR_H[50] WLWR_H[51] WLWR_H[52] WLWR_H[53] WLWR_H[54] WLWR_H[55] WLWR_H[56]
+   WLWR_H[57] WLWR_H[58] WLWR_H[59] WLWR_H[60] WLWR_H[61] WLWR_H[62] WLWR_H[63]
+   WLWR_H[64] WLWR_H[65] WLWR_H[66] WLWR_H[67] WLWR_H[68] WLWR_H[69] WLWR_H[70]
+   WLWR_H[71] WLWR_H[72] WLWR_H[73] WLWR_H[74] WLWR_H[75] WLWR_H[76] WLWR_H[77]
+   WLWR_H[78] WLWR_H[79] WLWR_H[80] WLWR_H[81] WLWR_H[82] WLWR_H[83] WLWR_H[84]
+   WLWR_H[85] WLWR_H[86] WLWR_H[87] WLWR_H[88] WLWR_H[89] WLWR_H[90] WLWR_H[91]
+   WLWR_H[92] WLWR_H[93] WLWR_H[94] WLWR_H[95] WLWR_H[96] WLWR_H[97] WLWR_H[98]
+   WLWR_H[99] WLWR_H[100] WLWR_H[101] WLWR_H[102] WLWR_H[103] WLWR_H[104]
+   WLWR_H[105] WLWR_H[106] WLWR_H[107] WLWR_H[108] WLWR_H[109] WLWR_H[110]
+   WLWR_H[111] WLWR_H[112] WLWR_H[113] WLWR_H[114] WLWR_H[115] WLWR_H[116]
+   WLWR_H[117] WLWR_H[118] WLWR_H[119] WLWR_H[120] WLWR_H[121] WLWR_H[122]
+   WLWR_H[123] WLWR_H[124] WLWR_H[125] WLWR_H[126] WLWR_H[127] WL_VSS
+   SNPS_RF_DP_UHD_512x80_ary_right
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ary_row_1 ARYSD BAB[0] BAB[1] BAB[2] BAB[3] BAB[4]
+       BAB[5] BAB[6] BAB[7] BAB[8] BAB[9] BAB[10] BAB[11] BAB[12] BAB[13]
+       BAB[14] BAB[15] BAB[16] BAB[17] BAB[18] BAB[19] BAB[20] BAB[21] BAB[22]
+       BAB[23] BAB[24] BAB[25] BAB[26] BAB[27] BAB[28] BAB[29] BAB[30] BAB[31]
+       BAB[32] BAB[33] BAB[34] BAB[35] BAB[36] BAB[37] BAB[38] BAB[39] BAB[40]
+       BAB[41] BAB[42] BAB[43] BAB[44] BAB[45] BAB[46] BAB[47] BAB[48] BAB[49]
+       BAB[50] BAB[51] BAB[52] BAB[53] BAB[54] BAB[55] BAB[56] BAB[57] BAB[58]
+       BAB[59] BAB[60] BAB[61] BAB[62] BAB[63] BAB[64] BAB[65] BAB[66] BAB[67]
+       BAB[68] BAB[69] BAB[70] BAB[71] BAB[72] BAB[73] BAB[74] BAB[75] BAB[76]
+       BAB[77] BAB[78] BAB[79] BAB[80] BAB[81] BAB[82] BAB[83] BAB[84] BAB[85]
+       BAB[86] BAB[87] BAB[88] BAB[89] BAB[90] BAB[91] BAB[92] BAB[93] BAB[94]
+       BAB[95] BAB[96] BAB[97] BAB[98] BAB[99] BAB[100] BAB[101] BAB[102]
+       BAB[103] BAB[104] BAB[105] BAB[106] BAB[107] BAB[108] BAB[109] BAB[110]
+       BAB[111] BAB[112] BAB[113] BAB[114] BAB[115] BAB[116] BAB[117] BAB[118]
+       BAB[119] BAB[120] BAB[121] BAB[122] BAB[123] BAB[124] BAB[125] BAB[126]
+       BAB[127] BAB[128] BAB[129] BAB[130] BAB[131] BAB[132] BAB[133] BAB[134]
+       BAB[135] BAB[136] BAB[137] BAB[138] BAB[139] BAB[140] BAB[141] BAB[142]
+       BAB[143] BAB[144] BAB[145] BAB[146] BAB[147] BAB[148] BAB[149] BAB[150]
+       BAB[151] BAB[152] BAB[153] BAB[154] BAB[155] BAB[156] BAB[157] BAB[158]
+       BAB[159] BAT[0] BAT[1] BAT[2] BAT[3] BAT[4] BAT[5] BAT[6] BAT[7] BAT[8]
+       BAT[9] BAT[10] BAT[11] BAT[12] BAT[13] BAT[14] BAT[15] BAT[16] BAT[17]
+       BAT[18] BAT[19] BAT[20] BAT[21] BAT[22] BAT[23] BAT[24] BAT[25] BAT[26]
+       BAT[27] BAT[28] BAT[29] BAT[30] BAT[31] BAT[32] BAT[33] BAT[34] BAT[35]
+       BAT[36] BAT[37] BAT[38] BAT[39] BAT[40] BAT[41] BAT[42] BAT[43] BAT[44]
+       BAT[45] BAT[46] BAT[47] BAT[48] BAT[49] BAT[50] BAT[51] BAT[52] BAT[53]
+       BAT[54] BAT[55] BAT[56] BAT[57] BAT[58] BAT[59] BAT[60] BAT[61] BAT[62]
+       BAT[63] BAT[64] BAT[65] BAT[66] BAT[67] BAT[68] BAT[69] BAT[70] BAT[71]
+       BAT[72] BAT[73] BAT[74] BAT[75] BAT[76] BAT[77] BAT[78] BAT[79] BAT[80]
+       BAT[81] BAT[82] BAT[83] BAT[84] BAT[85] BAT[86] BAT[87] BAT[88] BAT[89]
+       BAT[90] BAT[91] BAT[92] BAT[93] BAT[94] BAT[95] BAT[96] BAT[97] BAT[98]
+       BAT[99] BAT[100] BAT[101] BAT[102] BAT[103] BAT[104] BAT[105] BAT[106]
+       BAT[107] BAT[108] BAT[109] BAT[110] BAT[111] BAT[112] BAT[113] BAT[114]
+       BAT[115] BAT[116] BAT[117] BAT[118] BAT[119] BAT[120] BAT[121] BAT[122]
+       BAT[123] BAT[124] BAT[125] BAT[126] BAT[127] BAT[128] BAT[129] BAT[130]
+       BAT[131] BAT[132] BAT[133] BAT[134] BAT[135] BAT[136] BAT[137] BAT[138]
+       BAT[139] BAT[140] BAT[141] BAT[142] BAT[143] BAT[144] BAT[145] BAT[146]
+       BAT[147] BAT[148] BAT[149] BAT[150] BAT[151] BAT[152] BAT[153] BAT[154]
+       BAT[155] BAT[156] BAT[157] BAT[158] BAT[159] BKRDB BKRDB_128 CENDP
+       DEF1_RD DEF1_WR DMY_EDGE_LB[0] DMY_EDGE_LB[1] DMY_EDGE_LT[0]
+       DMY_EDGE_LT[1] DMY_EDGE_RB[0] DMY_EDGE_RB[1] DMY_EDGE_RT[0]
+       DMY_EDGE_RT[1] FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LCGTV[0]
+       LCGTV[1] LOG0 LOG1 LRWMEB LXADRBRD_2 LXADRBRD_3 LXADRBRD_4 PAWRB[0]
+       PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+       PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+       PCWRB[1] PCWRB[2] PCWRB[3] PGIOI QT[0] QT[1] QT[2] QT[3] QT[4] QT[5]
+       QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16]
+       QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26]
+       QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+       QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46]
+       QT[47] QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56]
+       QT[57] QT[58] QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66]
+       QT[67] QT[68] QT[69] QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76]
+       QT[77] QT[78] QT[79] QT[80] QT[81] QT[82] QT[83] QT[84] QT[85] QT[86]
+       QT[87] QT[88] QT[89] QT[90] QT[91] QT[92] QT[93] QT[94] QT[95] QT[96]
+       QT[97] QT[98] QT[99] QT[100] QT[101] QT[102] QT[103] QT[104] QT[105]
+       QT[106] QT[107] QT[108] QT[109] QT[110] QT[111] QT[112] QT[113] QT[114]
+       QT[115] QT[116] QT[117] QT[118] QT[119] QT[120] QT[121] QT[122] QT[123]
+       QT[124] QT[125] QT[126] QT[127] QT[128] QT[129] QT[130] QT[131] QT[132]
+       QT[133] QT[134] QT[135] QT[136] QT[137] QT[138] QT[139] QT[140] QT[141]
+       QT[142] QT[143] QT[144] QT[145] QT[146] QT[147] QT[148] QT[149] QT[150]
+       QT[151] QT[152] QT[153] QT[154] QT[155] QT[156] QT[157] QT[158] QT[159]
+       RASSB_H[0] RASSB_H[1] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5] RBL[6]
+       RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+       RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+       RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+       RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+       RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+       RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+       RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+       RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+       RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+       RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+       RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+       RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+       RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+       RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+       RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+       RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+       RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+       RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RBLWA
+       RDBL RERASSB[0] RERASSB[1] RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1]
+       RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR
+       T1TRD T1TWR TKEEPB VBN VBP VDDA VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2
+       VDDAPI VDDF VDDP VDDPI VDDWL_RD VDDWL_RD_REBUF VDDWL_WR VDDWL_WR_REBUF
+       VEDGE VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3] WCLKWR[0]
+       WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WL_VSS XAWRB XBRDB XBWRB XCRDB
+       XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]
X_ary_r ARYSD BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   BKRDB BKRDB_128 CENDP DEF1_RD DEF1_WR DMY_EDGE_LB[0] DMY_EDGE_LT[0]
+   DMY_EDGE_LB[1] DMY_EDGE_LT[1] DMY_EDGE_RB[0] DMY_EDGE_RB[1] DMY_EDGE_RT[0]
+   DMY_EDGE_RT[1] FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LCGTV[0] LCGTV[1]
+   LOG0 LOG0 LOG1 LOG1 LRWMEB LXADRBRD_2 LXADRBRD_3 LXADRBRD_4 PAWRB[0]
+   PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0]
+   PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0]
+   PCWRB[1] PCWRB[2] PCWRB[3] PGIOI QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17]
+   QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28]
+   QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38] QT[39]
+   QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49] QT[50]
+   QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60] QT[61]
+   QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70] QT[71] QT[72]
+   QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80] QT[81] QT[82] QT[83]
+   QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91] QT[92] QT[93] QT[94]
+   QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101] QT[102] QT[103] QT[104]
+   QT[105] QT[106] QT[107] QT[108] QT[109] QT[110] QT[111] QT[112] QT[113]
+   QT[114] QT[115] QT[116] QT[117] QT[118] QT[119] QT[120] QT[121] QT[122]
+   QT[123] QT[124] QT[125] QT[126] QT[127] QT[128] QT[129] QT[130] QT[131]
+   QT[132] QT[133] QT[134] QT[135] QT[136] QT[137] QT[138] QT[139] QT[140]
+   QT[141] QT[142] QT[143] QT[144] QT[145] QT[146] QT[147] QT[148] QT[149]
+   QT[150] QT[151] QT[152] QT[153] QT[154] QT[155] QT[156] QT[157] QT[158]
+   QT[159] RASSB_H[0] RASSB_H[1] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5]
+   RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+   RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24]
+   RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33]
+   RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42]
+   RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51]
+   RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60]
+   RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69]
+   RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78]
+   RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87]
+   RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96]
+   RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RBLWA RDBL
+   RERASSB[0] RERASSB[1] RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2]
+   RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR
+   TKEEPB VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDAIR1
+   VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDAPI VDDF VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDWL_RD VDDWL_RD_REBUF VDDWL_WR VDDWL_WR_REBUF
+   VEDGE VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2]
+   WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WL_VSS XAWRB
+   XBRDB XBWRB XCRDB XCWRB YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]
+   SNPS_RF_DP_UHD_512x80_ary_r
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ref_cnt ARYSD CENDP DEF1_RD DEF1_WR DMY_EDGE_LB
+       DMY_EDGE_T2_R FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LCGTV LOG0 LOG1
+       LRWMEB RBLWA RDBL REF_LLSB_H RFLOAT RM3CNT RMTRD[0] RMTRD[1] RMTRD[2]
+       RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_INT_WR RWLB_RD RWLB_WR
+       RWLDRD RWLDRD_PASS RWLDWR RWLRD RWLRD_INT RWLRD_PROG RWLWR RWL_PROG
+       T1TRD T1TWR VBN[0] VBN[1] VBN[2] VBP[0] VBP[1] VBP[2] VDDA[0] VDDA[1]
+       VDDA[2] VDDAPI VDDF VDDP[0] VDDP[1] VDDP[2] VDDPI[0] VDDPI[1] VDDWL_RD
+       VDDWL_WR VSS[0] VSS[1] VSS[2] VSSWL WDBL WFLOAT

*** Jumper Report ***
* Jumper: RWLDRD_PASS RWLRD_PROG
* Jumper: RWLDWR RWL_PROG
* Jumper: VDDA[1] VDDF VDDP[1] VDDPI[0]
* Jumper: VDDA[2] VDDP[2] VDDPI[1]

*X_mm17a04_u_hdrf2p_rw_edgel VDDA[0] VDDP[0] VSS[0] VBP[0] VBN[0]
*+  mm17a04_u_hdrf2p_rw_edgel
X_mm17a04_u_hdrf2p_rw VDDA[1] VDDAPI VDDF VDDP[1] VDDPI[0] VSS[1] VSSWL VBP[1]
+   VBN[1] LLST RBLWA RWLBRD RWLBWR RWLB_INT_WR RWLDRD_PASS RWLRD_INT ARYSD
+   CENDP LCGTL LOG0 LOG1 LRWMEB RDBL RFLOAT RM3CNT T1TRD T1TWR WDBL WFLOAT
+   DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTV RMTRD[0] RMTRD[1]
+   RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR RWLDRD
+   RWLDWR RWLRD_PROG RWL_PROG mm17a04_u_hdrf2p_rw
X_mm17a04_u_hdrf2p_rwbuf VDDA[2] VDDP[2] VDDPI[1] VDDWL_RD VDDWL_WR VSS[2]
+   VBP[2] VBN[2] REF_LLSB_H RWLRD RWLWR DMY_EDGE_LB DMY_EDGE_T2_R LCGTV LOG0
+   LOG1 RWLDRD RWLDWR LLST RWLBRD RWLBWR mm17a04_u_hdrf2p_rwbuf
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ref_rt_rwl BAB[0] BAB[1] BAB[2] BAB[3] BAB[4]
+       BAB[5] BAB[6] BAB[7] BAB[8] BAB[9] BAB[10] BAB[11] BAB[12] BAB[13]
+       BAB[14] BAB[15] BAB[16] BAB[17] BAB[18] BAB[19] BAT[0] BAT[1] BAT[2]
+       BAT[3] BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12]
+       BAT[13] BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] DMY_EDGE_T2[1]
+       DMY_EDGE_T2[5] LLSB LOG0 LOG1 QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+       QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16]
+       QT[17] QT[18] QT[19] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5] RBL[6]
+       RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15]
+       RBL[16] RBL[17] RBL[18] RBL[19] RWLDRD RWLDWR RWLRD RWLWR VBN[0] VBN[1]
+       VBN[2] VBN[3] VBN[4] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VDDA[0] VDDA[1]
+       VDDA[2] VDDA[3] VDDA[4] VDDAI[0] VDDAI[1] VDDAI[2] VDDAI[3] VDDAI[4]
+       VDDAI_SAC[0] VDDAI_SAC[1] VDDAI_SAC[2] VDDAI_SAC[3] VDDAI_SAC[4] VDDP[0]
+       VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+       VDDPI[4] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4]

*** Jumper Report ***
* Jumper: VDDA[0] VDDAI[0] VDDAI_SAC[0] VDDP[0]
* Jumper: VDDA[1] VDDAI[1] VDDAI_SAC[1] VDDP[1]
* Jumper: VDDA[2] VDDAI[2] VDDAI_SAC[2] VDDP[2]
* Jumper: VDDA[3] VDDAI[3] VDDAI_SAC[3] VDDP[3]
* Jumper: VDDA[4] VDDAI[4] VDDAI_SAC[4] VDDP[4]

X_mm17a04_u_hdrf2p_rar2x4m1_S0 VDDA[0] VDDAI[0] VDDAI_SAC[0] VDDP[0] VDDPI[0]
+   VSS[0] VBP[0] VBN[0] BAB[0] BAB[1] BAB[2] BAB[3] BAT[0] BAT[1] BAT[2] BAT[3]
+   DMY_EDGE_T2[1] DMY_EDGE_T2[0] LLSB LOG0 LOG1 QT[0] QT[1] QT[2] QT[3] RBL[0]
+   RBL[1] RBL[2] RBL[3] RWLDRD RWLDWR RWLRD RWLWR mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_S1 VDDA[1] VDDAI[1] VDDAI_SAC[1] VDDP[1] VDDPI[1]
+   VSS[1] VBP[1] VBN[1] BAB[4] BAB[5] BAB[6] BAB[7] BAT[4] BAT[5] BAT[6] BAT[7]
+   DMY_EDGE_T2[0] DMY_EDGE_T2[2] LLSB LOG0 LOG1 QT[4] QT[5] QT[6] QT[7] RBL[4]
+   RBL[5] RBL[6] RBL[7] RWLDRD RWLDWR RWLRD RWLWR mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_F2 VDDA[2] VDDAI[2] VDDAI_SAC[2] VDDP[2] VDDPI[2]
+   VSS[2] VBP[2] VBN[2] BAB[8] BAB[9] BAB[10] BAB[11] BAT[8] BAT[9] BAT[10]
+   BAT[11] DMY_EDGE_T2[2] DMY_EDGE_T2[3] LLSB LOG0 LOG1 QT[8] QT[9] QT[10]
+   QT[11] RBL[8] RBL[9] RBL[10] RBL[11] RWLDRD RWLDWR RWLRD RWLWR
+   mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_F1 VDDA[3] VDDAI[3] VDDAI_SAC[3] VDDP[3] VDDPI[3]
+   VSS[3] VBP[3] VBN[3] BAB[12] BAB[13] BAB[14] BAB[15] BAT[12] BAT[13] BAT[14]
+   BAT[15] DMY_EDGE_T2[3] DMY_EDGE_T2[4] LLSB LOG0 LOG1 QT[12] QT[13] QT[14]
+   QT[15] RBL[12] RBL[13] RBL[14] RBL[15] RWLDRD RWLDWR RWLRD RWLWR
+   mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_F0 VDDA[4] VDDAI[4] VDDAI_SAC[4] VDDP[4] VDDPI[4]
+   VSS[4] VBP[4] VBN[4] BAB[16] BAB[17] BAB[18] BAB[19] BAT[16] BAT[17] BAT[18]
+   BAT[19] DMY_EDGE_T2[4] DMY_EDGE_T2[5] LLSB LOG0 LOG1 QT[16] QT[17] QT[18]
+   QT[19] RBL[16] RBL[17] RBL[18] RBL[19] RWLDRD RWLDWR RWLRD RWLWR
+   mm17a04_u_hdrf2p_rar2x4m1
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ref_cnt_rt_rwl ARYSD BAB[0] BAB[1] BAB[2] BAB[3]
+       BAB[4] BAB[5] BAB[6] BAB[7] BAB[8] BAB[9] BAB[10] BAB[11] BAB[12]
+       BAB[13] BAB[14] BAB[15] BAB[16] BAB[17] BAB[18] BAB[19] BAT[0] BAT[1]
+       BAT[2] BAT[3] BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11]
+       BAT[12] BAT[13] BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] CENDP
+       DEF1_RD DEF1_WR DMY_EDGE_LB DMY_EDGE_T2_R[1] FAST1_RD FAST1_WR FAST2_RD
+       FAST2_WR LCGTL LCGTV LOG0 LOG1 LRWMEB QT[0] QT[1] QT[2] QT[3] QT[4]
+       QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15]
+       QT[16] QT[17] QT[18] QT[19] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5]
+       RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14]
+       RBL[15] RBL[16] RBL[17] RBL[18] RBL[19] RBLWA RDBL REF_LLSB_H RFLOAT
+       RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2]
+       RMTWR[3] RWLB_INT_WR RWLB_RD RWLB_WR RWLDRD RWLDRD_PASS RWLDWR RWLRD
+       RWLRD_INT RWLRD_PROG RWLWR RWL_PROG T1TRD T1TWR VBN[0] VBN[1] VBN[2]
+       VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4]
+       VBP[5] VBP[6] VBP[7] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5]
+       VDDA[6] VDDA[7] VDDAIR1 VDDAI_SACR1 VDDAPI VDDF VDDP[0] VDDP[1] VDDP[2]
+       VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDPI[0] VDDPI[1] VDDPI[2]
+       VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDWL_RD VDDWL_WR VSS[0] VSS[1]
+       VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSSWL WDBL WFLOAT
X_ref_cnt ARYSD CENDP DEF1_RD DEF1_WR DMY_EDGE_LB DMY_EDGE_T2_R[0] FAST1_RD
+   FAST1_WR FAST2_RD FAST2_WR LCGTL LCGTV LOG0 LOG1 LRWMEB RBLWA RDBL
+   REF_LLSB_H RFLOAT RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0]
+   RMTWR[1] RMTWR[2] RMTWR[3] RWLB_INT_WR RWLB_RD RWLB_WR RWLDRD RWLDRD_PASS
+   RWLDWR RWLRD RWLRD_INT RWLRD_PROG RWLWR RWL_PROG T1TRD T1TWR VBN[0] VBN[1]
+   VBN[2] VBP[0] VBP[1] VBP[2] VDDA[0] VDDA[1] VDDA[2] VDDAPI VDDF VDDP[0]
+   VDDP[1] VDDP[2] VDDPI[0] VDDPI[1] VDDWL_RD VDDWL_WR VSS[0] VSS[1] VSS[2]
+   VSSWL WDBL WFLOAT SNPS_RF_DP_UHD_512x80_ref_cnt
X_ref_rt_rwl BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAT[0] BAT[1] BAT[2] BAT[3] BAT[4] BAT[5] BAT[6] BAT[7]
+   BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13] BAT[14] BAT[15] BAT[16]
+   BAT[17] BAT[18] BAT[19] DMY_EDGE_T2_R[0] DMY_EDGE_T2_R[1] REF_LLSB_H LOG0
+   LOG1 QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10]
+   QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17] QT[18] QT[19] RBL[0] RBL[1]
+   RBL[2] RBL[3] RBL[4] RBL[5] RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11]
+   RBL[12] RBL[13] RBL[14] RBL[15] RBL[16] RBL[17] RBL[18] RBL[19] RWLDRD
+   RWLDWR RWLRD RWLWR VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBP[3] VBP[4] VBP[5]
+   VBP[6] VBP[7] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDAIR1 VDDAIR1
+   VDDAIR1 VDDAIR1 VDDAIR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1
+   VDDAI_SACR1 VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   SNPS_RF_DP_UHD_512x80_ref_rt_rwl
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ref_rt_log0_case BAB[0] BAB[1] BAB[2] BAB[3]
+       BAB[4] BAB[5] BAB[6] BAB[7] BAB[8] BAB[9] BAB[10] BAB[11] BAB[12]
+       BAB[13] BAB[14] BAB[15] BAB[16] BAB[17] BAB[18] BAB[19] BAB[20] BAB[21]
+       BAB[22] BAB[23] BAB[24] BAB[25] BAB[26] BAB[27] BAB[28] BAB[29] BAB[30]
+       BAB[31] BAB[32] BAB[33] BAB[34] BAB[35] BAB[36] BAB[37] BAB[38] BAB[39]
+       BAB[40] BAB[41] BAB[42] BAB[43] BAB[44] BAB[45] BAB[46] BAB[47] BAB[48]
+       BAB[49] BAB[50] BAB[51] BAB[52] BAB[53] BAB[54] BAB[55] BAT[0] BAT[1]
+       BAT[2] BAT[3] BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11]
+       BAT[12] BAT[13] BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20]
+       BAT[21] BAT[22] BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29]
+       BAT[30] BAT[31] BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38]
+       BAT[39] BAT[40] BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47]
+       BAT[48] BAT[49] BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55]
+       DMY_EDGE_T2[1] DMY_EDGE_T2[14] LLSB LOG0 LOG1 QT[0] QT[1] QT[2] QT[3]
+       QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+       QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24]
+       QT[25] QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34]
+       QT[35] QT[36] QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44]
+       QT[45] QT[46] QT[47] QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54]
+       QT[55] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5] RBL[6] RBL[7] RBL[8]
+       RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15] RBL[16] RBL[17]
+       RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24] RBL[25] RBL[26]
+       RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33] RBL[34] RBL[35]
+       RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42] RBL[43] RBL[44]
+       RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51] RBL[52] RBL[53]
+       RBL[54] RBL[55] RWLDRD RWLDWR RWLRD RWLWR VBN[0] VBN[1] VBN[2] VBN[3]
+       VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12]
+       VBN[13] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8]
+       VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+       VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11]
+       VDDA[12] VDDA[13] VDDAI[0] VDDAI[1] VDDAI[2] VDDAI[3] VDDAI[4] VDDAI[5]
+       VDDAI[6] VDDAI[7] VDDAI[8] VDDAI[9] VDDAI[10] VDDAI[11] VDDAI[12]
+       VDDAI[13] VDDAI_SAC[0] VDDAI_SAC[1] VDDAI_SAC[2] VDDAI_SAC[3]
+       VDDAI_SAC[4] VDDAI_SAC[5] VDDAI_SAC[6] VDDAI_SAC[7] VDDAI_SAC[8]
+       VDDAI_SAC[9] VDDAI_SAC[10] VDDAI_SAC[11] VDDAI_SAC[12] VDDAI_SAC[13]
+       VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8]
+       VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDPI[0] VDDPI[1] VDDPI[2]
+       VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+       VDDPI[11] VDDPI[12] VDDPI[13] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+       VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13]

*** Jumper Report ***
* Jumper: VDDA[0] VDDAI[0] VDDAI_SAC[0] VDDP[0]
* Jumper: VDDA[1] VDDAI[1] VDDAI_SAC[1] VDDP[1]
* Jumper: VDDA[2] VDDAI[2] VDDAI_SAC[2] VDDP[2]
* Jumper: VDDA[3] VDDAI[3] VDDAI_SAC[3] VDDP[3]
* Jumper: VDDA[4] VDDAI[4] VDDAI_SAC[4] VDDP[4]
* Jumper: VDDA[5] VDDAI[5] VDDAI_SAC[5] VDDP[5]
* Jumper: VDDA[6] VDDAI[6] VDDAI_SAC[6] VDDP[6]
* Jumper: VDDA[7] VDDAI[7] VDDAI_SAC[7] VDDP[7]
* Jumper: VDDA[8] VDDAI[8] VDDAI_SAC[8] VDDP[8]
* Jumper: VDDA[9] VDDAI[9] VDDAI_SAC[9] VDDP[9]
* Jumper: VDDA[10] VDDAI[10] VDDAI_SAC[10] VDDP[10]
* Jumper: VDDA[11] VDDAI[11] VDDAI_SAC[11] VDDP[11]
* Jumper: VDDA[12] VDDAI[12] VDDAI_SAC[12] VDDP[12]
* Jumper: VDDA[13] VDDAI[13] VDDAI_SAC[13] VDDP[13]

X_mm17a04_u_hdrf2p_rar2x4m1_S0 VDDA[0] VDDAI[0] VDDAI_SAC[0] VDDP[0] VDDPI[0]
+   VSS[0] VBP[0] VBN[0] BAB[0] BAB[1] BAB[2] BAB[3] BAT[0] BAT[1] BAT[2] BAT[3]
+   DMY_EDGE_T2[1] DMY_EDGE_T2[0] LLSB LOG0 LOG1 QT[0] QT[1] QT[2] QT[3] RBL[0]
+   RBL[1] RBL[2] RBL[3] RWLDRD RWLDWR RWLRD RWLWR mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_S1 VDDA[1] VDDAI[1] VDDAI_SAC[1] VDDP[1] VDDPI[1]
+   VSS[1] VBP[1] VBN[1] BAB[4] BAB[5] BAB[6] BAB[7] BAT[4] BAT[5] BAT[6] BAT[7]
+   DMY_EDGE_T2[0] DMY_EDGE_T2[2] LLSB LOG0 LOG1 QT[4] QT[5] QT[6] QT[7] RBL[4]
+   RBL[5] RBL[6] RBL[7] RWLDRD RWLDWR RWLRD RWLWR mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_S2 VDDA[2] VDDAI[2] VDDAI_SAC[2] VDDP[2] VDDPI[2]
+   VSS[2] VBP[2] VBN[2] BAB[8] BAB[9] BAB[10] BAB[11] BAT[8] BAT[9] BAT[10]
+   BAT[11] DMY_EDGE_T2[2] DMY_EDGE_T2[3] LLSB LOG0 LOG1 QT[8] QT[9] QT[10]
+   QT[11] RBL[8] RBL[9] RBL[10] RBL[11] RWLDRD RWLDWR RWLRD RWLWR
+   mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_S3 VDDA[3] VDDAI[3] VDDAI_SAC[3] VDDP[3] VDDPI[3]
+   VSS[3] VBP[3] VBN[3] BAB[12] BAB[13] BAB[14] BAB[15] BAT[12] BAT[13] BAT[14]
+   BAT[15] DMY_EDGE_T2[3] DMY_EDGE_T2[4] LLSB LOG0 LOG1 QT[12] QT[13] QT[14]
+   QT[15] RBL[12] RBL[13] RBL[14] RBL[15] RWLDRD RWLDWR RWLRD RWLWR
+   mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_S4 VDDA[4] VDDAI[4] VDDAI_SAC[4] VDDP[4] VDDPI[4]
+   VSS[4] VBP[4] VBN[4] BAB[16] BAB[17] BAB[18] BAB[19] BAT[16] BAT[17] BAT[18]
+   BAT[19] DMY_EDGE_T2[4] DMY_EDGE_T2[5] LLSB LOG0 LOG1 QT[16] QT[17] QT[18]
+   QT[19] RBL[16] RBL[17] RBL[18] RBL[19] RWLDRD RWLDWR RWLRD RWLWR
+   mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_S5 VDDA[5] VDDAI[5] VDDAI_SAC[5] VDDP[5] VDDPI[5]
+   VSS[5] VBP[5] VBN[5] BAB[20] BAB[21] BAB[22] BAB[23] BAT[20] BAT[21] BAT[22]
+   BAT[23] DMY_EDGE_T2[5] DMY_EDGE_T2[6] LLSB LOG0 LOG1 QT[20] QT[21] QT[22]
+   QT[23] RBL[20] RBL[21] RBL[22] RBL[23] RWLDRD RWLDWR RWLRD RWLWR
+   mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_S6 VDDA[6] VDDAI[6] VDDAI_SAC[6] VDDP[6] VDDPI[6]
+   VSS[6] VBP[6] VBN[6] BAB[24] BAB[25] BAB[26] BAB[27] BAT[24] BAT[25] BAT[26]
+   BAT[27] DMY_EDGE_T2[6] DMY_EDGE_T2[7] LLSB LOG0 LOG1 QT[24] QT[25] QT[26]
+   QT[27] RBL[24] RBL[25] RBL[26] RBL[27] RWLDRD RWLDWR RWLRD RWLWR
+   mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_F6 VDDA[7] VDDAI[7] VDDAI_SAC[7] VDDP[7] VDDPI[7]
+   VSS[7] VBP[7] VBN[7] BAB[28] BAB[29] BAB[30] BAB[31] BAT[28] BAT[29] BAT[30]
+   BAT[31] DMY_EDGE_T2[7] DMY_EDGE_T2[8] LLSB LOG0 LOG1 QT[28] QT[29] QT[30]
+   QT[31] RBL[28] RBL[29] RBL[30] RBL[31] RWLDRD RWLDWR RWLRD RWLWR
+   mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_F5 VDDA[8] VDDAI[8] VDDAI_SAC[8] VDDP[8] VDDPI[8]
+   VSS[8] VBP[8] VBN[8] BAB[32] BAB[33] BAB[34] BAB[35] BAT[32] BAT[33] BAT[34]
+   BAT[35] DMY_EDGE_T2[8] DMY_EDGE_T2[9] LLSB LOG0 LOG1 QT[32] QT[33] QT[34]
+   QT[35] RBL[32] RBL[33] RBL[34] RBL[35] RWLDRD RWLDWR RWLRD RWLWR
+   mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_F4 VDDA[9] VDDAI[9] VDDAI_SAC[9] VDDP[9] VDDPI[9]
+   VSS[9] VBP[9] VBN[9] BAB[36] BAB[37] BAB[38] BAB[39] BAT[36] BAT[37] BAT[38]
+   BAT[39] DMY_EDGE_T2[9] DMY_EDGE_T2[10] LLSB LOG0 LOG1 QT[36] QT[37] QT[38]
+   QT[39] RBL[36] RBL[37] RBL[38] RBL[39] RWLDRD RWLDWR RWLRD RWLWR
+   mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_F3 VDDA[10] VDDAI[10] VDDAI_SAC[10] VDDP[10]
+   VDDPI[10] VSS[10] VBP[10] VBN[10] BAB[40] BAB[41] BAB[42] BAB[43] BAT[40]
+   BAT[41] BAT[42] BAT[43] DMY_EDGE_T2[10] DMY_EDGE_T2[11] LLSB LOG0 LOG1
+   QT[40] QT[41] QT[42] QT[43] RBL[40] RBL[41] RBL[42] RBL[43] RWLDRD RWLDWR
+   RWLRD RWLWR mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_F2 VDDA[11] VDDAI[11] VDDAI_SAC[11] VDDP[11]
+   VDDPI[11] VSS[11] VBP[11] VBN[11] BAB[44] BAB[45] BAB[46] BAB[47] BAT[44]
+   BAT[45] BAT[46] BAT[47] DMY_EDGE_T2[11] DMY_EDGE_T2[12] LLSB LOG0 LOG1
+   QT[44] QT[45] QT[46] QT[47] RBL[44] RBL[45] RBL[46] RBL[47] RWLDRD RWLDWR
+   RWLRD RWLWR mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_F1 VDDA[12] VDDAI[12] VDDAI_SAC[12] VDDP[12]
+   VDDPI[12] VSS[12] VBP[12] VBN[12] BAB[48] BAB[49] BAB[50] BAB[51] BAT[48]
+   BAT[49] BAT[50] BAT[51] DMY_EDGE_T2[12] DMY_EDGE_T2[13] LLSB LOG0 LOG1
+   QT[48] QT[49] QT[50] QT[51] RBL[48] RBL[49] RBL[50] RBL[51] RWLDRD RWLDWR
+   RWLRD RWLWR mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_F0 VDDA[13] VDDAI[13] VDDAI_SAC[13] VDDP[13]
+   VDDPI[13] VSS[13] VBP[13] VBN[13] BAB[52] BAB[53] BAB[54] BAB[55] BAT[52]
+   BAT[53] BAT[54] BAT[55] DMY_EDGE_T2[13] DMY_EDGE_T2[14] LLSB LOG0 LOG1
+   QT[52] QT[53] QT[54] QT[55] RBL[52] RBL[53] RBL[54] RBL[55] RWLDRD RWLDWR
+   RWLRD RWLWR mm17a04_u_hdrf2p_rar2x4m1
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ref_rt_seg2 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4]
+       BAB[5] BAB[6] BAB[7] BAB[8] BAB[9] BAB[10] BAB[11] BAB[12] BAB[13]
+       BAB[14] BAB[15] BAB[16] BAB[17] BAB[18] BAB[19] BAB[20] BAB[21] BAB[22]
+       BAB[23] BAB[24] BAB[25] BAB[26] BAB[27] BAB[28] BAB[29] BAB[30] BAB[31]
+       BAB[32] BAB[33] BAB[34] BAB[35] BAB[36] BAB[37] BAB[38] BAB[39] BAB[40]
+       BAB[41] BAB[42] BAB[43] BAB[44] BAB[45] BAB[46] BAB[47] BAB[48] BAB[49]
+       BAB[50] BAB[51] BAB[52] BAB[53] BAB[54] BAB[55] BAB[56] BAB[57] BAB[58]
+       BAB[59] BAB[60] BAB[61] BAB[62] BAB[63] BAB[64] BAB[65] BAB[66] BAB[67]
+       BAB[68] BAB[69] BAB[70] BAB[71] BAB[72] BAB[73] BAB[74] BAB[75] BAB[76]
+       BAB[77] BAB[78] BAB[79] BAT[0] BAT[1] BAT[2] BAT[3] BAT[4] BAT[5] BAT[6]
+       BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13] BAT[14] BAT[15]
+       BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22] BAT[23] BAT[24]
+       BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31] BAT[32] BAT[33]
+       BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40] BAT[41] BAT[42]
+       BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49] BAT[50] BAT[51]
+       BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58] BAT[59] BAT[60]
+       BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67] BAT[68] BAT[69]
+       BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76] BAT[77] BAT[78]
+       BAT[79] DMY_EDGE_T2[1] DMY_EDGE_T2[20] LLSB LOG0 LOG1 QT[0] QT[1] QT[2]
+       QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13]
+       QT[14] QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23]
+       QT[24] QT[25] QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33]
+       QT[34] QT[35] QT[36] QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43]
+       QT[44] QT[45] QT[46] QT[47] QT[48] QT[49] QT[50] QT[51] QT[52] QT[53]
+       QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60] QT[61] QT[62] QT[63]
+       QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70] QT[71] QT[72] QT[73]
+       QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] RBL[0] RBL[1] RBL[2] RBL[3]
+       RBL[4] RBL[5] RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12]
+       RBL[13] RBL[14] RBL[15] RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21]
+       RBL[22] RBL[23] RBL[24] RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30]
+       RBL[31] RBL[32] RBL[33] RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39]
+       RBL[40] RBL[41] RBL[42] RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48]
+       RBL[49] RBL[50] RBL[51] RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57]
+       RBL[58] RBL[59] RBL[60] RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66]
+       RBL[67] RBL[68] RBL[69] RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75]
+       RBL[76] RBL[77] RBL[78] RBL[79] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4]
+       VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13]
+       VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBP[0] VBP[1] VBP[2]
+       VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+       VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VDDA[0] VDDA[1]
+       VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10]
+       VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17] VDDA[18]
+       VDDA[19] VDDAI[0] VDDAI[1] VDDAI[2] VDDAI[3] VDDAI[4] VDDAI[5] VDDAI[6]
+       VDDAI[7] VDDAI[8] VDDAI[9] VDDAI[10] VDDAI[11] VDDAI[12] VDDAI[13]
+       VDDAI[14] VDDAI[15] VDDAI[16] VDDAI[17] VDDAI[18] VDDAI[19] VDDAI_SAC[0]
+       VDDAI_SAC[1] VDDAI_SAC[2] VDDAI_SAC[3] VDDAI_SAC[4] VDDAI_SAC[5]
+       VDDAI_SAC[6] VDDAI_SAC[7] VDDAI_SAC[8] VDDAI_SAC[9] VDDAI_SAC[10]
+       VDDAI_SAC[11] VDDAI_SAC[12] VDDAI_SAC[13] VDDAI_SAC[14] VDDAI_SAC[15]
+       VDDAI_SAC[16] VDDAI_SAC[17] VDDAI_SAC[18] VDDAI_SAC[19] VDDP[0] VDDP[1]
+       VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+       VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+       VDDP[19] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6]
+       VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13]
+       VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VSS[0]
+       VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+       VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19]

*** Jumper Report ***
* Jumper: VDDA[0] VDDAI[0] VDDAI_SAC[0] VDDP[0]
* Jumper: VDDA[1] VDDAI[1] VDDAI_SAC[1] VDDP[1]
* Jumper: VDDA[2] VDDAI[2] VDDAI_SAC[2] VDDP[2]
* Jumper: VDDA[3] VDDAI[3] VDDAI_SAC[3] VDDP[3]
* Jumper: VDDA[4] VDDAI[4] VDDAI_SAC[4] VDDP[4]
* Jumper: VDDA[5] VDDAI[5] VDDAI_SAC[5] VDDP[5]
* Jumper: VDDA[6] VDDAI[6] VDDAI_SAC[6] VDDP[6]
* Jumper: VDDA[7] VDDAI[7] VDDAI_SAC[7] VDDP[7]
* Jumper: VDDA[8] VDDAI[8] VDDAI_SAC[8] VDDP[8]
* Jumper: VDDA[9] VDDAI[9] VDDAI_SAC[9] VDDP[9]
* Jumper: VDDA[10] VDDAI[10] VDDAI_SAC[10] VDDP[10]
* Jumper: VDDA[11] VDDAI[11] VDDAI_SAC[11] VDDP[11]
* Jumper: VDDA[12] VDDAI[12] VDDAI_SAC[12] VDDP[12]
* Jumper: VDDA[13] VDDAI[13] VDDAI_SAC[13] VDDP[13]
* Jumper: VDDA[14] VDDAI[14] VDDAI_SAC[14] VDDP[14]
* Jumper: VDDA[15] VDDAI[15] VDDAI_SAC[15] VDDP[15]
* Jumper: VDDA[16] VDDAI[16] VDDAI_SAC[16] VDDP[16]
* Jumper: VDDA[17] VDDAI[17] VDDAI_SAC[17] VDDP[17]
* Jumper: VDDA[18] VDDAI[18] VDDAI_SAC[18] VDDP[18]
* Jumper: VDDA[19] VDDAI[19] VDDAI_SAC[19] VDDP[19]

X_mm17a04_u_hdrf2p_rar2x4m1_S0 VDDA[0] VDDAI[0] VDDAI_SAC[0] VDDP[0] VDDPI[0]
+   VSS[0] VBP[0] VBN[0] BAB[0] BAB[1] BAB[2] BAB[3] BAT[0] BAT[1] BAT[2] BAT[3]
+   DMY_EDGE_T2[1] DMY_EDGE_T2[0] LLSB LOG0 LOG1 QT[0] QT[1] QT[2] QT[3] RBL[0]
+   RBL[1] RBL[2] RBL[3] LOG0 LOG0 LOG0 LOG0 mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_S1 VDDA[1] VDDAI[1] VDDAI_SAC[1] VDDP[1] VDDPI[1]
+   VSS[1] VBP[1] VBN[1] BAB[4] BAB[5] BAB[6] BAB[7] BAT[4] BAT[5] BAT[6] BAT[7]
+   DMY_EDGE_T2[0] DMY_EDGE_T2[2] LLSB LOG0 LOG1 QT[4] QT[5] QT[6] QT[7] RBL[4]
+   RBL[5] RBL[6] RBL[7] LOG0 LOG0 LOG0 LOG0 mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_S2 VDDA[2] VDDAI[2] VDDAI_SAC[2] VDDP[2] VDDPI[2]
+   VSS[2] VBP[2] VBN[2] BAB[8] BAB[9] BAB[10] BAB[11] BAT[8] BAT[9] BAT[10]
+   BAT[11] DMY_EDGE_T2[2] DMY_EDGE_T2[3] LLSB LOG0 LOG1 QT[8] QT[9] QT[10]
+   QT[11] RBL[8] RBL[9] RBL[10] RBL[11] LOG0 LOG0 LOG0 LOG0
+   mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_S3 VDDA[3] VDDAI[3] VDDAI_SAC[3] VDDP[3] VDDPI[3]
+   VSS[3] VBP[3] VBN[3] BAB[12] BAB[13] BAB[14] BAB[15] BAT[12] BAT[13] BAT[14]
+   BAT[15] DMY_EDGE_T2[3] DMY_EDGE_T2[4] LLSB LOG0 LOG1 QT[12] QT[13] QT[14]
+   QT[15] RBL[12] RBL[13] RBL[14] RBL[15] LOG0 LOG0 LOG0 LOG0
+   mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_S4 VDDA[4] VDDAI[4] VDDAI_SAC[4] VDDP[4] VDDPI[4]
+   VSS[4] VBP[4] VBN[4] BAB[16] BAB[17] BAB[18] BAB[19] BAT[16] BAT[17] BAT[18]
+   BAT[19] DMY_EDGE_T2[4] DMY_EDGE_T2[5] LLSB LOG0 LOG1 QT[16] QT[17] QT[18]
+   QT[19] RBL[16] RBL[17] RBL[18] RBL[19] LOG0 LOG0 LOG0 LOG0
+   mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_S5 VDDA[5] VDDAI[5] VDDAI_SAC[5] VDDP[5] VDDPI[5]
+   VSS[5] VBP[5] VBN[5] BAB[20] BAB[21] BAB[22] BAB[23] BAT[20] BAT[21] BAT[22]
+   BAT[23] DMY_EDGE_T2[5] DMY_EDGE_T2[6] LLSB LOG0 LOG1 QT[20] QT[21] QT[22]
+   QT[23] RBL[20] RBL[21] RBL[22] RBL[23] LOG0 LOG0 LOG0 LOG0
+   mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_S6 VDDA[6] VDDAI[6] VDDAI_SAC[6] VDDP[6] VDDPI[6]
+   VSS[6] VBP[6] VBN[6] BAB[24] BAB[25] BAB[26] BAB[27] BAT[24] BAT[25] BAT[26]
+   BAT[27] DMY_EDGE_T2[6] DMY_EDGE_T2[7] LLSB LOG0 LOG1 QT[24] QT[25] QT[26]
+   QT[27] RBL[24] RBL[25] RBL[26] RBL[27] LOG0 LOG0 LOG0 LOG0
+   mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_S7 VDDA[7] VDDAI[7] VDDAI_SAC[7] VDDP[7] VDDPI[7]
+   VSS[7] VBP[7] VBN[7] BAB[28] BAB[29] BAB[30] BAB[31] BAT[28] BAT[29] BAT[30]
+   BAT[31] DMY_EDGE_T2[7] DMY_EDGE_T2[8] LLSB LOG0 LOG1 QT[28] QT[29] QT[30]
+   QT[31] RBL[28] RBL[29] RBL[30] RBL[31] LOG0 LOG0 LOG0 LOG0
+   mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_S8 VDDA[8] VDDAI[8] VDDAI_SAC[8] VDDP[8] VDDPI[8]
+   VSS[8] VBP[8] VBN[8] BAB[32] BAB[33] BAB[34] BAB[35] BAT[32] BAT[33] BAT[34]
+   BAT[35] DMY_EDGE_T2[8] DMY_EDGE_T2[9] LLSB LOG0 LOG1 QT[32] QT[33] QT[34]
+   QT[35] RBL[32] RBL[33] RBL[34] RBL[35] LOG0 LOG0 LOG0 LOG0
+   mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_S9 VDDA[9] VDDAI[9] VDDAI_SAC[9] VDDP[9] VDDPI[9]
+   VSS[9] VBP[9] VBN[9] BAB[36] BAB[37] BAB[38] BAB[39] BAT[36] BAT[37] BAT[38]
+   BAT[39] DMY_EDGE_T2[9] DMY_EDGE_T2[10] LLSB LOG0 LOG1 QT[36] QT[37] QT[38]
+   QT[39] RBL[36] RBL[37] RBL[38] RBL[39] LOG0 LOG0 LOG0 LOG0
+   mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_F9 VDDA[10] VDDAI[10] VDDAI_SAC[10] VDDP[10]
+   VDDPI[10] VSS[10] VBP[10] VBN[10] BAB[40] BAB[41] BAB[42] BAB[43] BAT[40]
+   BAT[41] BAT[42] BAT[43] DMY_EDGE_T2[10] DMY_EDGE_T2[11] LLSB LOG0 LOG1
+   QT[40] QT[41] QT[42] QT[43] RBL[40] RBL[41] RBL[42] RBL[43] LOG0 LOG0 LOG0
+   LOG0 mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_F8 VDDA[11] VDDAI[11] VDDAI_SAC[11] VDDP[11]
+   VDDPI[11] VSS[11] VBP[11] VBN[11] BAB[44] BAB[45] BAB[46] BAB[47] BAT[44]
+   BAT[45] BAT[46] BAT[47] DMY_EDGE_T2[11] DMY_EDGE_T2[12] LLSB LOG0 LOG1
+   QT[44] QT[45] QT[46] QT[47] RBL[44] RBL[45] RBL[46] RBL[47] LOG0 LOG0 LOG0
+   LOG0 mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_F7 VDDA[12] VDDAI[12] VDDAI_SAC[12] VDDP[12]
+   VDDPI[12] VSS[12] VBP[12] VBN[12] BAB[48] BAB[49] BAB[50] BAB[51] BAT[48]
+   BAT[49] BAT[50] BAT[51] DMY_EDGE_T2[12] DMY_EDGE_T2[13] LLSB LOG0 LOG1
+   QT[48] QT[49] QT[50] QT[51] RBL[48] RBL[49] RBL[50] RBL[51] LOG0 LOG0 LOG0
+   LOG0 mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_F6 VDDA[13] VDDAI[13] VDDAI_SAC[13] VDDP[13]
+   VDDPI[13] VSS[13] VBP[13] VBN[13] BAB[52] BAB[53] BAB[54] BAB[55] BAT[52]
+   BAT[53] BAT[54] BAT[55] DMY_EDGE_T2[13] DMY_EDGE_T2[14] LLSB LOG0 LOG1
+   QT[52] QT[53] QT[54] QT[55] RBL[52] RBL[53] RBL[54] RBL[55] LOG0 LOG0 LOG0
+   LOG0 mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_F5 VDDA[14] VDDAI[14] VDDAI_SAC[14] VDDP[14]
+   VDDPI[14] VSS[14] VBP[14] VBN[14] BAB[56] BAB[57] BAB[58] BAB[59] BAT[56]
+   BAT[57] BAT[58] BAT[59] DMY_EDGE_T2[14] DMY_EDGE_T2[15] LLSB LOG0 LOG1
+   QT[56] QT[57] QT[58] QT[59] RBL[56] RBL[57] RBL[58] RBL[59] LOG0 LOG0 LOG0
+   LOG0 mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_F4 VDDA[15] VDDAI[15] VDDAI_SAC[15] VDDP[15]
+   VDDPI[15] VSS[15] VBP[15] VBN[15] BAB[60] BAB[61] BAB[62] BAB[63] BAT[60]
+   BAT[61] BAT[62] BAT[63] DMY_EDGE_T2[15] DMY_EDGE_T2[16] LLSB LOG0 LOG1
+   QT[60] QT[61] QT[62] QT[63] RBL[60] RBL[61] RBL[62] RBL[63] LOG0 LOG0 LOG0
+   LOG0 mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_F3 VDDA[16] VDDAI[16] VDDAI_SAC[16] VDDP[16]
+   VDDPI[16] VSS[16] VBP[16] VBN[16] BAB[64] BAB[65] BAB[66] BAB[67] BAT[64]
+   BAT[65] BAT[66] BAT[67] DMY_EDGE_T2[16] DMY_EDGE_T2[17] LLSB LOG0 LOG1
+   QT[64] QT[65] QT[66] QT[67] RBL[64] RBL[65] RBL[66] RBL[67] LOG0 LOG0 LOG0
+   LOG0 mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_F2 VDDA[17] VDDAI[17] VDDAI_SAC[17] VDDP[17]
+   VDDPI[17] VSS[17] VBP[17] VBN[17] BAB[68] BAB[69] BAB[70] BAB[71] BAT[68]
+   BAT[69] BAT[70] BAT[71] DMY_EDGE_T2[17] DMY_EDGE_T2[18] LLSB LOG0 LOG1
+   QT[68] QT[69] QT[70] QT[71] RBL[68] RBL[69] RBL[70] RBL[71] LOG0 LOG0 LOG0
+   LOG0 mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_F1 VDDA[18] VDDAI[18] VDDAI_SAC[18] VDDP[18]
+   VDDPI[18] VSS[18] VBP[18] VBN[18] BAB[72] BAB[73] BAB[74] BAB[75] BAT[72]
+   BAT[73] BAT[74] BAT[75] DMY_EDGE_T2[18] DMY_EDGE_T2[19] LLSB LOG0 LOG1
+   QT[72] QT[73] QT[74] QT[75] RBL[72] RBL[73] RBL[74] RBL[75] LOG0 LOG0 LOG0
+   LOG0 mm17a04_u_hdrf2p_rar2x4m1
X_mm17a04_u_hdrf2p_rar2x4m1_F0 VDDA[19] VDDAI[19] VDDAI_SAC[19] VDDP[19]
+   VDDPI[19] VSS[19] VBP[19] VBN[19] BAB[76] BAB[77] BAB[78] BAB[79] BAT[76]
+   BAT[77] BAT[78] BAT[79] DMY_EDGE_T2[19] DMY_EDGE_T2[20] LLSB LOG0 LOG1
+   QT[76] QT[77] QT[78] QT[79] RBL[76] RBL[77] RBL[78] RBL[79] LOG0 LOG0 LOG0
+   LOG0 mm17a04_u_hdrf2p_rar2x4m1
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ref_rt_rep_seg2 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4]
+       BAB[5] BAB[6] BAB[7] BAB[8] BAB[9] BAB[10] BAB[11] BAB[12] BAB[13]
+       BAB[14] BAB[15] BAB[16] BAB[17] BAB[18] BAB[19] BAB[20] BAB[21] BAB[22]
+       BAB[23] BAB[24] BAB[25] BAB[26] BAB[27] BAB[28] BAB[29] BAB[30] BAB[31]
+       BAB[32] BAB[33] BAB[34] BAB[35] BAB[36] BAB[37] BAB[38] BAB[39] BAB[40]
+       BAB[41] BAB[42] BAB[43] BAB[44] BAB[45] BAB[46] BAB[47] BAB[48] BAB[49]
+       BAB[50] BAB[51] BAB[52] BAB[53] BAB[54] BAB[55] BAB[56] BAB[57] BAB[58]
+       BAB[59] BAB[60] BAB[61] BAB[62] BAB[63] BAB[64] BAB[65] BAB[66] BAB[67]
+       BAB[68] BAB[69] BAB[70] BAB[71] BAB[72] BAB[73] BAB[74] BAB[75] BAB[76]
+       BAB[77] BAB[78] BAB[79] BAT[0] BAT[1] BAT[2] BAT[3] BAT[4] BAT[5] BAT[6]
+       BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13] BAT[14] BAT[15]
+       BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22] BAT[23] BAT[24]
+       BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31] BAT[32] BAT[33]
+       BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40] BAT[41] BAT[42]
+       BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49] BAT[50] BAT[51]
+       BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58] BAT[59] BAT[60]
+       BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67] BAT[68] BAT[69]
+       BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76] BAT[77] BAT[78]
+       BAT[79] DMY_EDGE_LB DMY_EDGE_RB DMY_EDGE_T2[1] DMY_EDGE_T2[2] LCGTV LOG0
+       LOG1 QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10]
+       QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17] QT[18] QT[19] QT[20]
+       QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28] QT[29] QT[30]
+       QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38] QT[39] QT[40]
+       QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49] QT[50]
+       QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60]
+       QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70]
+       QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] RBL[0]
+       RBL[1] RBL[2] RBL[3] RBL[4] RBL[5] RBL[6] RBL[7] RBL[8] RBL[9] RBL[10]
+       RBL[11] RBL[12] RBL[13] RBL[14] RBL[15] RBL[16] RBL[17] RBL[18] RBL[19]
+       RBL[20] RBL[21] RBL[22] RBL[23] RBL[24] RBL[25] RBL[26] RBL[27] RBL[28]
+       RBL[29] RBL[30] RBL[31] RBL[32] RBL[33] RBL[34] RBL[35] RBL[36] RBL[37]
+       RBL[38] RBL[39] RBL[40] RBL[41] RBL[42] RBL[43] RBL[44] RBL[45] RBL[46]
+       RBL[47] RBL[48] RBL[49] RBL[50] RBL[51] RBL[52] RBL[53] RBL[54] RBL[55]
+       RBL[56] RBL[57] RBL[58] RBL[59] RBL[60] RBL[61] RBL[62] RBL[63] RBL[64]
+       RBL[65] RBL[66] RBL[67] RBL[68] RBL[69] RBL[70] RBL[71] RBL[72] RBL[73]
+       RBL[74] RBL[75] RBL[76] RBL[77] RBL[78] RBL[79] REF_LLSB_H RELLSB RWLDRD
+       RWLDWR RWLRD RWLWR VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+       VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15]
+       VBN[16] VBN[17] VBN[18] VBN[19] VBN[20] VBP[0] VBP[1] VBP[2] VBP[3]
+       VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+       VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VDDA[0]
+       VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9]
+       VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17]
+       VDDA[18] VDDA[19] VDDA[20] VDDAIR2 VDDAI_SACR2 VDDP[0] VDDP[1] VDDP[2]
+       VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10]
+       VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+       VDDP[19] VDDP[20] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5]
+       VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12]
+       VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19]
+       VDDPI[20] VDDWL_RD_REBUF VDDWL_WR_REBUF VSS[0] VSS[1] VSS[2] VSS[3]
+       VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+       VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] WL_VSS

*** Jumper Report ***
* Jumper: LOG0 RWLDRD RWLDWR RWLRD RWLWR
* Jumper: VDDP[0] VDDPI[0]

X_mm17a04_u_hdrf2p_rwrebuf VDDA[0] VDDP[0] VDDPI[0] VDDWL_RD_REBUF
+   VDDWL_WR_REBUF VSS[0] VBP[0] VBN[0] RELLSB RWLDRD RWLDWR DMY_EDGE_LB
+   DMY_EDGE_RB DMY_EDGE_T2[1] DMY_EDGE_T2[0] LOG0 LOG1 WL_VSS LCGTV REF_LLSB_H
+   RWLRD RWLWR mm17a04_u_hdrf2p_rwrebuf
X_ref_rt_seg2 BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAT[0]
+   BAT[1] BAT[2] BAT[3] BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10]
+   BAT[11] BAT[12] BAT[13] BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19]
+   BAT[20] BAT[21] BAT[22] BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28]
+   BAT[29] BAT[30] BAT[31] BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37]
+   BAT[38] BAT[39] BAT[40] BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46]
+   BAT[47] BAT[48] BAT[49] BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55]
+   BAT[56] BAT[57] BAT[58] BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64]
+   BAT[65] BAT[66] BAT[67] BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73]
+   BAT[74] BAT[75] BAT[76] BAT[77] BAT[78] BAT[79] DMY_EDGE_T2[0]
+   DMY_EDGE_T2[2] RELLSB LOG0 LOG1 QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17]
+   QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28]
+   QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38] QT[39]
+   QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49] QT[50]
+   QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60] QT[61]
+   QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70] QT[71] QT[72]
+   QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] RBL[0] RBL[1] RBL[2] RBL[3]
+   RBL[4] RBL[5] RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13]
+   RBL[14] RBL[15] RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21] RBL[22]
+   RBL[23] RBL[24] RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30] RBL[31]
+   RBL[32] RBL[33] RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39] RBL[40]
+   RBL[41] RBL[42] RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48] RBL[49]
+   RBL[50] RBL[51] RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57] RBL[58]
+   RBL[59] RBL[60] RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66] RBL[67]
+   RBL[68] RBL[69] RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75] RBL[76]
+   RBL[77] RBL[78] RBL[79] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7]
+   VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+   VBN[17] VBN[18] VBN[19] VBN[20] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+   VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+   VBP[17] VBP[18] VBP[19] VBP[20] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5]
+   VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+   VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDAIR2 VDDAIR2
+   VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2
+   VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2 VDDAIR2
+   VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2
+   VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2
+   VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2 VDDAI_SACR2
+   VDDAI_SACR2 VDDAI_SACR2 VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6]
+   VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14]
+   VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDPI[1] VDDPI[2]
+   VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+   VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17]
+   VDDPI[18] VDDPI[19] VDDPI[20] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6]
+   VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16]
+   VSS[17] VSS[18] VSS[19] VSS[20] SNPS_RF_DP_UHD_512x80_ref_rt_seg2
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ref_row ARYSD BAB[0] BAB[1] BAB[2] BAB[3] BAB[4]
+       BAB[5] BAB[6] BAB[7] BAB[8] BAB[9] BAB[10] BAB[11] BAB[12] BAB[13]
+       BAB[14] BAB[15] BAB[16] BAB[17] BAB[18] BAB[19] BAB[20] BAB[21] BAB[22]
+       BAB[23] BAB[24] BAB[25] BAB[26] BAB[27] BAB[28] BAB[29] BAB[30] BAB[31]
+       BAB[32] BAB[33] BAB[34] BAB[35] BAB[36] BAB[37] BAB[38] BAB[39] BAB[40]
+       BAB[41] BAB[42] BAB[43] BAB[44] BAB[45] BAB[46] BAB[47] BAB[48] BAB[49]
+       BAB[50] BAB[51] BAB[52] BAB[53] BAB[54] BAB[55] BAB[56] BAB[57] BAB[58]
+       BAB[59] BAB[60] BAB[61] BAB[62] BAB[63] BAB[64] BAB[65] BAB[66] BAB[67]
+       BAB[68] BAB[69] BAB[70] BAB[71] BAB[72] BAB[73] BAB[74] BAB[75] BAB[76]
+       BAB[77] BAB[78] BAB[79] BAB[80] BAB[81] BAB[82] BAB[83] BAB[84] BAB[85]
+       BAB[86] BAB[87] BAB[88] BAB[89] BAB[90] BAB[91] BAB[92] BAB[93] BAB[94]
+       BAB[95] BAB[96] BAB[97] BAB[98] BAB[99] BAB[100] BAB[101] BAB[102]
+       BAB[103] BAB[104] BAB[105] BAB[106] BAB[107] BAB[108] BAB[109] BAB[110]
+       BAB[111] BAB[112] BAB[113] BAB[114] BAB[115] BAB[116] BAB[117] BAB[118]
+       BAB[119] BAB[120] BAB[121] BAB[122] BAB[123] BAB[124] BAB[125] BAB[126]
+       BAB[127] BAB[128] BAB[129] BAB[130] BAB[131] BAB[132] BAB[133] BAB[134]
+       BAB[135] BAB[136] BAB[137] BAB[138] BAB[139] BAB[140] BAB[141] BAB[142]
+       BAB[143] BAB[144] BAB[145] BAB[146] BAB[147] BAB[148] BAB[149] BAB[150]
+       BAB[151] BAB[152] BAB[153] BAB[154] BAB[155] BAB[156] BAB[157] BAB[158]
+       BAB[159] BAT[0] BAT[1] BAT[2] BAT[3] BAT[4] BAT[5] BAT[6] BAT[7] BAT[8]
+       BAT[9] BAT[10] BAT[11] BAT[12] BAT[13] BAT[14] BAT[15] BAT[16] BAT[17]
+       BAT[18] BAT[19] BAT[20] BAT[21] BAT[22] BAT[23] BAT[24] BAT[25] BAT[26]
+       BAT[27] BAT[28] BAT[29] BAT[30] BAT[31] BAT[32] BAT[33] BAT[34] BAT[35]
+       BAT[36] BAT[37] BAT[38] BAT[39] BAT[40] BAT[41] BAT[42] BAT[43] BAT[44]
+       BAT[45] BAT[46] BAT[47] BAT[48] BAT[49] BAT[50] BAT[51] BAT[52] BAT[53]
+       BAT[54] BAT[55] BAT[56] BAT[57] BAT[58] BAT[59] BAT[60] BAT[61] BAT[62]
+       BAT[63] BAT[64] BAT[65] BAT[66] BAT[67] BAT[68] BAT[69] BAT[70] BAT[71]
+       BAT[72] BAT[73] BAT[74] BAT[75] BAT[76] BAT[77] BAT[78] BAT[79] BAT[80]
+       BAT[81] BAT[82] BAT[83] BAT[84] BAT[85] BAT[86] BAT[87] BAT[88] BAT[89]
+       BAT[90] BAT[91] BAT[92] BAT[93] BAT[94] BAT[95] BAT[96] BAT[97] BAT[98]
+       BAT[99] BAT[100] BAT[101] BAT[102] BAT[103] BAT[104] BAT[105] BAT[106]
+       BAT[107] BAT[108] BAT[109] BAT[110] BAT[111] BAT[112] BAT[113] BAT[114]
+       BAT[115] BAT[116] BAT[117] BAT[118] BAT[119] BAT[120] BAT[121] BAT[122]
+       BAT[123] BAT[124] BAT[125] BAT[126] BAT[127] BAT[128] BAT[129] BAT[130]
+       BAT[131] BAT[132] BAT[133] BAT[134] BAT[135] BAT[136] BAT[137] BAT[138]
+       BAT[139] BAT[140] BAT[141] BAT[142] BAT[143] BAT[144] BAT[145] BAT[146]
+       BAT[147] BAT[148] BAT[149] BAT[150] BAT[151] BAT[152] BAT[153] BAT[154]
+       BAT[155] BAT[156] BAT[157] BAT[158] BAT[159] CENDP DEF1_RD DEF1_WR
+       DMY_EDGE_LB[0] DMY_EDGE_LB[1] DMY_EDGE_RB[0] DMY_EDGE_RB[1] FAST1_RD
+       FAST1_WR FAST2_RD FAST2_WR LCGTL LCGTV[0] LCGTV[1] LOG0 LOG1 LRWMEB
+       PGIOI QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10]
+       QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17] QT[18] QT[19] QT[20]
+       QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28] QT[29] QT[30]
+       QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38] QT[39] QT[40]
+       QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49] QT[50]
+       QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60]
+       QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70]
+       QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+       QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90]
+       QT[91] QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100]
+       QT[101] QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109]
+       QT[110] QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118]
+       QT[119] QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127]
+       QT[128] QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136]
+       QT[137] QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145]
+       QT[146] QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154]
+       QT[155] QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3]
+       RBL[4] RBL[5] RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12]
+       RBL[13] RBL[14] RBL[15] RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21]
+       RBL[22] RBL[23] RBL[24] RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30]
+       RBL[31] RBL[32] RBL[33] RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39]
+       RBL[40] RBL[41] RBL[42] RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48]
+       RBL[49] RBL[50] RBL[51] RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57]
+       RBL[58] RBL[59] RBL[60] RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66]
+       RBL[67] RBL[68] RBL[69] RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75]
+       RBL[76] RBL[77] RBL[78] RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84]
+       RBL[85] RBL[86] RBL[87] RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93]
+       RBL[94] RBL[95] RBL[96] RBL[97] RBL[98] RBL[99] RBL[100] RBL[101]
+       RBL[102] RBL[103] RBL[104] RBL[105] RBL[106] RBL[107] RBL[108] RBL[109]
+       RBL[110] RBL[111] RBL[112] RBL[113] RBL[114] RBL[115] RBL[116] RBL[117]
+       RBL[118] RBL[119] RBL[120] RBL[121] RBL[122] RBL[123] RBL[124] RBL[125]
+       RBL[126] RBL[127] RBL[128] RBL[129] RBL[130] RBL[131] RBL[132] RBL[133]
+       RBL[134] RBL[135] RBL[136] RBL[137] RBL[138] RBL[139] RBL[140] RBL[141]
+       RBL[142] RBL[143] RBL[144] RBL[145] RBL[146] RBL[147] RBL[148] RBL[149]
+       RBL[150] RBL[151] RBL[152] RBL[153] RBL[154] RBL[155] RBL[156] RBL[157]
+       RBL[158] RBL[159] RBLWA RDBL RFLOAT RM3CNT RMTRD[0] RMTRD[1] RMTRD[2]
+       RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_INT_WR RWLB_RD RWLB_WR
+       RWLDRD_PASS RWLRD_INT RWLRD_PROG RWL_PROG T1TRD T1TWR VBN[0] VBN[1]
+       VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11]
+       VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20]
+       VBN[21] VBN[22] VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28] VBN[29]
+       VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35] VBN[36] VBN[37] VBN[38]
+       VBN[39] VBN[40] VBN[41] VBN[42] VBN[43] VBN[44] VBP[0] VBP[1] VBP[2]
+       VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+       VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VBP[21]
+       VBP[22] VBP[23] VBP[24] VBP[25] VBP[26] VBP[27] VBP[28] VBP[29] VBP[30]
+       VBP[31] VBP[32] VBP[33] VBP[34] VBP[35] VBP[36] VBP[37] VBP[38] VBP[39]
+       VBP[40] VBP[41] VBP[42] VBP[43] VBP[44] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+       VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11]
+       VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19]
+       VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27]
+       VDDA[28] VDDA[29] VDDA[30] VDDA[31] VDDA[32] VDDA[33] VDDA[34] VDDA[35]
+       VDDA[36] VDDA[37] VDDA[38] VDDA[39] VDDA[40] VDDA[41] VDDA[42] VDDA[43]
+       VDDA[44] VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDAPI VDDF VDDP[0]
+       VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9]
+       VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17]
+       VDDP[18] VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDP[23] VDDP[24] VDDP[25]
+       VDDP[26] VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31] VDDP[32] VDDP[33]
+       VDDP[34] VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39] VDDP[40] VDDP[41]
+       VDDP[42] VDDP[43] VDDP[44] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+       VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+       VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18]
+       VDDPI[19] VDDPI[20] VDDPI[21] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25]
+       VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31] VDDPI[32]
+       VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36] VDDPI[37] VDDPI[38] VDDPI[39]
+       VDDPI[40] VDDPI[41] VDDPI[42] VDDPI[43] VDDWL_RD VDDWL_RD_REBUF VDDWL_WR
+       VDDWL_WR_REBUF VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6]
+       VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15]
+       VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22] VSS[23] VSS[24]
+       VSS[25] VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33]
+       VSS[34] VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] VSS[42]
+       VSS[43] VSS[44] VSSWL WDBL WFLOAT WL_VSS

*** Jumper Report ***
* Jumper: LOG1 PGIOI
* Jumper: VDDA[8] VDDAIR1 VDDAI_SACR1 VDDP[8]
* Jumper: VDDA[44] VDDP[44]

X_ref_cnt_rt_rwl ARYSD BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7]
+   BAB[8] BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16]
+   BAB[17] BAB[18] BAB[19] BAT[0] BAT[1] BAT[2] BAT[3] BAT[4] BAT[5] BAT[6]
+   BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13] BAT[14] BAT[15] BAT[16]
+   BAT[17] BAT[18] BAT[19] CENDP DEF1_RD DEF1_WR DMY_EDGE_LB[0] DMY_EDGE_T2_R
+   FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LCGTV[0] LOG0 LOG1 LRWMEB QT[0]
+   QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12]
+   QT[13] QT[14] QT[15] QT[16] QT[17] QT[18] QT[19] RBL[0] RBL[1] RBL[2] RBL[3]
+   RBL[4] RBL[5] RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12] RBL[13]
+   RBL[14] RBL[15] RBL[16] RBL[17] RBL[18] RBL[19] RBLWA RDBL REF_LLSB_H RFLOAT
+   RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2]
+   RMTWR[3] RWLB_INT_WR RWLB_RD RWLB_WR RWLDRD[0] RWLDRD_PASS RWL_PROG
+   RWLDRD[0] RWLRD_INT RWLRD_PROG RWL_PROG RWL_PROG T1TRD T1TWR VBN[0] VBN[1]
+   VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4]
+   VBP[5] VBP[6] VBP[7] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6]
+   VDDA[7] VDDAIR1 VDDAI_SACR1 VDDAPI VDDF VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+   VDDPI[5] VDDPI[6] VDDWL_RD VDDWL_WR VSS[0] VSS[1] VSS[2] VSS[3] VSS[4]
+   VSS[5] VSS[6] VSS[7] VSSWL WDBL WFLOAT SNPS_RF_DP_UHD_512x80_ref_cnt_rt_rwl
X_mm17a04_u_hdrf2p_rrar2x4m1 VDDA[8] VDDAIR1 VDDAI_SACR1 VDDP[8] VDDPI[7] VSS[8]
+   VBP[8] VBN[8] BAB[20] BAB[21] BAB[22] BAB[23] BAT[20] BAT[21] BAT[22]
+   BAT[23] DMY_EDGE_T2_R DMY_EDGE_T2[0] REF_LLSB_H LOG0 LOG1 QT[20] QT[21]
+   QT[22] QT[23] RBL[20] RBL[21] RBL[22] RBL[23] RWLDRD[0] RWL_PROG
+   mm17a04_u_hdrf2p_rrar2x4m1
X_ref_rt_log0_case BAB[24] BAB[25] BAB[26] BAB[27] BAB[28] BAB[29] BAB[30]
+   BAB[31] BAB[32] BAB[33] BAB[34] BAB[35] BAB[36] BAB[37] BAB[38] BAB[39]
+   BAB[40] BAB[41] BAB[42] BAB[43] BAB[44] BAB[45] BAB[46] BAB[47] BAB[48]
+   BAB[49] BAB[50] BAB[51] BAB[52] BAB[53] BAB[54] BAB[55] BAB[56] BAB[57]
+   BAB[58] BAB[59] BAB[60] BAB[61] BAB[62] BAB[63] BAB[64] BAB[65] BAB[66]
+   BAB[67] BAB[68] BAB[69] BAB[70] BAB[71] BAB[72] BAB[73] BAB[74] BAB[75]
+   BAB[76] BAB[77] BAB[78] BAB[79] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28]
+   BAT[29] BAT[30] BAT[31] BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37]
+   BAT[38] BAT[39] BAT[40] BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46]
+   BAT[47] BAT[48] BAT[49] BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55]
+   BAT[56] BAT[57] BAT[58] BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64]
+   BAT[65] BAT[66] BAT[67] BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73]
+   BAT[74] BAT[75] BAT[76] BAT[77] BAT[78] BAT[79] DMY_EDGE_T2[0]
+   DMY_EDGE_T2[1] REF_LLSB_H LOG0 LOG1 QT[24] QT[25] QT[26] QT[27] QT[28]
+   QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38] QT[39]
+   QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49] QT[50]
+   QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60] QT[61]
+   QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70] QT[71] QT[72]
+   QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] RBL[24] RBL[25] RBL[26]
+   RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33] RBL[34] RBL[35]
+   RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42] RBL[43] RBL[44]
+   RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51] RBL[52] RBL[53]
+   RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60] RBL[61] RBL[62]
+   RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69] RBL[70] RBL[71]
+   RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78] RBL[79] LOG0 LOG0
+   LOG0 LOG0 VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+   VBN[17] VBN[18] VBN[19] VBN[20] VBN[21] VBN[22] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20]
+   VBP[21] VBP[22] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+   VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22]
+   VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1
+   VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1
+   VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1
+   VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDAI_SACR1 VDDP[9] VDDP[10]
+   VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDP[21] VDDP[22] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18]
+   VDDPI[19] VDDPI[20] VDDPI[21] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14]
+   VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS[21] VSS[22]
+   SNPS_RF_DP_UHD_512x80_ref_rt_log0_case
X_ref_rt_rep_seg2 BAB[80] BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86]
+   BAB[87] BAB[88] BAB[89] BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95]
+   BAB[96] BAB[97] BAB[98] BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104]
+   BAB[105] BAB[106] BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112]
+   BAB[113] BAB[114] BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120]
+   BAB[121] BAB[122] BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128]
+   BAB[129] BAB[130] BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136]
+   BAB[137] BAB[138] BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144]
+   BAB[145] BAB[146] BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152]
+   BAB[153] BAB[154] BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[80]
+   BAT[81] BAT[82] BAT[83] BAT[84] BAT[85] BAT[86] BAT[87] BAT[88] BAT[89]
+   BAT[90] BAT[91] BAT[92] BAT[93] BAT[94] BAT[95] BAT[96] BAT[97] BAT[98]
+   BAT[99] BAT[100] BAT[101] BAT[102] BAT[103] BAT[104] BAT[105] BAT[106]
+   BAT[107] BAT[108] BAT[109] BAT[110] BAT[111] BAT[112] BAT[113] BAT[114]
+   BAT[115] BAT[116] BAT[117] BAT[118] BAT[119] BAT[120] BAT[121] BAT[122]
+   BAT[123] BAT[124] BAT[125] BAT[126] BAT[127] BAT[128] BAT[129] BAT[130]
+   BAT[131] BAT[132] BAT[133] BAT[134] BAT[135] BAT[136] BAT[137] BAT[138]
+   BAT[139] BAT[140] BAT[141] BAT[142] BAT[143] BAT[144] BAT[145] BAT[146]
+   BAT[147] BAT[148] BAT[149] BAT[150] BAT[151] BAT[152] BAT[153] BAT[154]
+   BAT[155] BAT[156] BAT[157] BAT[158] BAT[159] DMY_EDGE_LB[1] DMY_EDGE_RB[0]
+   DMY_EDGE_T2_R_REBUF DMY_EDGE_T2[2] LCGTV[1] LOG0 LOG1 QT[80] QT[81] QT[82]
+   QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91] QT[92] QT[93]
+   QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101] QT[102] QT[103]
+   QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110] QT[111] QT[112]
+   QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119] QT[120] QT[121]
+   QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128] QT[129] QT[130]
+   QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137] QT[138] QT[139]
+   QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146] QT[147] QT[148]
+   QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155] QT[156] QT[157]
+   QT[158] QT[159] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86]
+   RBL[87] RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95]
+   RBL[96] RBL[97] RBL[98] RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104]
+   RBL[105] RBL[106] RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112]
+   RBL[113] RBL[114] RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120]
+   RBL[121] RBL[122] RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128]
+   RBL[129] RBL[130] RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136]
+   RBL[137] RBL[138] RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144]
+   RBL[145] RBL[146] RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152]
+   RBL[153] RBL[154] RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] REF_LLSB_H
+   RELLSB LOG0 LOG0 LOG0 LOG0 VBN[23] VBN[24] VBN[25] VBN[26] VBN[27] VBN[28]
+   VBN[29] VBN[30] VBN[31] VBN[32] VBN[33] VBN[34] VBN[35] VBN[36] VBN[37]
+   VBN[38] VBN[39] VBN[40] VBN[41] VBN[42] VBN[43] VBP[23] VBP[24] VBP[25]
+   VBP[26] VBP[27] VBP[28] VBP[29] VBP[30] VBP[31] VBP[32] VBP[33] VBP[34]
+   VBP[35] VBP[36] VBP[37] VBP[38] VBP[39] VBP[40] VBP[41] VBP[42] VBP[43]
+   VDDA[23] VDDA[24] VDDA[25] VDDA[26] VDDA[27] VDDA[28] VDDA[29] VDDA[30]
+   VDDA[31] VDDA[32] VDDA[33] VDDA[34] VDDA[35] VDDA[36] VDDA[37] VDDA[38]
+   VDDA[39] VDDA[40] VDDA[41] VDDA[42] VDDA[43] VDDAIR2 VDDAI_SACR2 VDDP[23]
+   VDDP[24] VDDP[25] VDDP[26] VDDP[27] VDDP[28] VDDP[29] VDDP[30] VDDP[31]
+   VDDP[32] VDDP[33] VDDP[34] VDDP[35] VDDP[36] VDDP[37] VDDP[38] VDDP[39]
+   VDDP[40] VDDP[41] VDDP[42] VDDP[43] VDDPI[22] VDDPI[23] VDDPI[24] VDDPI[25]
+   VDDPI[26] VDDPI[27] VDDPI[28] VDDPI[29] VDDPI[30] VDDPI[31] VDDPI[32]
+   VDDPI[33] VDDPI[34] VDDPI[35] VDDPI[36] VDDPI[37] VDDPI[38] VDDPI[39]
+   VDDPI[40] VDDPI[41] VDDPI[42] VDDWL_RD_REBUF VDDWL_WR_REBUF VSS[23] VSS[24]
+   VSS[25] VSS[26] VSS[27] VSS[28] VSS[29] VSS[30] VSS[31] VSS[32] VSS[33]
+   VSS[34] VSS[35] VSS[36] VSS[37] VSS[38] VSS[39] VSS[40] VSS[41] VSS[42]
+   VSS[43] WL_VSS SNPS_RF_DP_UHD_512x80_ref_rt_rep_seg2
X_mm17a04_u_hdrf2p_pg_pwedge VDDA[44] VDDP[44] VDDPI[43] VSS[44] VBP[44] VBN[44]
+   DMY_EDGE_RB[1] DMY_EDGE_T2[2] LOG0 LOG1 VEDGE PGIOI
+   mm17a04_u_hdrf2p_pg_pwedge
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_ref_row_1 ARYSD BAB[0] BAB[1] BAB[2] BAB[3] BAB[4]
+       BAB[5] BAB[6] BAB[7] BAB[8] BAB[9] BAB[10] BAB[11] BAB[12] BAB[13]
+       BAB[14] BAB[15] BAB[16] BAB[17] BAB[18] BAB[19] BAB[20] BAB[21] BAB[22]
+       BAB[23] BAB[24] BAB[25] BAB[26] BAB[27] BAB[28] BAB[29] BAB[30] BAB[31]
+       BAB[32] BAB[33] BAB[34] BAB[35] BAB[36] BAB[37] BAB[38] BAB[39] BAB[40]
+       BAB[41] BAB[42] BAB[43] BAB[44] BAB[45] BAB[46] BAB[47] BAB[48] BAB[49]
+       BAB[50] BAB[51] BAB[52] BAB[53] BAB[54] BAB[55] BAB[56] BAB[57] BAB[58]
+       BAB[59] BAB[60] BAB[61] BAB[62] BAB[63] BAB[64] BAB[65] BAB[66] BAB[67]
+       BAB[68] BAB[69] BAB[70] BAB[71] BAB[72] BAB[73] BAB[74] BAB[75] BAB[76]
+       BAB[77] BAB[78] BAB[79] BAB[80] BAB[81] BAB[82] BAB[83] BAB[84] BAB[85]
+       BAB[86] BAB[87] BAB[88] BAB[89] BAB[90] BAB[91] BAB[92] BAB[93] BAB[94]
+       BAB[95] BAB[96] BAB[97] BAB[98] BAB[99] BAB[100] BAB[101] BAB[102]
+       BAB[103] BAB[104] BAB[105] BAB[106] BAB[107] BAB[108] BAB[109] BAB[110]
+       BAB[111] BAB[112] BAB[113] BAB[114] BAB[115] BAB[116] BAB[117] BAB[118]
+       BAB[119] BAB[120] BAB[121] BAB[122] BAB[123] BAB[124] BAB[125] BAB[126]
+       BAB[127] BAB[128] BAB[129] BAB[130] BAB[131] BAB[132] BAB[133] BAB[134]
+       BAB[135] BAB[136] BAB[137] BAB[138] BAB[139] BAB[140] BAB[141] BAB[142]
+       BAB[143] BAB[144] BAB[145] BAB[146] BAB[147] BAB[148] BAB[149] BAB[150]
+       BAB[151] BAB[152] BAB[153] BAB[154] BAB[155] BAB[156] BAB[157] BAB[158]
+       BAB[159] BAT[0] BAT[1] BAT[2] BAT[3] BAT[4] BAT[5] BAT[6] BAT[7] BAT[8]
+       BAT[9] BAT[10] BAT[11] BAT[12] BAT[13] BAT[14] BAT[15] BAT[16] BAT[17]
+       BAT[18] BAT[19] BAT[20] BAT[21] BAT[22] BAT[23] BAT[24] BAT[25] BAT[26]
+       BAT[27] BAT[28] BAT[29] BAT[30] BAT[31] BAT[32] BAT[33] BAT[34] BAT[35]
+       BAT[36] BAT[37] BAT[38] BAT[39] BAT[40] BAT[41] BAT[42] BAT[43] BAT[44]
+       BAT[45] BAT[46] BAT[47] BAT[48] BAT[49] BAT[50] BAT[51] BAT[52] BAT[53]
+       BAT[54] BAT[55] BAT[56] BAT[57] BAT[58] BAT[59] BAT[60] BAT[61] BAT[62]
+       BAT[63] BAT[64] BAT[65] BAT[66] BAT[67] BAT[68] BAT[69] BAT[70] BAT[71]
+       BAT[72] BAT[73] BAT[74] BAT[75] BAT[76] BAT[77] BAT[78] BAT[79] BAT[80]
+       BAT[81] BAT[82] BAT[83] BAT[84] BAT[85] BAT[86] BAT[87] BAT[88] BAT[89]
+       BAT[90] BAT[91] BAT[92] BAT[93] BAT[94] BAT[95] BAT[96] BAT[97] BAT[98]
+       BAT[99] BAT[100] BAT[101] BAT[102] BAT[103] BAT[104] BAT[105] BAT[106]
+       BAT[107] BAT[108] BAT[109] BAT[110] BAT[111] BAT[112] BAT[113] BAT[114]
+       BAT[115] BAT[116] BAT[117] BAT[118] BAT[119] BAT[120] BAT[121] BAT[122]
+       BAT[123] BAT[124] BAT[125] BAT[126] BAT[127] BAT[128] BAT[129] BAT[130]
+       BAT[131] BAT[132] BAT[133] BAT[134] BAT[135] BAT[136] BAT[137] BAT[138]
+       BAT[139] BAT[140] BAT[141] BAT[142] BAT[143] BAT[144] BAT[145] BAT[146]
+       BAT[147] BAT[148] BAT[149] BAT[150] BAT[151] BAT[152] BAT[153] BAT[154]
+       BAT[155] BAT[156] BAT[157] BAT[158] BAT[159] CENDP DEF1_RD DEF1_WR
+       DMY_EDGE_LB[0] DMY_EDGE_LB[1] DMY_EDGE_RB[0] DMY_EDGE_RB[1] FAST1_RD
+       FAST1_WR FAST2_RD FAST2_WR LCGTL LCGTV[0] LCGTV[1] LOG0 LOG1 LRWMEB
+       PGIOI QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10]
+       QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17] QT[18] QT[19] QT[20]
+       QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28] QT[29] QT[30]
+       QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38] QT[39] QT[40]
+       QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49] QT[50]
+       QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60]
+       QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70]
+       QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+       QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90]
+       QT[91] QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100]
+       QT[101] QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109]
+       QT[110] QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118]
+       QT[119] QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127]
+       QT[128] QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136]
+       QT[137] QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145]
+       QT[146] QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154]
+       QT[155] QT[156] QT[157] QT[158] QT[159] RBL[0] RBL[1] RBL[2] RBL[3]
+       RBL[4] RBL[5] RBL[6] RBL[7] RBL[8] RBL[9] RBL[10] RBL[11] RBL[12]
+       RBL[13] RBL[14] RBL[15] RBL[16] RBL[17] RBL[18] RBL[19] RBL[20] RBL[21]
+       RBL[22] RBL[23] RBL[24] RBL[25] RBL[26] RBL[27] RBL[28] RBL[29] RBL[30]
+       RBL[31] RBL[32] RBL[33] RBL[34] RBL[35] RBL[36] RBL[37] RBL[38] RBL[39]
+       RBL[40] RBL[41] RBL[42] RBL[43] RBL[44] RBL[45] RBL[46] RBL[47] RBL[48]
+       RBL[49] RBL[50] RBL[51] RBL[52] RBL[53] RBL[54] RBL[55] RBL[56] RBL[57]
+       RBL[58] RBL[59] RBL[60] RBL[61] RBL[62] RBL[63] RBL[64] RBL[65] RBL[66]
+       RBL[67] RBL[68] RBL[69] RBL[70] RBL[71] RBL[72] RBL[73] RBL[74] RBL[75]
+       RBL[76] RBL[77] RBL[78] RBL[79] RBL[80] RBL[81] RBL[82] RBL[83] RBL[84]
+       RBL[85] RBL[86] RBL[87] RBL[88] RBL[89] RBL[90] RBL[91] RBL[92] RBL[93]
+       RBL[94] RBL[95] RBL[96] RBL[97] RBL[98] RBL[99] RBL[100] RBL[101]
+       RBL[102] RBL[103] RBL[104] RBL[105] RBL[106] RBL[107] RBL[108] RBL[109]
+       RBL[110] RBL[111] RBL[112] RBL[113] RBL[114] RBL[115] RBL[116] RBL[117]
+       RBL[118] RBL[119] RBL[120] RBL[121] RBL[122] RBL[123] RBL[124] RBL[125]
+       RBL[126] RBL[127] RBL[128] RBL[129] RBL[130] RBL[131] RBL[132] RBL[133]
+       RBL[134] RBL[135] RBL[136] RBL[137] RBL[138] RBL[139] RBL[140] RBL[141]
+       RBL[142] RBL[143] RBL[144] RBL[145] RBL[146] RBL[147] RBL[148] RBL[149]
+       RBL[150] RBL[151] RBL[152] RBL[153] RBL[154] RBL[155] RBL[156] RBL[157]
+       RBL[158] RBL[159] RBLWA RDBL RFLOAT RM3CNT RMTRD[0] RMTRD[1] RMTRD[2]
+       RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_INT_WR RWLB_RD RWLB_WR
+       RWLDRD_PASS RWLRD_INT RWLRD_PROG RWL_PROG T1TRD T1TWR VBN VBP VDDA
+       VDDAIR1 VDDAIR2 VDDAI_SACR1 VDDAI_SACR2 VDDAPI VDDF VDDP VDDPI VDDWL_RD
+       VDDWL_RD_REBUF VDDWL_WR VDDWL_WR_REBUF VEDGE VSS VSSWL WDBL WFLOAT
+       WL_VSS
X_ref_row ARYSD BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   CENDP DEF1_RD DEF1_WR DMY_EDGE_LB[0] DMY_EDGE_LB[1] DMY_EDGE_RB[0]
+   DMY_EDGE_RB[1] FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL LCGTV[0] LCGTV[1]
+   LOG0 LOG1 LRWMEB PGIOI QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8]
+   QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17] QT[18] QT[19]
+   QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28] QT[29] QT[30]
+   QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38] QT[39] QT[40] QT[41]
+   QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49] QT[50] QT[51] QT[52]
+   QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60] QT[61] QT[62] QT[63]
+   QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70] QT[71] QT[72] QT[73] QT[74]
+   QT[75] QT[76] QT[77] QT[78] QT[79] QT[80] QT[81] QT[82] QT[83] QT[84] QT[85]
+   QT[86] QT[87] QT[88] QT[89] QT[90] QT[91] QT[92] QT[93] QT[94] QT[95] QT[96]
+   QT[97] QT[98] QT[99] QT[100] QT[101] QT[102] QT[103] QT[104] QT[105] QT[106]
+   QT[107] QT[108] QT[109] QT[110] QT[111] QT[112] QT[113] QT[114] QT[115]
+   QT[116] QT[117] QT[118] QT[119] QT[120] QT[121] QT[122] QT[123] QT[124]
+   QT[125] QT[126] QT[127] QT[128] QT[129] QT[130] QT[131] QT[132] QT[133]
+   QT[134] QT[135] QT[136] QT[137] QT[138] QT[139] QT[140] QT[141] QT[142]
+   QT[143] QT[144] QT[145] QT[146] QT[147] QT[148] QT[149] QT[150] QT[151]
+   QT[152] QT[153] QT[154] QT[155] QT[156] QT[157] QT[158] QT[159] RBL[0]
+   RBL[1] RBL[2] RBL[3] RBL[4] RBL[5] RBL[6] RBL[7] RBL[8] RBL[9] RBL[10]
+   RBL[11] RBL[12] RBL[13] RBL[14] RBL[15] RBL[16] RBL[17] RBL[18] RBL[19]
+   RBL[20] RBL[21] RBL[22] RBL[23] RBL[24] RBL[25] RBL[26] RBL[27] RBL[28]
+   RBL[29] RBL[30] RBL[31] RBL[32] RBL[33] RBL[34] RBL[35] RBL[36] RBL[37]
+   RBL[38] RBL[39] RBL[40] RBL[41] RBL[42] RBL[43] RBL[44] RBL[45] RBL[46]
+   RBL[47] RBL[48] RBL[49] RBL[50] RBL[51] RBL[52] RBL[53] RBL[54] RBL[55]
+   RBL[56] RBL[57] RBL[58] RBL[59] RBL[60] RBL[61] RBL[62] RBL[63] RBL[64]
+   RBL[65] RBL[66] RBL[67] RBL[68] RBL[69] RBL[70] RBL[71] RBL[72] RBL[73]
+   RBL[74] RBL[75] RBL[76] RBL[77] RBL[78] RBL[79] RBL[80] RBL[81] RBL[82]
+   RBL[83] RBL[84] RBL[85] RBL[86] RBL[87] RBL[88] RBL[89] RBL[90] RBL[91]
+   RBL[92] RBL[93] RBL[94] RBL[95] RBL[96] RBL[97] RBL[98] RBL[99] RBL[100]
+   RBL[101] RBL[102] RBL[103] RBL[104] RBL[105] RBL[106] RBL[107] RBL[108]
+   RBL[109] RBL[110] RBL[111] RBL[112] RBL[113] RBL[114] RBL[115] RBL[116]
+   RBL[117] RBL[118] RBL[119] RBL[120] RBL[121] RBL[122] RBL[123] RBL[124]
+   RBL[125] RBL[126] RBL[127] RBL[128] RBL[129] RBL[130] RBL[131] RBL[132]
+   RBL[133] RBL[134] RBL[135] RBL[136] RBL[137] RBL[138] RBL[139] RBL[140]
+   RBL[141] RBL[142] RBL[143] RBL[144] RBL[145] RBL[146] RBL[147] RBL[148]
+   RBL[149] RBL[150] RBL[151] RBL[152] RBL[153] RBL[154] RBL[155] RBL[156]
+   RBL[157] RBL[158] RBL[159] RBLWA RDBL RFLOAT RM3CNT RMTRD[0] RMTRD[1]
+   RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_INT_WR RWLB_RD
+   RWLB_WR RWLDRD_PASS RWLRD_INT RWLRD_PROG RWL_PROG T1TRD T1TWR VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDAIR1 VDDAIR2 VDDAI_SACR1
+   VDDAI_SACR2 VDDAPI VDDF VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDWL_RD VDDWL_RD_REBUF VDDWL_WR VDDWL_WR_REBUF VEDGE VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSSWL WDBL WFLOAT WL_VSS SNPS_RF_DP_UHD_512x80_ref_row
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_top ARYSD CLKRD CLKWR D[0] D[1] D[2] D[3] D[4]
+       D[5] D[6] D[7] D[8] D[9] D[10] D[11] D[12] D[13] D[14] D[15] D[16] D[17]
+       D[18] D[19] D[20] D[21] D[22] D[23] D[24] D[25] D[26] D[27] D[28] D[29]
+       D[30] D[31] D[32] D[33] D[34] D[35] D[36] D[37] D[38] D[39] D[40] D[41]
+       D[42] D[43] D[44] D[45] D[46] D[47] D[48] D[49] D[50] D[51] D[52] D[53]
+       D[54] D[55] D[56] D[57] D[58] D[59] D[60] D[61] D[62] D[63] D[64] D[65]
+       D[66] D[67] D[68] D[69] D[70] D[71] D[72] D[73] D[74] D[75] D[76] D[77]
+       D[78] D[79] DS FISO LOG0 LOG1 LS MERD MEWR PROCOM[0] PROCOM[1] Q[0] Q[1]
+       Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13] Q[14]
+       Q[15] Q[16] Q[17] Q[18] Q[19] Q[20] Q[21] Q[22] Q[23] Q[24] Q[25] Q[26]
+       Q[27] Q[28] Q[29] Q[30] Q[31] Q[32] Q[33] Q[34] Q[35] Q[36] Q[37] Q[38]
+       Q[39] Q[40] Q[41] Q[42] Q[43] Q[44] Q[45] Q[46] Q[47] Q[48] Q[49] Q[50]
+       Q[51] Q[52] Q[53] Q[54] Q[55] Q[56] Q[57] Q[58] Q[59] Q[60] Q[61] Q[62]
+       Q[63] Q[64] Q[65] Q[66] Q[67] Q[68] Q[69] Q[70] Q[71] Q[72] Q[73] Q[74]
+       Q[75] Q[76] Q[77] Q[78] Q[79] RA[0] RA[1] RMERD RMEWR RMRD[0] RMRD[1]
+       RMRD[2] RMRD[3] RMWR[0] RMWR[1] RMWR[2] RMWR[3] ROP TEST1RD TEST1WR
+       TEST_RNM VBN VBP VDDA VDDP VDDPI VSS WA[0] WA[1] WE WEM[0] WEM[1] WEM[2]
+       WEM[3] WEM[4] WEM[5] WEM[6] WEM[7] WEM[8] WEM[9] WEM[10] WEM[11] WEM[12]
+       WEM[13] WEM[14] WEM[15] WEM[16] WEM[17] WEM[18] WEM[19] WEM[20] WEM[21]
+       WEM[22] WEM[23] WEM[24] WEM[25] WEM[26] WEM[27] WEM[28] WEM[29] WEM[30]
+       WEM[31] WEM[32] WEM[33] WEM[34] WEM[35] WEM[36] WEM[37] WEM[38] WEM[39]
+       WEM[40] WEM[41] WEM[42] WEM[43] WEM[44] WEM[45] WEM[46] WEM[47] WEM[48]
+       WEM[49] WEM[50] WEM[51] WEM[52] WEM[53] WEM[54] WEM[55] WEM[56] WEM[57]
+       WEM[58] WEM[59] WEM[60] WEM[61] WEM[62] WEM[63] WEM[64] WEM[65] WEM[66]
+       WEM[67] WEM[68] WEM[69] WEM[70] WEM[71] WEM[72] WEM[73] WEM[74] WEM[75]
+       WEM[76] WEM[77] WEM[78] WEM[79] WP[0] WP[1] WP[2] XADRRD[0] XADRRD[1]
+       XADRRD[2] XADRRD[3] XADRRD[4] XADRRD[5] XADRRD[6] XADRRD[7] XADRWR[0]
+       XADRWR[1] XADRWR[2] XADRWR[3] XADRWR[4] XADRWR[5] XADRWR[6] XADRWR[7]
+       YADRRD[0] YADRRD[1] YADRWR[0] YADRWR[1]

*** Jumper Report ***
* Jumper: LOG0 DS FISO PROCOM[0] RA[0] RA[1] XADRRD[3] XADRWR[3] YADRRD[1] YADRWR[1]
* Jumper: LOG1 PROCOM[1]

*X_pin_row ARYSD CLKRD CLKWR D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] D[8] D[9]
*+  D[10] D[11] D[12] D[13] D[14] D[15] D[16] D[17] D[18] D[19] D[20] D[21]
*+  D[22] D[23] D[24] D[25] D[26] D[27] D[28] D[29] D[30] D[31] D[32] D[33]
*+  D[34] D[35] D[36] D[37] D[38] D[39] D[40] D[41] D[42] D[43] D[44] D[45]
*+  D[46] D[47] D[48] D[49] D[50] D[51] D[52] D[53] D[54] D[55] D[56] D[57]
*+  D[58] D[59] D[60] D[61] D[62] D[63] D[64] D[65] D[66] D[67] D[68] D[69]
*+  D[70] D[71] D[72] D[73] D[74] D[75] D[76] D[77] D[78] D[79] DS FISO LOG0
*+  LOG0 LOG1 LOG1 LS MERD MEWR PROCOM[0] PROCOM[1] Q[0] Q[1] Q[2] Q[3] Q[4]
*+  Q[5] Q[6] Q[7] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13] Q[14] Q[15] Q[16] Q[17]
*+  Q[18] Q[19] Q[20] Q[21] Q[22] Q[23] Q[24] Q[25] Q[26] Q[27] Q[28] Q[29]
*+  Q[30] Q[31] Q[32] Q[33] Q[34] Q[35] Q[36] Q[37] Q[38] Q[39] Q[40] Q[41]
*+  Q[42] Q[43] Q[44] Q[45] Q[46] Q[47] Q[48] Q[49] Q[50] Q[51] Q[52] Q[53]
*+  Q[54] Q[55] Q[56] Q[57] Q[58] Q[59] Q[60] Q[61] Q[62] Q[63] Q[64] Q[65]
*+  Q[66] Q[67] Q[68] Q[69] Q[70] Q[71] Q[72] Q[73] Q[74] Q[75] Q[76] Q[77]
*+  Q[78] Q[79] RA[0] RA[1] RMERD RMEWR RMRD[0] RMRD[1] RMRD[2] RMRD[3] RMWR[0]
*+  RMWR[1] RMWR[2] RMWR[3] ROP LOG0 LOG0 LOG0 LOG0 LOG0 TEST1RD TEST1WR
*+  TEST_RNM VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
*+  VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
*+  VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
*+  VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
*+  VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBP VBP VBP VBP VBP VBP VBP VBP VBP
*+  VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
*+  VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
*+  VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
*+  VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VDDA
*+  VDDA VDDA VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
*+  VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
*+  VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
*+  VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
*+  VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
*+  VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDPI VDDPI VDDPI
*+  VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
*+  VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
*+  VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
*+  VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
*+  VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
*+  VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
*+  VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VSS VSS VSS VSS VSS VSS VSS
*+  VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
*+  VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
*+  VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
*+  VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
*+  VSS WA[0] WA[1] WE WEM[0] WEM[1] WEM[2] WEM[3] WEM[4] WEM[5] WEM[6] WEM[7]
*+  WEM[8] WEM[9] WEM[10] WEM[11] WEM[12] WEM[13] WEM[14] WEM[15] WEM[16]
*+  WEM[17] WEM[18] WEM[19] WEM[20] WEM[21] WEM[22] WEM[23] WEM[24] WEM[25]
*+  WEM[26] WEM[27] WEM[28] WEM[29] WEM[30] WEM[31] WEM[32] WEM[33] WEM[34]
*+  WEM[35] WEM[36] WEM[37] WEM[38] WEM[39] WEM[40] WEM[41] WEM[42] WEM[43]
*+  WEM[44] WEM[45] WEM[46] WEM[47] WEM[48] WEM[49] WEM[50] WEM[51] WEM[52]
*+  WEM[53] WEM[54] WEM[55] WEM[56] WEM[57] WEM[58] WEM[59] WEM[60] WEM[61]
*+  WEM[62] WEM[63] WEM[64] WEM[65] WEM[66] WEM[67] WEM[68] WEM[69] WEM[70]
*+  WEM[71] WEM[72] WEM[73] WEM[74] WEM[75] WEM[76] WEM[77] WEM[78] WEM[79]
*+  WP[0] WP[1] WP[2] XADRRD[0] XADRRD[1] XADRRD[2] XADRRD[3] XADRRD[4]
*+  XADRRD[5] XADRRD[6] XADRRD[7] XADRWR[0] XADRWR[1] XADRWR[2] XADRWR[3]
*+  XADRWR[4] XADRWR[5] XADRWR[6] XADRWR[7] YADRRD[0] YADRRD[1] YADRWR[0]
*+  YADRWR[1] SNPS_RF_DP_UHD_512x80_pin_row
X_gio_row ARYSD CB[0] CB[1] CB[2] CB[3] CB[4] CB[5] CB[6] CB[7] CB[8] CB[9]
+   CB[10] CB[11] CB[12] CB[13] CB[14] CB[15] CB[16] CB[17] CB[18] CB[19] CB[20]
+   CB[21] CB[22] CB[23] CB[24] CB[25] CB[26] CB[27] CB[28] CB[29] CB[30] CB[31]
+   CB[32] CB[33] CB[34] CB[35] CB[36] CB[37] CB[38] CB[39] LOG0 CKGATE_RD CLKRD
+   CLKWR CT[0] CT[1] CT[2] CT[3] CT[4] CT[5] CT[6] CT[7] CT[8] CT[9] CT[10]
+   CT[11] CT[12] CT[13] CT[14] CT[15] CT[16] CT[17] CT[18] CT[19] CT[20] CT[21]
+   CT[22] CT[23] CT[24] CT[25] CT[26] CT[27] CT[28] CT[29] CT[30] CT[31] CT[32]
+   CT[33] CT[34] CT[35] CT[36] CT[37] CT[38] CT[39] D[0] D[1] D[2] D[3] D[4]
+   D[5] D[6] D[7] D[8] D[9] D[10] D[11] D[12] D[13] D[14] D[15] D[16] D[17]
+   D[18] D[19] D[20] D[21] D[22] D[23] D[24] D[25] D[26] D[27] D[28] D[29]
+   D[30] D[31] D[32] D[33] D[34] D[35] D[36] D[37] D[38] D[39] D[40] D[41]
+   D[42] D[43] D[44] D[45] D[46] D[47] D[48] D[49] D[50] D[51] D[52] D[53]
+   D[54] D[55] D[56] D[57] D[58] D[59] D[60] D[61] D[62] D[63] D[64] D[65]
+   D[66] D[67] D[68] D[69] D[70] D[71] D[72] D[73] D[74] D[75] D[76] D[77]
+   D[78] D[79] DEF1_RD DEF1_WR LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0
+   LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0
+   LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0
+   LOG0 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1
+   LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1
+   LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG0 LOG0 LOG0 LOG0
+   DIB_LT[0] DIB_LT[1] DIB_LT[2] DIB_LT[3] DIB_LT[4] DIB_LT[5] DIB_LT[6]
+   DIB_LT[7] DIB_LT[8] DIB_LT[9] DIB_LT[10] DIB_LT[11] DIB_LT[12] DIB_LT[13]
+   DIB_LT[14] DIB_LT[15] DIB_LT[16] DIB_LT[17] DIB_LT[18] DIB_LT[19] DIB_LT[20]
+   DIB_LT[21] DIB_LT[22] DIB_LT[23] DIB_LT[24] DIB_LT[25] DIB_LT[26] DIB_LT[27]
+   DIB_LT[28] DIB_LT[29] DIB_LT[30] DIB_LT[31] DIB_LT[32] DIB_LT[33] DIB_LT[34]
+   DIB_LT[35] DIB_LT[36] DIB_LT[37] DIB_LT[38] DIB_LT[39] DIB_LT[40] DIB_LT[41]
+   DIB_LT[42] DIB_LT[43] DIB_LT[44] DIB_LT[45] DIB_LT[46] DIB_LT[47] DIB_LT[48]
+   DIB_LT[49] DIB_LT[50] DIB_LT[51] DIB_LT[52] DIB_LT[53] DIB_LT[54] DIB_LT[55]
+   DIB_LT[56] DIB_LT[57] DIB_LT[58] DIB_LT[59] DIB_LT[60] DIB_LT[61] DIB_LT[62]
+   DIB_LT[63] DIB_LT[64] DIB_LT[65] DIB_LT[66] DIB_LT[67] DIB_LT[68] DIB_LT[69]
+   DIB_LT[70] DIB_LT[71] DIB_LT[72] DIB_LT[73] DIB_LT[74] DIB_LT[75] DIB_LT[76]
+   DIB_LT[77] DIB_LT[78] DIB_LT[79] DINB[0] DINB[1] DINB[2] DINB[3] DINB[4]
+   DINB[5] DINB[6] DINB[7] DINB[8] DINB[9] DINB[10] DINB[11] DINB[12] DINB[13]
+   DINB[14] DINB[15] DINB[16] DINB[17] DINB[18] DINB[19] DINB[20] DINB[21]
+   DINB[22] DINB[23] DINB[24] DINB[25] DINB[26] DINB[27] DINB[28] DINB[29]
+   DINB[30] DINB[31] DINB[32] DINB[33] DINB[34] DINB[35] DINB[36] DINB[37]
+   DINB[38] DINB[39] DINB[40] DINB[41] DINB[42] DINB[43] DINB[44] DINB[45]
+   DINB[46] DINB[47] DINB[48] DINB[49] DINB[50] DINB[51] DINB[52] DINB[53]
+   DINB[54] DINB[55] DINB[56] DINB[57] DINB[58] DINB[59] DINB[60] DINB[61]
+   DINB[62] DINB[63] DINB[64] DINB[65] DINB[66] DINB[67] DINB[68] DINB[69]
+   DINB[70] DINB[71] DINB[72] DINB[73] DINB[74] DINB[75] DINB[76] DINB[77]
+   DINB[78] DINB[79] LOG1 LOG0 LOG0 FAST1_RD FAST1_WR FAST2_RD FAST2_WR FISO
+   LCLKRDB LCLKRDT LCLKWRB LCLKWRT LDIB[0] LDIB[1] LDIB[2] LDIB[3] LDIB[4]
+   LDIB[5] LDIB[6] LDIB[7] LDIB[8] LDIB[9] LDIB[10] LDIB[11] LDIB[12] LDIB[13]
+   LDIB[14] LDIB[15] LDIB[16] LDIB[17] LDIB[18] LDIB[19] LDIB[20] LDIB[21]
+   LDIB[22] LDIB[23] LDIB[24] LDIB[25] LDIB[26] LDIB[27] LDIB[28] LDIB[29]
+   LDIB[30] LDIB[31] LDIB[32] LDIB[33] LDIB[34] LDIB[35] LDIB[36] LDIB[37]
+   LDIB[38] LDIB[39] LDIB[40] LDIB[41] LDIB[42] LDIB[43] LDIB[44] LDIB[45]
+   LDIB[46] LDIB[47] LDIB[48] LDIB[49] LDIB[50] LDIB[51] LDIB[52] LDIB[53]
+   LDIB[54] LDIB[55] LDIB[56] LDIB[57] LDIB[58] LDIB[59] LDIB[60] LDIB[61]
+   LDIB[62] LDIB[63] LDIB[64] LDIB[65] LDIB[66] LDIB[67] LDIB[68] LDIB[69]
+   LDIB[70] LDIB[71] LDIB[72] LDIB[73] LDIB[74] LDIB[75] LDIB[76] LDIB[77]
+   LDIB[78] LDIB[79] LITESLP LMERD LMEWR LOG1 LOG1 LOG0 LOG1 LOG1RMRD_VDDPI
+   LOG1RMWR_VDDPI LOG1RMRD_VDDPI LOG1RMWR_VDDPI LQB[0] LQB[1] LQB[2] LQB[3]
+   LQB[4] LQB[5] LQB[6] LQB[7] LQB[8] LQB[9] LQB[10] LQB[11] LQB[12] LQB[13]
+   LQB[14] LQB[15] LQB[16] LQB[17] LQB[18] LQB[19] LQB[20] LQB[21] LQB[22]
+   LQB[23] LQB[24] LQB[25] LQB[26] LQB[27] LQB[28] LQB[29] LQB[30] LQB[31]
+   LQB[32] LQB[33] LQB[34] LQB[35] LQB[36] LQB[37] LQB[38] LQB[39] LQB[40]
+   LQB[41] LQB[42] LQB[43] LQB[44] LQB[45] LQB[46] LQB[47] LQB[48] LQB[49]
+   LQB[50] LQB[51] LQB[52] LQB[53] LQB[54] LQB[55] LQB[56] LQB[57] LQB[58]
+   LQB[59] LQB[60] LQB[61] LQB[62] LQB[63] LQB[64] LQB[65] LQB[66] LQB[67]
+   LQB[68] LQB[69] LQB[70] LQB[71] LQB[72] LQB[73] LQB[74] LQB[75] LQB[76]
+   LQB[77] LQB[78] LQB[79] LRWMEB LS LWE LXADRBRD_0 LXADRBRD_1 LXADRBRD_2
+   LXADRBRD_3 LXADRBRD_4 LXADRBRD_5 LXADRBRD_6 LXADRBRD_7 LXADRBWR[0]
+   LXADRBWR[1] LXADRBWR[2] LXADRBWR[3] LXADRBWR[4] LXADRBWR[5] LXADRBWR[6]
+   LXADRBWR[7] LXADRRD[0] LXADRRD[1] LXADRRD[2] LXADRRD[3] LXADRRD[4]
+   LXADRRD[5] LXADRRD[6] LXADRRD[7] LXADRWR[0] LXADRWR[1] LXADRWR[2] LXADRWR[3]
+   LXADRWR[4] LXADRWR[5] LXADRWR[6] LXADRWR[7] LYADRBRD[0] LYADRBRD[1]
+   LYADRBWR[0] LYADRBWR[1] LYADRRD[0] LYADRRD[1] LYADRWR[0] LYADRWR[1] MCLKRDB
+   MCLKRDT MCLKWRB MCLKWRT MERD MEWR PROCOM[0] PROCOM[1] PWDO Q[0] Q[1] Q[2]
+   Q[3] Q[4] Q[5] Q[6] Q[7] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13] Q[14] Q[15] Q[16]
+   Q[17] Q[18] Q[19] Q[20] Q[21] Q[22] Q[23] Q[24] Q[25] Q[26] Q[27] Q[28]
+   Q[29] Q[30] Q[31] Q[32] Q[33] Q[34] Q[35] Q[36] Q[37] Q[38] Q[39] Q[40]
+   Q[41] Q[42] Q[43] Q[44] Q[45] Q[46] Q[47] Q[48] Q[49] Q[50] Q[51] Q[52]
+   Q[53] Q[54] Q[55] Q[56] Q[57] Q[58] Q[59] Q[60] Q[61] Q[62] Q[63] Q[64]
+   Q[65] Q[66] Q[67] Q[68] Q[69] Q[70] Q[71] Q[72] Q[73] Q[74] Q[75] Q[76]
+   Q[77] Q[78] Q[79] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8]
+   QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17] QT[18] QT[19]
+   QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28] QT[29] QT[30]
+   QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38] QT[39] QT[40] QT[41]
+   QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49] QT[50] QT[51] QT[52]
+   QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60] QT[61] QT[62] QT[63]
+   QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70] QT[71] QT[72] QT[73] QT[74]
+   QT[75] QT[76] QT[77] QT[78] QT[79] QT[80] QT[81] QT[82] QT[83] QT[84] QT[85]
+   QT[86] QT[87] QT[88] QT[89] QT[90] QT[91] QT[92] QT[93] QT[94] QT[95] QT[96]
+   QT[97] QT[98] QT[99] QT[100] QT[101] QT[102] QT[103] QT[104] QT[105] QT[106]
+   QT[107] QT[108] QT[109] QT[110] QT[111] QT[112] QT[113] QT[114] QT[115]
+   QT[116] QT[117] QT[118] QT[119] QT[120] QT[121] QT[122] QT[123] QT[124]
+   QT[125] QT[126] QT[127] QT[128] QT[129] QT[130] QT[131] QT[132] QT[133]
+   QT[134] QT[135] QT[136] QT[137] QT[138] QT[139] QT[140] QT[141] QT[142]
+   QT[143] QT[144] QT[145] QT[146] QT[147] QT[148] QT[149] QT[150] QT[151]
+   QT[152] QT[153] QT[154] QT[155] QT[156] QT[157] QT[158] QT[159] RA[0] RA[1]
+   RASSB_H[0] RASSB_H[1] RERASSB[0] RERASSB[1] RFLOAT RFLT_RET
+   RMDEF12_RD_PROCOM00[0] RMDEF12_RD_PROCOM00[1] RMDEF12_RD_PROCOM00[2]
+   RMDEF12_RD_PROCOM00[3] RMDEF12_RD_PROCOM01[0] RMDEF12_RD_PROCOM01[1]
+   RMDEF12_RD_PROCOM01[2] RMDEF12_RD_PROCOM01[3] RMDEF12_WR_PROCOM00[0]
+   RMDEF12_WR_PROCOM00[1] RMDEF12_WR_PROCOM00[2] RMDEF12_WR_PROCOM00[3]
+   RMDEF12_WR_PROCOM01[0] RMDEF12_WR_PROCOM01[1] RMDEF12_WR_PROCOM01[2]
+   RMDEF12_WR_PROCOM01[3] RMERD RMEWR RMRD[0] RMRD[1] RMRD[2] RMRD[3] RMTRD[0]
+   RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RMWR[0]
+   RMWR[1] RMWR[2] RMWR[3] LOG0 LOG0 LOG0 LOG0 LOG0 RWLCKB LOG1 LOG0 STRSB
+   T1TRD T1TWR TEST1RD TEST1WR TEST_RNM TKEEPB VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VDDA VDDA VDDA VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VEDGE VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS WA[0] WA[1] WABUF[0] WABUF[1] WABUF[2] WBI[0] WBI[1] WBI[2] WBI[3]
+   WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13]
+   WBI[14] WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22]
+   WBI[23] WBI[24] WBI[25] WBI[26] WBI[27] WBI[28] WBI[29] WBI[30] WBI[31]
+   WBI[32] WBI[33] WBI[34] WBI[35] WBI[36] WBI[37] WBI[38] WBI[39] WBI[40]
+   WBI[41] WBI[42] WBI[43] WBI[44] WBI[45] WBI[46] WBI[47] WBI[48] WBI[49]
+   WBI[50] WBI[51] WBI[52] WBI[53] WBI[54] WBI[55] WBI[56] WBI[57] WBI[58]
+   WBI[59] WBI[60] WBI[61] WBI[62] WBI[63] WBI[64] WBI[65] WBI[66] WBI[67]
+   WBI[68] WBI[69] WBI[70] WBI[71] WBI[72] WBI[73] WBI[74] WBI[75] WBI[76]
+   WBI[77] WBI[78] WBI[79] WE WEM[0] WEM[1] WEM[2] WEM[3] WEM[4] WEM[5] WEM[6]
+   WEM[7] WEM[8] WEM[9] WEM[10] WEM[11] WEM[12] WEM[13] WEM[14] WEM[15] WEM[16]
+   WEM[17] WEM[18] WEM[19] WEM[20] WEM[21] WEM[22] WEM[23] WEM[24] WEM[25]
+   WEM[26] WEM[27] WEM[28] WEM[29] WEM[30] WEM[31] WEM[32] WEM[33] WEM[34]
+   WEM[35] WEM[36] WEM[37] WEM[38] WEM[39] WEM[40] WEM[41] WEM[42] WEM[43]
+   WEM[44] WEM[45] WEM[46] WEM[47] WEM[48] WEM[49] WEM[50] WEM[51] WEM[52]
+   WEM[53] WEM[54] WEM[55] WEM[56] WEM[57] WEM[58] WEM[59] WEM[60] WEM[61]
+   WEM[62] WEM[63] WEM[64] WEM[65] WEM[66] WEM[67] WEM[68] WEM[69] WEM[70]
+   WEM[71] WEM[72] WEM[73] WEM[74] WEM[75] WEM[76] WEM[77] WEM[78] WEM[79]
+   WEMB[0] WEMB[1] WEMB[2] WEMB[3] WEMB[4] WEMB[5] WEMB[6] WEMB[7] WEMB[8]
+   WEMB[9] WEMB[10] WEMB[11] WEMB[12] WEMB[13] WEMB[14] WEMB[15] WEMB[16]
+   WEMB[17] WEMB[18] WEMB[19] WEMB[20] WEMB[21] WEMB[22] WEMB[23] WEMB[24]
+   WEMB[25] WEMB[26] WEMB[27] WEMB[28] WEMB[29] WEMB[30] WEMB[31] WEMB[32]
+   WEMB[33] WEMB[34] WEMB[35] WEMB[36] WEMB[37] WEMB[38] WEMB[39] WEMB[40]
+   WEMB[41] WEMB[42] WEMB[43] WEMB[44] WEMB[45] WEMB[46] WEMB[47] WEMB[48]
+   WEMB[49] WEMB[50] WEMB[51] WEMB[52] WEMB[53] WEMB[54] WEMB[55] WEMB[56]
+   WEMB[57] WEMB[58] WEMB[59] WEMB[60] WEMB[61] WEMB[62] WEMB[63] WEMB[64]
+   WEMB[65] WEMB[66] WEMB[67] WEMB[68] WEMB[69] WEMB[70] WEMB[71] WEMB[72]
+   WEMB[73] WEMB[74] WEMB[75] WEMB[76] WEMB[77] WEMB[78] WEMB[79] WFLOAT
+   WFLT_RET WP[0] WP[1] WP[2] WPBUF[0] WPBUF[1] WPBUF[2] WTI[0] WTI[1] WTI[2]
+   WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12]
+   WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21]
+   WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27] WTI[28] WTI[29] WTI[30]
+   WTI[31] WTI[32] WTI[33] WTI[34] WTI[35] WTI[36] WTI[37] WTI[38] WTI[39]
+   WTI[40] WTI[41] WTI[42] WTI[43] WTI[44] WTI[45] WTI[46] WTI[47] WTI[48]
+   WTI[49] WTI[50] WTI[51] WTI[52] WTI[53] WTI[54] WTI[55] WTI[56] WTI[57]
+   WTI[58] WTI[59] WTI[60] WTI[61] WTI[62] WTI[63] WTI[64] WTI[65] WTI[66]
+   WTI[67] WTI[68] WTI[69] WTI[70] WTI[71] WTI[72] WTI[73] WTI[74] WTI[75]
+   WTI[76] WTI[77] WTI[78] WTI[79] XADRRD[0] XADRRD[1] XADRRD[2] XADRRD[3]
+   XADRRD[4] XADRRD[5] XADRRD[6] XADRRD[7] XADRWR[0] XADRWR[1] XADRWR[2]
+   XADRWR[3] XADRWR[4] XADRWR[5] XADRWR[6] XADRWR[7] YADRRD[0] YADRRD[1]
+   YADRWR[0] YADRWR[1] YCOLRD[0] YCOLRD[1] YCOLRD[2] YCOLRD[3] YSELRD[0]
+   YSELRD[1] YSELRD[2] YSELRD[3] SNPS_RF_DP_UHD_512x80_gio_row
X_was_row ARYSD BADB[0] BADB[1] BADB[2] BADB[3] BADB[4] BADB[5] BADB[6] BADB[7]
+   BADB[8] BADB[9] BADB[10] BADB[11] BADB[12] BADB[13] BADB[14] BADB[15]
+   BADB[16] BADB[17] BADB[18] BADB[19] BADB[20] BADB[21] BADB[22] BADB[23]
+   BADB[24] BADB[25] BADB[26] BADB[27] BADB[28] BADB[29] BADB[30] BADB[31]
+   BADB[32] BADB[33] BADB[34] BADB[35] BADB[36] BADB[37] BADB[38] BADB[39] LOG0
+   CKGATE_RD DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR LOG0 LOG0
+   LITESLP LOG0 LOG1 LRWMEB LXADRBRD_0 LXADRBRD_1 LXADRBRD_2 LXADRBRD_3
+   LXADRBRD_4 LXADRBRD_5 LXADRBRD_6 LXADRBRD_7 LXADRBWR[0] LXADRBWR[1]
+   LXADRBWR[2] LXADRBWR[3] LXADRBWR[4] LXADRBWR[5] LXADRBWR[6] LXADRBWR[7]
+   LXADRRD[0] LXADRRD[1] LXADRRD[2] LXADRRD[3] LXADRRD[4] LXADRRD[5] LXADRRD[6]
+   LXADRRD[7] LXADRWR[0] LXADRWR[1] LXADRWR[2] LXADRWR[3] LXADRWR[4] LXADRWR[5]
+   LXADRWR[6] LXADRWR[7] LYADRBRD[0] LYADRBRD[1] LYADRBWR[0] LYADRBWR[1]
+   LYADRRD[0] LYADRRD[1] LYADRWR[0] LYADRWR[1] PAARD[0] PAARD[1] PAARD[2]
+   PAARD[3] PAAWR[0] PAAWR[1] PAAWR[2] PAAWR[3] PAWR[0] PAWR[1] PAWR[2] PAWR[3]
+   PBRD[0] PBRD[1] PBRD[2] PBRD[3] PBWR[0] PBWR[1] PBWR[2] PBWR[3] PCRD[0]
+   PCRD[1] PCRD[2] PCRD[3] PCWR[0] PCWR[1] PCWR[2] PCWR[3] LOG1 QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13]
+   QT[14] QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24]
+   QT[25] QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35]
+   QT[36] QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46]
+   QT[47] QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57]
+   QT[58] QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68]
+   QT[69] QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79]
+   QT[80] QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90]
+   QT[91] QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100]
+   QT[101] QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109]
+   QT[110] QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118]
+   QT[119] QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127]
+   QT[128] QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136]
+   QT[137] QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145]
+   QT[146] QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154]
+   QT[155] QT[156] QT[157] QT[158] QT[159] RASSB_H[0] RASSB_H[1] RBLWA
+   RERASSB[0] RERASSB[1] RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2]
+   RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] STCLK STRSB T1TRD T1TWR TKEEPB
+   VBN VBP VDDA VDDP VDDP VDDP VDDP VDDP VDDP VDDPI VEDGE VSS WABUF[0] WABUF[1]
+   WABUF[2] WAGND[0] WAGND[1] WAGND[2] WAGND[3] WAGND[4] WAGND[5] WAGND[6]
+   WAGND[7] WAGND[8] WAGND[9] WAGND[10] WAGND[11] WAGND[12] WAGND[13] WAGND[14]
+   WAGND[15] WAGND[16] WAGND[17] WAGND[18] WAGND[19] WAGND[20] WAGND[21]
+   WAGND[22] WAGND[23] WAGND[24] WAGND[25] WAGND[26] WAGND[27] WAGND[28]
+   WAGND[29] WAGND[30] WAGND[31] WAGND[32] WAGND[33] WAGND[34] WAGND[35]
+   WAGND[36] WAGND[37] WAGND[38] WAGND[39] WAGND[40] WAGND[41] WAGND[42]
+   WAGND[43] WAGND[44] WAGND[45] WAGND[46] WAGND[47] WAGND[48] WAGND[49]
+   WAGND[50] WAGND[51] WAGND[52] WAGND[53] WAGND[54] WAGND[55] WAGND[56]
+   WAGND[57] WAGND[58] WAGND[59] WAGND[60] WAGND[61] WAGND[62] WAGND[63]
+   WAGND[64] WAGND[65] WAGND[66] WAGND[67] WAGND[68] WAGND[69] WAGND[70]
+   WAGND[71] WAGND[72] WAGND[73] WAGND[74] WAGND[75] WAGND[76] WAGND[77]
+   WAGND[78] WAGND[79] WAPRCLKB_RET_LCEN WAPRCLKB_RET_DEL WAPRCLKB_RET_DEL_2
+   WAPRCLKB_RET_DEL_4 WAPRCLKB_RET_LCEN WBI[0] WBI[1] WBI[2] WBI[3] WBI[4]
+   WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14]
+   WBI[15] WBI[16] WBI[17] WBI[18] WBI[19] WBI[20] WBI[21] WBI[22] WBI[23]
+   WBI[24] WBI[25] WBI[26] WBI[27] WBI[28] WBI[29] WBI[30] WBI[31] WBI[32]
+   WBI[33] WBI[34] WBI[35] WBI[36] WBI[37] WBI[38] WBI[39] WBI[40] WBI[41]
+   WBI[42] WBI[43] WBI[44] WBI[45] WBI[46] WBI[47] WBI[48] WBI[49] WBI[50]
+   WBI[51] WBI[52] WBI[53] WBI[54] WBI[55] WBI[56] WBI[57] WBI[58] WBI[59]
+   WBI[60] WBI[61] WBI[62] WBI[63] WBI[64] WBI[65] WBI[66] WBI[67] WBI[68]
+   WBI[69] WBI[70] WBI[71] WBI[72] WBI[73] WBI[74] WBI[75] WBI[76] WBI[77]
+   WBI[78] WBI[79] WFLOAT WFLT_RET WPBUF[0] WPBUF[1] WPBUF[2] WTI[0] WTI[1]
+   WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11]
+   WTI[12] WTI[13] WTI[14] WTI[15] WTI[16] WTI[17] WTI[18] WTI[19] WTI[20]
+   WTI[21] WTI[22] WTI[23] WTI[24] WTI[25] WTI[26] WTI[27] WTI[28] WTI[29]
+   WTI[30] WTI[31] WTI[32] WTI[33] WTI[34] WTI[35] WTI[36] WTI[37] WTI[38]
+   WTI[39] WTI[40] WTI[41] WTI[42] WTI[43] WTI[44] WTI[45] WTI[46] WTI[47]
+   WTI[48] WTI[49] WTI[50] WTI[51] WTI[52] WTI[53] WTI[54] WTI[55] WTI[56]
+   WTI[57] WTI[58] WTI[59] WTI[60] WTI[61] WTI[62] WTI[63] WTI[64] WTI[65]
+   WTI[66] WTI[67] WTI[68] WTI[69] WTI[70] WTI[71] WTI[72] WTI[73] WTI[74]
+   WTI[75] WTI[76] WTI[77] WTI[78] WTI[79] YCOLRD[0] YCOLRD[1] YCOLRD[2]
+   YCOLRD[3] YCOLWR[0] YCOLWR[1] YCOLWR[2] YCOLWR[3] YSELRD[0] YSELRD[1]
+   YSELRD[2] YSELRD[3] SNPS_RF_DP_UHD_512x80_was_row
X_mux_row ARYSD LOG0 CKGATE_RD LOG0 CLKWLB_RD CLKWLB_RD_HV CLKWLB_RD
+   CLKWLB_WR_HV WFLOAT DEF1_RD DEF1_WR FAST1_RD FAST1_WR FAST2_RD FAST2_WR
+   LCGTL[0] LCGTV[0] LCGTV[1] LITESLP LOG0 LOG0 LOG1 LOG1 LRWMEB LXADRBRD_2
+   LXADRBRD_3 LXADRBRD_4 PAARD[0] PAARD[1] PAARD[2] PAARD[3] PAAWR[0] PAAWR[1]
+   PAAWR[2] PAAWR[3] PAWR[0] PAWR[1] PAWR[2] PAWR[3] PAWRB[0] PAWRB[1] PAWRB[2]
+   PAWRB[3] PBRD[0] PBRD[1] PBRD[2] PBRD[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3]
+   PBWR[0] PBWR[1] PBWR[2] PBWR[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3] PCRD[0]
+   PCRD[1] PCRD[2] PCRD[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWR[0] PCWR[1]
+   PCWR[2] PCWR[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3] LOG1 QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+   QT[15] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25]
+   QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] QT[32] QT[33] QT[34] QT[35] QT[36]
+   QT[37] QT[38] QT[39] QT[40] QT[41] QT[42] QT[43] QT[44] QT[45] QT[46] QT[47]
+   QT[48] QT[49] QT[50] QT[51] QT[52] QT[53] QT[54] QT[55] QT[56] QT[57] QT[58]
+   QT[59] QT[60] QT[61] QT[62] QT[63] QT[64] QT[65] QT[66] QT[67] QT[68] QT[69]
+   QT[70] QT[71] QT[72] QT[73] QT[74] QT[75] QT[76] QT[77] QT[78] QT[79] QT[80]
+   QT[81] QT[82] QT[83] QT[84] QT[85] QT[86] QT[87] QT[88] QT[89] QT[90] QT[91]
+   QT[92] QT[93] QT[94] QT[95] QT[96] QT[97] QT[98] QT[99] QT[100] QT[101]
+   QT[102] QT[103] QT[104] QT[105] QT[106] QT[107] QT[108] QT[109] QT[110]
+   QT[111] QT[112] QT[113] QT[114] QT[115] QT[116] QT[117] QT[118] QT[119]
+   QT[120] QT[121] QT[122] QT[123] QT[124] QT[125] QT[126] QT[127] QT[128]
+   QT[129] QT[130] QT[131] QT[132] QT[133] QT[134] QT[135] QT[136] QT[137]
+   QT[138] QT[139] QT[140] QT[141] QT[142] QT[143] QT[144] QT[145] QT[146]
+   QT[147] QT[148] QT[149] QT[150] QT[151] QT[152] QT[153] QT[154] QT[155]
+   QT[156] QT[157] QT[158] QT[159] RASSB_H[0] RASSB_H[1] RBLWA RDBL[0]
+   RERASSB[0] RERASSB[1] RFLOAT LOG1 RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2]
+   RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] STCLK STCLK_WR_RST_PGM STRSB
+   T1TRD T1TWR TKEEPB VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDP VDDP VDDP VDDP VDDAPI VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDWL_RD VDDWL_RD_REBUF VDDWL_WR VDDWL_WR_REBUF VEDGE VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSSWL WABUF[2] WAGND[0] WAGND[1] WAGND[2] WAGND[3]
+   WAGND[4] WAGND[5] WAGND[6] WAGND[7] WAGND[8] WAGND[9] WAGND[10] WAGND[11]
+   WAGND[12] WAGND[13] WAGND[14] WAGND[15] WAGND[16] WAGND[17] WAGND[18]
+   WAGND[19] WAGND[20] WAGND[21] WAGND[22] WAGND[23] WAGND[24] WAGND[25]
+   WAGND[26] WAGND[27] WAGND[28] WAGND[29] WAGND[30] WAGND[31] WAGND[32]
+   WAGND[33] WAGND[34] WAGND[35] WAGND[36] WAGND[37] WAGND[38] WAGND[39]
+   WAGND[40] WAGND[41] WAGND[42] WAGND[43] WAGND[44] WAGND[45] WAGND[46]
+   WAGND[47] WAGND[48] WAGND[49] WAGND[50] WAGND[51] WAGND[52] WAGND[53]
+   WAGND[54] WAGND[55] WAGND[56] WAGND[57] WAGND[58] WAGND[59] WAGND[60]
+   WAGND[61] WAGND[62] WAGND[63] WAGND[64] WAGND[65] WAGND[66] WAGND[67]
+   WAGND[68] WAGND[69] WAGND[70] WAGND[71] WAGND[72] WAGND[73] WAGND[74]
+   WAGND[75] WAGND[76] WAGND[77] WAGND[78] WAGND[79] WAPRCLKB_RET_LCEN WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10]
+   WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WBI[16] WBI[17] WBI[18] WBI[19]
+   WBI[20] WBI[21] WBI[22] WBI[23] WBI[24] WBI[25] WBI[26] WBI[27] WBI[28]
+   WBI[29] WBI[30] WBI[31] WBI[32] WBI[33] WBI[34] WBI[35] WBI[36] WBI[37]
+   WBI[38] WBI[39] WBI[40] WBI[41] WBI[42] WBI[43] WBI[44] WBI[45] WBI[46]
+   WBI[47] WBI[48] WBI[49] WBI[50] WBI[51] WBI[52] WBI[53] WBI[54] WBI[55]
+   WBI[56] WBI[57] WBI[58] WBI[59] WBI[60] WBI[61] WBI[62] WBI[63] WBI[64]
+   WBI[65] WBI[66] WBI[67] WBI[68] WBI[69] WBI[70] WBI[71] WBI[72] WBI[73]
+   WBI[74] WBI[75] WBI[76] WBI[77] WBI[78] WBI[79] BAB[0] BAB[1] BAB[2] BAB[3]
+   BAB[4] BAB[5] BAB[6] BAB[7] BAB[8] BAB[9] BAB[10] BAB[11] BAB[12] BAB[13]
+   BAB[14] BAB[15] BAB[16] BAB[17] BAB[18] BAB[19] BAB[20] BAB[21] BAB[22]
+   BAB[23] BAB[24] BAB[25] BAB[26] BAB[27] BAB[28] BAB[29] BAB[30] BAB[31]
+   BAB[32] BAB[33] BAB[34] BAB[35] BAB[36] BAB[37] BAB[38] BAB[39] BAB[40]
+   BAB[41] BAB[42] BAB[43] BAB[44] BAB[45] BAB[46] BAB[47] BAB[48] BAB[49]
+   BAB[50] BAB[51] BAB[52] BAB[53] BAB[54] BAB[55] BAB[56] BAB[57] BAB[58]
+   BAB[59] BAB[60] BAB[61] BAB[62] BAB[63] BAB[64] BAB[65] BAB[66] BAB[67]
+   BAB[68] BAB[69] BAB[70] BAB[71] BAB[72] BAB[73] BAB[74] BAB[75] BAB[76]
+   BAB[77] BAB[78] BAB[79] BAB[80] BAB[81] BAB[82] BAB[83] BAB[84] BAB[85]
+   BAB[86] BAB[87] BAB[88] BAB[89] BAB[90] BAB[91] BAB[92] BAB[93] BAB[94]
+   BAB[95] BAB[96] BAB[97] BAB[98] BAB[99] BAB[100] BAB[101] BAB[102] BAB[103]
+   BAB[104] BAB[105] BAB[106] BAB[107] BAB[108] BAB[109] BAB[110] BAB[111]
+   BAB[112] BAB[113] BAB[114] BAB[115] BAB[116] BAB[117] BAB[118] BAB[119]
+   BAB[120] BAB[121] BAB[122] BAB[123] BAB[124] BAB[125] BAB[126] BAB[127]
+   BAB[128] BAB[129] BAB[130] BAB[131] BAB[132] BAB[133] BAB[134] BAB[135]
+   BAB[136] BAB[137] BAB[138] BAB[139] BAB[140] BAB[141] BAB[142] BAB[143]
+   BAB[144] BAB[145] BAB[146] BAB[147] BAB[148] BAB[149] BAB[150] BAB[151]
+   BAB[152] BAB[153] BAB[154] BAB[155] BAB[156] BAB[157] BAB[158] BAB[159]
+   BAT[0] BAT[1] BAT[2] BAT[3] BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9]
+   BAT[10] BAT[11] BAT[12] BAT[13] BAT[14] BAT[15] BAT[16] BAT[17] BAT[18]
+   BAT[19] BAT[20] BAT[21] BAT[22] BAT[23] BAT[24] BAT[25] BAT[26] BAT[27]
+   BAT[28] BAT[29] BAT[30] BAT[31] BAT[32] BAT[33] BAT[34] BAT[35] BAT[36]
+   BAT[37] BAT[38] BAT[39] BAT[40] BAT[41] BAT[42] BAT[43] BAT[44] BAT[45]
+   BAT[46] BAT[47] BAT[48] BAT[49] BAT[50] BAT[51] BAT[52] BAT[53] BAT[54]
+   BAT[55] BAT[56] BAT[57] BAT[58] BAT[59] BAT[60] BAT[61] BAT[62] BAT[63]
+   BAT[64] BAT[65] BAT[66] BAT[67] BAT[68] BAT[69] BAT[70] BAT[71] BAT[72]
+   BAT[73] BAT[74] BAT[75] BAT[76] BAT[77] BAT[78] BAT[79] BAT[80] BAT[81]
+   BAT[82] BAT[83] BAT[84] BAT[85] BAT[86] BAT[87] BAT[88] BAT[89] BAT[90]
+   BAT[91] BAT[92] BAT[93] BAT[94] BAT[95] BAT[96] BAT[97] BAT[98] BAT[99]
+   BAT[100] BAT[101] BAT[102] BAT[103] BAT[104] BAT[105] BAT[106] BAT[107]
+   BAT[108] BAT[109] BAT[110] BAT[111] BAT[112] BAT[113] BAT[114] BAT[115]
+   BAT[116] BAT[117] BAT[118] BAT[119] BAT[120] BAT[121] BAT[122] BAT[123]
+   BAT[124] BAT[125] BAT[126] BAT[127] BAT[128] BAT[129] BAT[130] BAT[131]
+   BAT[132] BAT[133] BAT[134] BAT[135] BAT[136] BAT[137] BAT[138] BAT[139]
+   BAT[140] BAT[141] BAT[142] BAT[143] BAT[144] BAT[145] BAT[146] BAT[147]
+   BAT[148] BAT[149] BAT[150] BAT[151] BAT[152] BAT[153] BAT[154] BAT[155]
+   BAT[156] BAT[157] BAT[158] BAT[159] WCLKRD[0] WCLKRD[1] WCLKRD[2] WCLKRD[3]
+   WCLKWR[0] WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WFLT_DEL_A
+   STCLK_WR_RST_PGM WFLT_RET WL_VSS WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   WTI[16] WTI[17] WTI[18] WTI[19] WTI[20] WTI[21] WTI[22] WTI[23] WTI[24]
+   WTI[25] WTI[26] WTI[27] WTI[28] WTI[29] WTI[30] WTI[31] WTI[32] WTI[33]
+   WTI[34] WTI[35] WTI[36] WTI[37] WTI[38] WTI[39] WTI[40] WTI[41] WTI[42]
+   WTI[43] WTI[44] WTI[45] WTI[46] WTI[47] WTI[48] WTI[49] WTI[50] WTI[51]
+   WTI[52] WTI[53] WTI[54] WTI[55] WTI[56] WTI[57] WTI[58] WTI[59] WTI[60]
+   WTI[61] WTI[62] WTI[63] WTI[64] WTI[65] WTI[66] WTI[67] WTI[68] WTI[69]
+   WTI[70] WTI[71] WTI[72] WTI[73] WTI[74] WTI[75] WTI[76] WTI[77] WTI[78]
+   WTI[79] YCOLWR[0] YCOLWR[1] YCOLWR[2] YCOLWR[3] YSELRD[0] YSELRD[1]
+   YSELRD[2] YSELRD[3] SNPS_RF_DP_UHD_512x80_mux_row
X_sac_row_t ARYSD BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159] LOG0
+   DEF1_RD DEF1_WR DMY_EDGE_LT[0] DMY_EDGE_LT[1] DMY_EDGE_RT[0] DMY_EDGE_RT[1]
+   FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL[0] LCGTL[1] LCGTV[0] LCGTV[1] LOG0
+   LOG1 LRWMEB LXADR[0] LXADR[1] LXADR[2] LXADRBRD_2 LXADRBRD_3 LXADRBRD_4
+   OPT_RET PAWRB[0] PAWRB[1] PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2]
+   PBRDB[3] PBWRB[0] PBWRB[1] PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2]
+   PCRDB[3] PCWRB[0] PCWRB[1] PCWRB[2] PCWRB[3] LOG1 LXADR[0] PLBKADR[1]
+   PLBKADR[2] LXADRBRD_2 QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8]
+   QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17] QT[18] QT[19]
+   QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28] QT[29] QT[30]
+   QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38] QT[39] QT[40] QT[41]
+   QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49] QT[50] QT[51] QT[52]
+   QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60] QT[61] QT[62] QT[63]
+   QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70] QT[71] QT[72] QT[73] QT[74]
+   QT[75] QT[76] QT[77] QT[78] QT[79] QT[80] QT[81] QT[82] QT[83] QT[84] QT[85]
+   QT[86] QT[87] QT[88] QT[89] QT[90] QT[91] QT[92] QT[93] QT[94] QT[95] QT[96]
+   QT[97] QT[98] QT[99] QT[100] QT[101] QT[102] QT[103] QT[104] QT[105] QT[106]
+   QT[107] QT[108] QT[109] QT[110] QT[111] QT[112] QT[113] QT[114] QT[115]
+   QT[116] QT[117] QT[118] QT[119] QT[120] QT[121] QT[122] QT[123] QT[124]
+   QT[125] QT[126] QT[127] QT[128] QT[129] QT[130] QT[131] QT[132] QT[133]
+   QT[134] QT[135] QT[136] QT[137] QT[138] QT[139] QT[140] QT[141] QT[142]
+   QT[143] QT[144] QT[145] QT[146] QT[147] QT[148] QT[149] QT[150] QT[151]
+   QT[152] QT[153] QT[154] QT[155] QT[156] QT[157] QT[158] QT[159] RASSB_H[0]
+   RASSB_H[1] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5] RBL[6] RBL[7] RBL[8]
+   RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15] RBL[16] RBL[17]
+   RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24] RBL[25] RBL[26]
+   RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33] RBL[34] RBL[35]
+   RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42] RBL[43] RBL[44]
+   RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51] RBL[52] RBL[53]
+   RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60] RBL[61] RBL[62]
+   RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69] RBL[70] RBL[71]
+   RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78] RBL[79] RBL[80]
+   RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87] RBL[88] RBL[89]
+   RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96] RBL[97] RBL[98]
+   RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104] RBL[105] RBL[106]
+   RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112] RBL[113] RBL[114]
+   RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120] RBL[121] RBL[122]
+   RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128] RBL[129] RBL[130]
+   RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136] RBL[137] RBL[138]
+   RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144] RBL[145] RBL[146]
+   RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152] RBL[153] RBL[154]
+   RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RBLWA RDBL[1] RERASSB[0]
+   RERASSB[1] RFLOAT RFLOAT_H RFLOAT_H_DEL0 RFLOAT_H_DEL2 RFLOAT_H_DEL4
+   RFLOAT_H_DEL6 RFLOAT_H_DEL6 RFLOAT_H_DEL2 RFLT_DEL_A RFLT_DEL_B RFLT_DEL_C
+   RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1]
+   RMTWR[2] RMTWR[3] ROWBKDB ROWBKTB RWLB_RD RWLB_WR RFLT_DEL_C T1TRD T1TWR
+   TKEEPB VBN VBP VDDA VDDP VDDP VDDP VDDP VDDAPI VDDP VDDP VDDPI VDDWL_RD
+   VDDWL_RD_REBUF VDDWL_WR VDDWL_WR_REBUF VEDGE VSS VSSWL WCLKRD[0] WCLKRD[1]
+   WCLKRD[2] WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT
+   WFLOAT_H WFLOAT_H_DEL0 WFLOAT_H_DEL2 WFLOAT_H_DEL4 WFLOAT_H_DEL6
+   WFLOAT_H_DEL4 WFLOAT_H_DEL2 WL_VSS YSELRD[0] YSELRD[1] YSELRD[2] YSELRD[3]
+   SNPS_RF_DP_UHD_512x80_sac_row_t
X_ary_row_1 ARYSD BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159]
+   ROWBKDB ROWBKTB LOG0 DEF1_RD DEF1_WR DMY_EDGE_LT[0] DMY_EDGE_LT[1]
+   DMY_EDGE_LT[2] DMY_EDGE_LT[3] DMY_EDGE_RT[0] DMY_EDGE_RT[1] DMY_EDGE_RT[2]
+   DMY_EDGE_RT[3] FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL[1] LCGTV[0]
+   LCGTV[1] LOG0 LOG1 LRWMEB LXADRBRD_2 LXADRBRD_3 LXADRBRD_4 PAWRB[0] PAWRB[1]
+   PAWRB[2] PAWRB[3] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PBWRB[0] PBWRB[1]
+   PBWRB[2] PBWRB[3] PCRDB[0] PCRDB[1] PCRDB[2] PCRDB[3] PCWRB[0] PCWRB[1]
+   PCWRB[2] PCWRB[3] LOG1 QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8]
+   QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17] QT[18] QT[19]
+   QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28] QT[29] QT[30]
+   QT[31] QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38] QT[39] QT[40] QT[41]
+   QT[42] QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49] QT[50] QT[51] QT[52]
+   QT[53] QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60] QT[61] QT[62] QT[63]
+   QT[64] QT[65] QT[66] QT[67] QT[68] QT[69] QT[70] QT[71] QT[72] QT[73] QT[74]
+   QT[75] QT[76] QT[77] QT[78] QT[79] QT[80] QT[81] QT[82] QT[83] QT[84] QT[85]
+   QT[86] QT[87] QT[88] QT[89] QT[90] QT[91] QT[92] QT[93] QT[94] QT[95] QT[96]
+   QT[97] QT[98] QT[99] QT[100] QT[101] QT[102] QT[103] QT[104] QT[105] QT[106]
+   QT[107] QT[108] QT[109] QT[110] QT[111] QT[112] QT[113] QT[114] QT[115]
+   QT[116] QT[117] QT[118] QT[119] QT[120] QT[121] QT[122] QT[123] QT[124]
+   QT[125] QT[126] QT[127] QT[128] QT[129] QT[130] QT[131] QT[132] QT[133]
+   QT[134] QT[135] QT[136] QT[137] QT[138] QT[139] QT[140] QT[141] QT[142]
+   QT[143] QT[144] QT[145] QT[146] QT[147] QT[148] QT[149] QT[150] QT[151]
+   QT[152] QT[153] QT[154] QT[155] QT[156] QT[157] QT[158] QT[159] RASSB_H[0]
+   RASSB_H[1] RBL[0] RBL[1] RBL[2] RBL[3] RBL[4] RBL[5] RBL[6] RBL[7] RBL[8]
+   RBL[9] RBL[10] RBL[11] RBL[12] RBL[13] RBL[14] RBL[15] RBL[16] RBL[17]
+   RBL[18] RBL[19] RBL[20] RBL[21] RBL[22] RBL[23] RBL[24] RBL[25] RBL[26]
+   RBL[27] RBL[28] RBL[29] RBL[30] RBL[31] RBL[32] RBL[33] RBL[34] RBL[35]
+   RBL[36] RBL[37] RBL[38] RBL[39] RBL[40] RBL[41] RBL[42] RBL[43] RBL[44]
+   RBL[45] RBL[46] RBL[47] RBL[48] RBL[49] RBL[50] RBL[51] RBL[52] RBL[53]
+   RBL[54] RBL[55] RBL[56] RBL[57] RBL[58] RBL[59] RBL[60] RBL[61] RBL[62]
+   RBL[63] RBL[64] RBL[65] RBL[66] RBL[67] RBL[68] RBL[69] RBL[70] RBL[71]
+   RBL[72] RBL[73] RBL[74] RBL[75] RBL[76] RBL[77] RBL[78] RBL[79] RBL[80]
+   RBL[81] RBL[82] RBL[83] RBL[84] RBL[85] RBL[86] RBL[87] RBL[88] RBL[89]
+   RBL[90] RBL[91] RBL[92] RBL[93] RBL[94] RBL[95] RBL[96] RBL[97] RBL[98]
+   RBL[99] RBL[100] RBL[101] RBL[102] RBL[103] RBL[104] RBL[105] RBL[106]
+   RBL[107] RBL[108] RBL[109] RBL[110] RBL[111] RBL[112] RBL[113] RBL[114]
+   RBL[115] RBL[116] RBL[117] RBL[118] RBL[119] RBL[120] RBL[121] RBL[122]
+   RBL[123] RBL[124] RBL[125] RBL[126] RBL[127] RBL[128] RBL[129] RBL[130]
+   RBL[131] RBL[132] RBL[133] RBL[134] RBL[135] RBL[136] RBL[137] RBL[138]
+   RBL[139] RBL[140] RBL[141] RBL[142] RBL[143] RBL[144] RBL[145] RBL[146]
+   RBL[147] RBL[148] RBL[149] RBL[150] RBL[151] RBL[152] RBL[153] RBL[154]
+   RBL[155] RBL[156] RBL[157] RBL[158] RBL[159] RBLWA RDBL[1] RERASSB[0]
+   RERASSB[1] RFLOAT RFLT_RET RM3CNT RMTRD[0] RMTRD[1] RMTRD[2] RMTRD[3]
+   RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_RD RWLB_WR T1TRD T1TWR TKEEPB VBN
+   VBP VDDA VDDP VDDP VDDP VDDP VDDAPI VDDP VDDP VDDPI VDDWL_RD VDDWL_RD_REBUF
+   VDDWL_WR VDDWL_WR_REBUF VEDGE VSS VSSWL WCLKRD[0] WCLKRD[1] WCLKRD[2]
+   WCLKRD[3] WCLKWR[0] WCLKWR[1] WCLKWR[2] WCLKWR[3] WDBL WFLOAT WL_VSS
+   PAWRB[0] PBRDB[0] PBWRB[0] PCRDB[0] PCWRB[0] YSELRD[0] YSELRD[1] YSELRD[2]
+   YSELRD[3] SNPS_RF_DP_UHD_512x80_ary_row_1
X_ref_row ARYSD BAB[0] BAB[1] BAB[2] BAB[3] BAB[4] BAB[5] BAB[6] BAB[7] BAB[8]
+   BAB[9] BAB[10] BAB[11] BAB[12] BAB[13] BAB[14] BAB[15] BAB[16] BAB[17]
+   BAB[18] BAB[19] BAB[20] BAB[21] BAB[22] BAB[23] BAB[24] BAB[25] BAB[26]
+   BAB[27] BAB[28] BAB[29] BAB[30] BAB[31] BAB[32] BAB[33] BAB[34] BAB[35]
+   BAB[36] BAB[37] BAB[38] BAB[39] BAB[40] BAB[41] BAB[42] BAB[43] BAB[44]
+   BAB[45] BAB[46] BAB[47] BAB[48] BAB[49] BAB[50] BAB[51] BAB[52] BAB[53]
+   BAB[54] BAB[55] BAB[56] BAB[57] BAB[58] BAB[59] BAB[60] BAB[61] BAB[62]
+   BAB[63] BAB[64] BAB[65] BAB[66] BAB[67] BAB[68] BAB[69] BAB[70] BAB[71]
+   BAB[72] BAB[73] BAB[74] BAB[75] BAB[76] BAB[77] BAB[78] BAB[79] BAB[80]
+   BAB[81] BAB[82] BAB[83] BAB[84] BAB[85] BAB[86] BAB[87] BAB[88] BAB[89]
+   BAB[90] BAB[91] BAB[92] BAB[93] BAB[94] BAB[95] BAB[96] BAB[97] BAB[98]
+   BAB[99] BAB[100] BAB[101] BAB[102] BAB[103] BAB[104] BAB[105] BAB[106]
+   BAB[107] BAB[108] BAB[109] BAB[110] BAB[111] BAB[112] BAB[113] BAB[114]
+   BAB[115] BAB[116] BAB[117] BAB[118] BAB[119] BAB[120] BAB[121] BAB[122]
+   BAB[123] BAB[124] BAB[125] BAB[126] BAB[127] BAB[128] BAB[129] BAB[130]
+   BAB[131] BAB[132] BAB[133] BAB[134] BAB[135] BAB[136] BAB[137] BAB[138]
+   BAB[139] BAB[140] BAB[141] BAB[142] BAB[143] BAB[144] BAB[145] BAB[146]
+   BAB[147] BAB[148] BAB[149] BAB[150] BAB[151] BAB[152] BAB[153] BAB[154]
+   BAB[155] BAB[156] BAB[157] BAB[158] BAB[159] BAT[0] BAT[1] BAT[2] BAT[3]
+   BAT[4] BAT[5] BAT[6] BAT[7] BAT[8] BAT[9] BAT[10] BAT[11] BAT[12] BAT[13]
+   BAT[14] BAT[15] BAT[16] BAT[17] BAT[18] BAT[19] BAT[20] BAT[21] BAT[22]
+   BAT[23] BAT[24] BAT[25] BAT[26] BAT[27] BAT[28] BAT[29] BAT[30] BAT[31]
+   BAT[32] BAT[33] BAT[34] BAT[35] BAT[36] BAT[37] BAT[38] BAT[39] BAT[40]
+   BAT[41] BAT[42] BAT[43] BAT[44] BAT[45] BAT[46] BAT[47] BAT[48] BAT[49]
+   BAT[50] BAT[51] BAT[52] BAT[53] BAT[54] BAT[55] BAT[56] BAT[57] BAT[58]
+   BAT[59] BAT[60] BAT[61] BAT[62] BAT[63] BAT[64] BAT[65] BAT[66] BAT[67]
+   BAT[68] BAT[69] BAT[70] BAT[71] BAT[72] BAT[73] BAT[74] BAT[75] BAT[76]
+   BAT[77] BAT[78] BAT[79] BAT[80] BAT[81] BAT[82] BAT[83] BAT[84] BAT[85]
+   BAT[86] BAT[87] BAT[88] BAT[89] BAT[90] BAT[91] BAT[92] BAT[93] BAT[94]
+   BAT[95] BAT[96] BAT[97] BAT[98] BAT[99] BAT[100] BAT[101] BAT[102] BAT[103]
+   BAT[104] BAT[105] BAT[106] BAT[107] BAT[108] BAT[109] BAT[110] BAT[111]
+   BAT[112] BAT[113] BAT[114] BAT[115] BAT[116] BAT[117] BAT[118] BAT[119]
+   BAT[120] BAT[121] BAT[122] BAT[123] BAT[124] BAT[125] BAT[126] BAT[127]
+   BAT[128] BAT[129] BAT[130] BAT[131] BAT[132] BAT[133] BAT[134] BAT[135]
+   BAT[136] BAT[137] BAT[138] BAT[139] BAT[140] BAT[141] BAT[142] BAT[143]
+   BAT[144] BAT[145] BAT[146] BAT[147] BAT[148] BAT[149] BAT[150] BAT[151]
+   BAT[152] BAT[153] BAT[154] BAT[155] BAT[156] BAT[157] BAT[158] BAT[159] LOG0
+   DEF1_RD DEF1_WR DMY_EDGE_LT[2] DMY_EDGE_LT[3] DMY_EDGE_RT[2] DMY_EDGE_RT[3]
+   FAST1_RD FAST1_WR FAST2_RD FAST2_WR LCGTL[1] LCGTV[0] LCGTV[1] LOG0 LOG1
+   LRWMEB LOG1 QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9]
+   QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] QT[16] QT[17] QT[18] QT[19] QT[20]
+   QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28] QT[29] QT[30] QT[31]
+   QT[32] QT[33] QT[34] QT[35] QT[36] QT[37] QT[38] QT[39] QT[40] QT[41] QT[42]
+   QT[43] QT[44] QT[45] QT[46] QT[47] QT[48] QT[49] QT[50] QT[51] QT[52] QT[53]
+   QT[54] QT[55] QT[56] QT[57] QT[58] QT[59] QT[60] QT[61] QT[62] QT[63] QT[64]
+   QT[65] QT[66] QT[67] QT[68] QT[69] QT[70] QT[71] QT[72] QT[73] QT[74] QT[75]
+   QT[76] QT[77] QT[78] QT[79] QT[80] QT[81] QT[82] QT[83] QT[84] QT[85] QT[86]
+   QT[87] QT[88] QT[89] QT[90] QT[91] QT[92] QT[93] QT[94] QT[95] QT[96] QT[97]
+   QT[98] QT[99] QT[100] QT[101] QT[102] QT[103] QT[104] QT[105] QT[106]
+   QT[107] QT[108] QT[109] QT[110] QT[111] QT[112] QT[113] QT[114] QT[115]
+   QT[116] QT[117] QT[118] QT[119] QT[120] QT[121] QT[122] QT[123] QT[124]
+   QT[125] QT[126] QT[127] QT[128] QT[129] QT[130] QT[131] QT[132] QT[133]
+   QT[134] QT[135] QT[136] QT[137] QT[138] QT[139] QT[140] QT[141] QT[142]
+   QT[143] QT[144] QT[145] QT[146] QT[147] QT[148] QT[149] QT[150] QT[151]
+   QT[152] QT[153] QT[154] QT[155] QT[156] QT[157] QT[158] QT[159] RBL[0]
+   RBL[1] RBL[2] RBL[3] RBL[4] RBL[5] RBL[6] RBL[7] RBL[8] RBL[9] RBL[10]
+   RBL[11] RBL[12] RBL[13] RBL[14] RBL[15] RBL[16] RBL[17] RBL[18] RBL[19]
+   RBL[20] RBL[21] RBL[22] RBL[23] RBL[24] RBL[25] RBL[26] RBL[27] RBL[28]
+   RBL[29] RBL[30] RBL[31] RBL[32] RBL[33] RBL[34] RBL[35] RBL[36] RBL[37]
+   RBL[38] RBL[39] RBL[40] RBL[41] RBL[42] RBL[43] RBL[44] RBL[45] RBL[46]
+   RBL[47] RBL[48] RBL[49] RBL[50] RBL[51] RBL[52] RBL[53] RBL[54] RBL[55]
+   RBL[56] RBL[57] RBL[58] RBL[59] RBL[60] RBL[61] RBL[62] RBL[63] RBL[64]
+   RBL[65] RBL[66] RBL[67] RBL[68] RBL[69] RBL[70] RBL[71] RBL[72] RBL[73]
+   RBL[74] RBL[75] RBL[76] RBL[77] RBL[78] RBL[79] RBL[80] RBL[81] RBL[82]
+   RBL[83] RBL[84] RBL[85] RBL[86] RBL[87] RBL[88] RBL[89] RBL[90] RBL[91]
+   RBL[92] RBL[93] RBL[94] RBL[95] RBL[96] RBL[97] RBL[98] RBL[99] RBL[100]
+   RBL[101] RBL[102] RBL[103] RBL[104] RBL[105] RBL[106] RBL[107] RBL[108]
+   RBL[109] RBL[110] RBL[111] RBL[112] RBL[113] RBL[114] RBL[115] RBL[116]
+   RBL[117] RBL[118] RBL[119] RBL[120] RBL[121] RBL[122] RBL[123] RBL[124]
+   RBL[125] RBL[126] RBL[127] RBL[128] RBL[129] RBL[130] RBL[131] RBL[132]
+   RBL[133] RBL[134] RBL[135] RBL[136] RBL[137] RBL[138] RBL[139] RBL[140]
+   RBL[141] RBL[142] RBL[143] RBL[144] RBL[145] RBL[146] RBL[147] RBL[148]
+   RBL[149] RBL[150] RBL[151] RBL[152] RBL[153] RBL[154] RBL[155] RBL[156]
+   RBL[157] RBL[158] RBL[159] RBLWA RDBL[1] RFLOAT RM3CNT RMTRD[0] RMTRD[1]
+   RMTRD[2] RMTRD[3] RMTWR[0] RMTWR[1] RMTWR[2] RMTWR[3] RWLB_INT_WR RWLB_RD
+   RWLB_WR RWLDRD_PASS RWLRD_INT RWLDRD_PASS RWL_PROG T1TRD T1TWR VBN VBP VDDA
+   VDDP VDDP VDDP VDDP VDDAPI VDDP VDDP VDDPI VDDWL_RD VDDWL_RD_REBUF VDDWL_WR
+   VDDWL_WR_REBUF VEDGE VSS VSSWL WDBL WFLOAT WL_VSS
+   SNPS_RF_DP_UHD_512x80_ref_row_1
*X_ref_row_dummy SNPS_RF_DP_UHD_512x80_ref_row_dummy
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80_TOP_LAY ADRA[0] ADRA[2] ADRA[3] ADRA[5] ADRA[6]
+       ADRA[7] ADRA[8] ADRA[9] ADRB[0] ADRB[2] ADRB[3] ADRB[5] ADRB[6] ADRB[7]
+       ADRB[8] ADRB[9] CLKA CLKB DA[0] DA[1] DA[2] DA[3] DA[4] DA[5] DA[6]
+       DA[7] DA[8] DA[9] DA[10] DA[11] DA[12] DA[13] DA[14] DA[15] DA[16]
+       DA[17] DA[18] DA[19] DA[20] DA[21] DA[22] DA[23] DA[24] DA[25] DA[26]
+       DA[27] DA[28] DA[29] DA[30] DA[31] DA[32] DA[33] DA[34] DA[35] DA[36]
+       DA[37] DA[38] DA[39] DA[40] DA[41] DA[42] DA[43] DA[44] DA[45] DA[46]
+       DA[47] DA[48] DA[49] DA[50] DA[51] DA[52] DA[53] DA[54] DA[55] DA[56]
+       DA[57] DA[58] DA[59] DA[60] DA[61] DA[62] DA[63] DA[64] DA[65] DA[66]
+       DA[67] DA[68] DA[69] DA[70] DA[71] DA[72] DA[73] DA[74] DA[75] DA[76]
+       DA[77] DA[78] DA[79] LS MEA MEB QB[0] QB[1] QB[2] QB[3] QB[4] QB[5]
+       QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QB[16]
+       QB[17] QB[18] QB[19] QB[20] QB[21] QB[22] QB[23] QB[24] QB[25] QB[26]
+       QB[27] QB[28] QB[29] QB[30] QB[31] QB[32] QB[33] QB[34] QB[35] QB[36]
+       QB[37] QB[38] QB[39] QB[40] QB[41] QB[42] QB[43] QB[44] QB[45] QB[46]
+       QB[47] QB[48] QB[49] QB[50] QB[51] QB[52] QB[53] QB[54] QB[55] QB[56]
+       QB[57] QB[58] QB[59] QB[60] QB[61] QB[62] QB[63] QB[64] QB[65] QB[66]
+       QB[67] QB[68] QB[69] QB[70] QB[71] QB[72] QB[73] QB[74] QB[75] QB[76]
+       QB[77] QB[78] QB[79] RMA[0] RMA[1] RMA[2] RMA[3] RMB[0] RMB[1] RMB[2]
+       RMB[3] RMEA RMEB TEST1A TEST1B TEST_RNMA VDD[0] VNW_N VPW_P VSS WA[0]
+       WA[1] WEA WPULSE[0] WPULSE[1] WPULSE[2]
X_top LOG0 CLKB CLKA DA[0] DA[1] DA[2] DA[3] DA[4] DA[5] DA[6] DA[7] DA[8] DA[9]
+   DA[10] DA[11] DA[12] DA[13] DA[14] DA[15] DA[16] DA[17] DA[18] DA[19] DA[20]
+   DA[21] DA[22] DA[23] DA[24] DA[25] DA[26] DA[27] DA[28] DA[29] DA[30] DA[31]
+   DA[32] DA[33] DA[34] DA[35] DA[36] DA[37] DA[38] DA[39] DA[40] DA[41] DA[42]
+   DA[43] DA[44] DA[45] DA[46] DA[47] DA[48] DA[49] DA[50] DA[51] DA[52] DA[53]
+   DA[54] DA[55] DA[56] DA[57] DA[58] DA[59] DA[60] DA[61] DA[62] DA[63] DA[64]
+   DA[65] DA[66] DA[67] DA[68] DA[69] DA[70] DA[71] DA[72] DA[73] DA[74] DA[75]
+   DA[76] DA[77] DA[78] DA[79] LOG0 LOG0 LOG0 LOG1 LS MEB MEA LOG0 LOG1 QB[0]
+   QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12]
+   QB[13] QB[14] QB[15] QB[16] QB[17] QB[18] QB[19] QB[20] QB[21] QB[22] QB[23]
+   QB[24] QB[25] QB[26] QB[27] QB[28] QB[29] QB[30] QB[31] QB[32] QB[33] QB[34]
+   QB[35] QB[36] QB[37] QB[38] QB[39] QB[40] QB[41] QB[42] QB[43] QB[44] QB[45]
+   QB[46] QB[47] QB[48] QB[49] QB[50] QB[51] QB[52] QB[53] QB[54] QB[55] QB[56]
+   QB[57] QB[58] QB[59] QB[60] QB[61] QB[62] QB[63] QB[64] QB[65] QB[66] QB[67]
+   QB[68] QB[69] QB[70] QB[71] QB[72] QB[73] QB[74] QB[75] QB[76] QB[77] QB[78]
+   QB[79] LOG0 LOG0 RMEB RMEA RMB[0] RMB[1] RMB[2] RMB[3] RMA[0] RMA[1] RMA[2]
+   RMA[3] ROP TEST1B TEST1A TEST_RNMA VNW_N VPW_P VDD[0] VDD[0] VDD[0] VSS
+   WA[0] WA[1] WEA LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1
+   LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1
+   LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1
+   LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1
+   LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1
+   LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 WPULSE[0] WPULSE[1] WPULSE[2]
+   ADRB[2] ADRB[3] ADRB[9] LOG0 ADRB[5] ADRB[6] ADRB[7] ADRB[8] ADRA[2] ADRA[3]
+   ADRA[9] LOG0 ADRA[5] ADRA[6] ADRA[7] ADRA[8] ADRB[0] LOG0 ADRA[0] LOG0
+   SNPS_RF_DP_UHD_512x80_top
.ENDS
.SUBCKT SNPS_RF_DP_UHD_512x80 ADRA[0] ADRA[1] ADRA[2] ADRA[3] ADRA[4] ADRA[5]
+       ADRA[6] ADRA[7] ADRB[0] ADRB[1] ADRB[2] ADRB[3] ADRB[4] ADRB[5] ADRB[6]
+       ADRB[7] CLKA CLKB DA[0] DA[1] DA[2] DA[3] DA[4] DA[5] DA[6] DA[7] DA[8]
+       DA[9] DA[10] DA[11] DA[12] DA[13] DA[14] DA[15] DA[16] DA[17] DA[18]
+       DA[19] DA[20] DA[21] DA[22] DA[23] DA[24] DA[25] DA[26] DA[27] DA[28]
+       DA[29] DA[30] DA[31] DA[32] DA[33] DA[34] DA[35] DA[36] DA[37] DA[38]
+       DA[39] DA[40] DA[41] DA[42] DA[43] DA[44] DA[45] DA[46] DA[47] DA[48]
+       DA[49] DA[50] DA[51] DA[52] DA[53] DA[54] DA[55] DA[56] DA[57] DA[58]
+       DA[59] DA[60] DA[61] DA[62] DA[63] DA[64] DA[65] DA[66] DA[67] DA[68]
+       DA[69] DA[70] DA[71] DA[72] DA[73] DA[74] DA[75] DA[76] DA[77] DA[78]
+       DA[79] LS MEA MEB QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8]
+       QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QB[16] QB[17] QB[18]
+       QB[19] QB[20] QB[21] QB[22] QB[23] QB[24] QB[25] QB[26] QB[27] QB[28]
+       QB[29] QB[30] QB[31] QB[32] QB[33] QB[34] QB[35] QB[36] QB[37] QB[38]
+       QB[39] QB[40] QB[41] QB[42] QB[43] QB[44] QB[45] QB[46] QB[47] QB[48]
+       QB[49] QB[50] QB[51] QB[52] QB[53] QB[54] QB[55] QB[56] QB[57] QB[58]
+       QB[59] QB[60] QB[61] QB[62] QB[63] QB[64] QB[65] QB[66] QB[67] QB[68]
+       QB[69] QB[70] QB[71] QB[72] QB[73] QB[74] QB[75] QB[76] QB[77] QB[78]
+       QB[79] RMA[0] RMA[1] RMA[2] RMA[3] RMB[0] RMB[1] RMB[2] RMB[3] RMEA RMEB
+       TEST1A TEST1B TEST_RNMA VDD VNW_N VPW_P VSS WA[0] WA[1] WEA WPULSE[0]
+       WPULSE[1] WPULSE[2]
X_TOP_LAY ADRA[0] ADRA[1] ADRA[2] ADRA[3] ADRA[4] ADRA[5] ADRA[6] ADRA[7]
+   ADRB[0] ADRB[1] ADRB[2] ADRB[3] ADRB[4] ADRB[5] ADRB[6] ADRB[7] CLKA CLKB
+   DA[0] DA[1] DA[2] DA[3] DA[4] DA[5] DA[6] DA[7] DA[8] DA[9] DA[10] DA[11]
+   DA[12] DA[13] DA[14] DA[15] DA[16] DA[17] DA[18] DA[19] DA[20] DA[21] DA[22]
+   DA[23] DA[24] DA[25] DA[26] DA[27] DA[28] DA[29] DA[30] DA[31] DA[32] DA[33]
+   DA[34] DA[35] DA[36] DA[37] DA[38] DA[39] DA[40] DA[41] DA[42] DA[43] DA[44]
+   DA[45] DA[46] DA[47] DA[48] DA[49] DA[50] DA[51] DA[52] DA[53] DA[54] DA[55]
+   DA[56] DA[57] DA[58] DA[59] DA[60] DA[61] DA[62] DA[63] DA[64] DA[65] DA[66]
+   DA[67] DA[68] DA[69] DA[70] DA[71] DA[72] DA[73] DA[74] DA[75] DA[76] DA[77]
+   DA[78] DA[79] LS MEA MEB QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7]
+   QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QB[16] QB[17] QB[18]
+   QB[19] QB[20] QB[21] QB[22] QB[23] QB[24] QB[25] QB[26] QB[27] QB[28] QB[29]
+   QB[30] QB[31] QB[32] QB[33] QB[34] QB[35] QB[36] QB[37] QB[38] QB[39] QB[40]
+   QB[41] QB[42] QB[43] QB[44] QB[45] QB[46] QB[47] QB[48] QB[49] QB[50] QB[51]
+   QB[52] QB[53] QB[54] QB[55] QB[56] QB[57] QB[58] QB[59] QB[60] QB[61] QB[62]
+   QB[63] QB[64] QB[65] QB[66] QB[67] QB[68] QB[69] QB[70] QB[71] QB[72] QB[73]
+   QB[74] QB[75] QB[76] QB[77] QB[78] QB[79] RMA[0] RMA[1] RMA[2] RMA[3] RMB[0]
+   RMB[1] RMB[2] RMB[3] RMEA RMEB TEST1A TEST1B TEST_RNMA VDD VNW_N VPW_P VSS
+   WA[0] WA[1] WEA WPULSE[0] WPULSE[1] WPULSE[2] SNPS_RF_DP_UHD_512x80_TOP_LAY
 Xvpw_p_h VPW_P vassert_hi vmax=0
 Xvpw_p_l VPW_P vassert_lo vmin=-1.5
 Xvnw_n_l VNW_N vassert_lo vmin=0
 Xvnw_n_h VNW_N vassert_hi vmax=1.2
 Xvss_h VSS vassert_hi vmax=0
 Xvss_l VSS vassert_lo vmin=0
 Xvdd_h VDD vassert_hi vmax=0.9
 Xvdd_l VDD vassert_lo vmin=0.45
.ENDS
