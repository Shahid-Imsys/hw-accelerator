*---------------------------------------------------------------------*
*               Copyright(c) Synopsys, Inc.                           *
*     All Rights reserved - Unpublished -rights reserved under        *
*     the Copyright laws of the United States of America.             *
*                                                                     *
*  U.S. Patents: 7,093,156 B1 and 7,406,620 B2 (and more pending).    *
*                                                                     *
*  This file includes the Confidential information of Synopsys, Inc.  *
*  and GLOBALFOUNDRIES.                                               *
*  The receiver of this Confidential Information shall not disclose   *
*  it to any third party and shall protect its confidentiality by     *
*  using the same degree of care, but not less than a reasonable      *
*  degree of care, as the receiver uses to protect receiver's own     *
*  Confidential Information.                                          *
*  Licensee acknowledges and agrees that all output generated for     *
*  Licensee by Synopsys, Inc. as described in the pertinent Program   *
*  Schedule(s), or generated by Licensee through use of any Compiler  *
*  licensed hereunder contains information that complies with the     *
*  Virtual Component Identification Physical Tagging Standard (VCID)  *
*  as maintained by the Virtual Socket Interface Alliance (VSIA).     *
*  Such information may be expressed in GDSII Layer 63 or other such  *
*  layer designated by the VSIA, hardware definition languages, or    *
*  other formats.  Licensee is not authorized to alter or change any  *
*  such information.                                                  *
*---------------------------------------------------------------------*
*                                                                     *
*  Built for linux64 and running on linux64.                          *
*                                                                     *
*  Software           : Rev: U-2022.12                                *
*  Library Format     : Rev: 1.05.00                                  *
*  Compiler Name      : gf22nsd41p11s1dcl02msa05                      *
*  Platform           : Linux3.10.0-957.5.1.el7.x86_64                *
*                     : #1 SMP Wed Dec 19 10:46:58 EST 2018x86_64     *
*  Date of Generation : Fri Dec 09 14:16:08 CET 2022                  *
*                                                                     *
*---------------------------------------------------------------------*
.option MACMOD=1
.option SCALE=1

.subckt mm16a05_u_logrepedge VDDP VSS VBP VBN LOG0 LOG1
MPLOG VDDP LOG0 LOG1 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=10
M0 LOG0 LOG1 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=10
.ends

.subckt mm16a05_u_hdsp_plus_capgio VDDP VDDPI VSS VBP VBN LOG0 LOG1 PWDO VEDGE
Xlogrep_gio VDDP VSS VBP VBN LOG0 LOG1 mm16a05_u_logrepedge
.ends

.subckt mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=120n wn2=120n wp1=360n wp2=360n
MNA1 X A1 VSS VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 X A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MPA2 net10 A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2
+ w=wp2 m=m_p2
MPA1 X A1 net10 VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
.ends

.subckt mm16a05_u_we_ysel VDDP VDDPI VSS VBP VBN LYSEL LQB WBI WTI LYI[0]
+ LYI[1]
XI50 VDDPI VSS VBP VBN LYSEL LYI[1] LYI[0]
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=360n
+ wp2=360n
.ends

.subckt mm16a05_u_inv_bulk_n_vt2_p_vt2 VDD VSS VBP VBN X A CPP=104n P_LA_n=4n
+ P_LA_p=4n ULP=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=758n wp=1092n
MNA X A VSS VBN slvtnfet cpp=cpp p_la=p_la_n ulp=ulp nf=nf_n l=ln w=wn m=m_n
MPA X A VDD VBP slvtpfet cpp=cpp p_la=p_la_p ulp=ulp nf=nf_p l=lp w=wp m=m_p
.ends

.subckt mm16a05_u_data_drv_ysel VDDP VDDPI VSS VBP VBN DATA_OUT DATA_IN
XI56 VDDPI VSS VBP VBN DATA_OUT DATA_IN mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=758n
+ wp=1092n
.ends

.subckt mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=600n wn2=600n wp1=450n wp2=450n
MPA2 X A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
MPA1 X A1 VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MNA1 X A1 net22 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 net22 A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2
+ w=wn2 m=m_n2
.ends

.subckt mm16a05_u_resolver_hdsp VDDP VDDPI VDDPI_RL VSS VBP VBN QTI LQB PDB QB
+ QT
MI84 VDDPI QB QTI VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=450n m=2
MI73 VDDPI_RL QT LQB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=180n m=5
MI74 LQB QTI net71 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=900n m=2
MI75 net71 PDB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=900n m=2
MI83 QTI QB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
.ends

.subckt mm16a05_u_data_drv VDDP VDDPI VSS VBP VBN DATA_OUT DATA_IN
XI56 VDDPI VSS VBP VBN DATA_OUT DATA_IN mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=758n
+ wp=1092n
.ends

.subckt mm16a05_u_xmux_ysel VDDP VDDPI VDDPI_RL VSS VBP VBN ND_SELB ND_WB ND_WT
+ QTI SELB WB WT LQB IV_SELB IV_WB IV_WT LYSEL PDB QB QT WBI WTI
XI70 VDDP VDDPI VSS VBP VBN SELB IV_SELB mm16a05_u_data_drv_ysel
XI73 VDDPI VSS VBP VBN ND_WT LYSEL WTI
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=600n wn2=600n wp1=450n
+ wp2=450n
XI65 VDDPI VSS VBP VBN ND_WB LYSEL WBI
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=600n wn2=600n wp1=450n
+ wp2=450n
XI71 VDDP VDDPI VDDPI_RL VSS VBP VBN QTI LQB PDB QB QT mm16a05_u_resolver_hdsp
XI69 VDDP VDDPI VSS VBP VBN WT IV_WT mm16a05_u_data_drv
XI68 VDDP VDDPI VSS VBP VBN WB IV_WB mm16a05_u_data_drv
XI61 VDDPI VSS VBP VBN ND_SELB LYSEL mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=350n
+ wp=450n
.ends

.subckt mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 VDD VSS VBP VBN X A S0
+ S1 CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=120n wn2=120n wp1=120n wp2=120n
MNA net020 A VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MNS0 X S0 net020 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MPA net16 A VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MPS1 X S1 net16 VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
.ends

.subckt mm16a05_u_l2bio VDDP VDDPI VSS VBP VBN Q QB CB CT DIN
XI7 VDDPI VSS VBP VBN Q QB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=160n wp=160n
XI3 VDDPI VSS VBP VBN QB Q CT CB
+ mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XI11 VDDPI VSS VBP VBN QB DIN CB CT
+ mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2
+ m_n2=2 m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
.ends

.subckt mm16a05_u_dclk_ct_cb_gen VDDPI VSS VBP VBN CB CT DCLK
XI2 VDDPI VSS VBP VBN CB CT mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n wp=160n
XI1 VDDPI VSS VBP VBN CT DCLKB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI0 VDDPI VSS VBP VBN DCLKB DCLK mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=160n
+ wp=160n
.ends

.subckt mm16a05_u_di_dft_plus VDDP VDDPI VSS VBP VBN CB CT LDIB LWIB WBI WTI
+ LQB SEB SET DCLKT DIB WIB
XD VDDP VDDPI VSS VBP VBN LDIB WTI CB CT DIB mm16a05_u_l2bio
XW VDDP VDDPI VSS VBP VBN LWIB WBI CB CT WIB mm16a05_u_l2bio
XI51 VDDPI VSS VBP VBN CB CT DCLKT mm16a05_u_dclk_ct_cb_gen
.ends

.subckt mm16a05_u_output_drv_gf22 VDDP VDDPI VSS VBP VBN Q_OUT Q_IN
XI4 VDDPI VSS VBP VBN Q_OUT Q_IN mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1 wn=220n
+ wp=315n
.ends

.subckt mm16a05_u_latch_lqb VDDP VDDPI VSS VBP VBN LQB LQB_N[0] LQB_N[1]
+ LQB_P[0] LQB_P[1]
M58 VDDP LQB_P[1] net5 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=400n
+ m=1
MI77 net5 LQB_P[0] net6 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=400n
+ m=1
M1 net6 IFF LQB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=400n m=1
MI79 net7 LQB_N[0] net8 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
M5 net8 LQB_N[1] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
M4 LQB IFF net7 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
XI31 VDDPI VSS VBP VBN IFF LQB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
.ends

.subckt mm16a05_u_do_hdsp VDDP VDDPI VDDPI_DR VSS VBP VBN DIB_LT D_AL Q WEM_AL
+ WIB LQB DCLKT DIN DINB LDFTYBUF LQB_N[0] LQB_N[1] LQB_P[0] LQB_P[1] SEB SET
+ WEM WEMB
XI16 VDDPI VSS VBP VBN DWEMT DINB WEMH
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=206n wn2=206n wp1=120n
+ wp2=120n
XI69 VDDPI VSS VBP VBN DWEMB DINT WEMH
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=206n wn2=206n wp1=120n
+ wp2=120n
XI65 VDDP VDDPI VSS VBP VBN Q LQB mm16a05_u_output_drv_gf22
XI57 VDDPI VSS VBP VBN LDFTYBUFB LDFTYBUF mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=220n
XI59 VDDPI VSS VBP VBN WEM_AL WEM mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI61 VDDPI VSS VBP VBN WEMH WEMB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI4 VDDPI VSS VBP VBN D_AL DIN mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI70 VDDPI VSS VBP VBN DINT DINB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI68 VDDPI VSS VBP VBN WIB DIB_LT LDFTYBUF LDFTYBUFB
+ mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=220n wp2=220n
XI63 VDDPI VSS VBP VBN WIB DWEMB LDFTYBUFB LDFTYBUF
+ mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=220n wp2=220n
XI207 VDDPI VSS VBP VBN DIB_LT DWEMT SEB SET
+ mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=220n wp2=220n
XLQB VDDP VDDPI VSS VBP VBN LQB LQB_N[0] LQB_N[1] LQB_P[0] LQB_P[1]
+ mm16a05_u_latch_lqb
.ends

.subckt mm16a05_u_gio8_hdsp_plus VDDP VDDPI VDDPI_DR VDDPI_RL VSS VBP VBN CB CT
+ D_AL LDIB LQB LWIB ND_SEL[0] ND_SEL[1] ND_WB[0] ND_WB[1] ND_WT[0] ND_WT[1] Q
+ SEL[0] SEL[1] WB[0] WB[1] WEM_AL WT[0] WT[1] DIB LOG0 LOG1 DCLKT DIN DINB
+ IV_SEL[0] IV_SEL[1] IV_WB[0] IV_WB[1] IV_WT[0] IV_WT[1] LDFTYBUF LYB[0]
+ LYB[1] PDB QB[0] QB[1] QT[0] QT[1] SEB SET WEM WEMB
XSEL1 VDDP VDDPI VSS VBP VBN LYSELFF LQB WBI WTI LYB[0] LOG0 mm16a05_u_we_ysel
XSEL0 VDDP VDDPI VSS VBP VBN LYSEL0 LQB WBI WTI LYT[0] LOG0 mm16a05_u_we_ysel
XM VDDP VDDPI VDDP VSS VBP VBN ND_SEL[1] ND_WB[1] ND_WT[1] QTI[1] SEL[1] WB[1]
+ WT[1] LQB IV_SEL[1] IV_WB[1] IV_WT[1] LYSELFF PDB QB[1] QT[1] WBI WTI
+ mm16a05_u_xmux_ysel
X0 VDDP VDDPI VDDP VSS VBP VBN ND_SEL[0] ND_WB[0] ND_WT[0] QTI[0] SEL[0] WB[0]
+ WT[0] LQB IV_SEL[0] IV_WB[0] IV_WT[0] LYSEL0 PDB QB[0] QT[0] WBI WTI
+ mm16a05_u_xmux_ysel
XDI VDDP VDDPI VSS VBP VBN CB CT LDIB LWIB net230 net229 LQB SEB SET DCLKT DIB
+ net228 mm16a05_u_di_dft_plus
XDO VDDP VDDPI VDDPI_DR VSS VBP VBN DIB D_AL Q WEM_AL net228 LQB DCLKT DIN DINB
+ LDFTYBUF QT[0] QT[1] QTI[0] QTI[1] SEB SET WEM WEMB mm16a05_u_do_hdsp
XI29 VDDPI VSS VBP VBN WBI net230 mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI64 VDDPI VSS VBP VBN WTI net229 mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
Xlyt[0] VDDPI VSS VBP VBN LYT[0] LYB[0] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
Xlyt[1] VDDPI VSS VBP VBN LYT[1] LYB[1] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
.ends

.subckt mm16a05_u_hdsp_plus_giom8x1 VDDP VDDPI VDDPI_DR VDDPI_RL VSS VBP VBN CB
+ CT D_AL LDIB LQB LWIB ND_SEL[0] ND_SEL[1] ND_WB[0] ND_WB[1] ND_WT[0] ND_WT[1]
+ Q SEL[0] SEL[1] WB[0] WB[1] WEM_AL WT[0] WT[1] DIB LOG0 LOG1 LYB[0] LYB[1]
+ QB[0] QB[1] QT[0] QT[1] D DCLKT DINB DLYPDB IV_SEL[0] IV_SEL[1] IV_WB[0]
+ IV_WB[1] IV_WT[0] IV_WT[1] LDFTYBUF SE_DB SE_DT WEM WEMB
Xgio_0 VDDP VDDPI VDDPI_DR VDDPI_RL VSS VBP VBN CB CT D_AL LDIB LQB LWIB
+ ND_SEL[0] ND_SEL[1] ND_WB[0] ND_WB[1] ND_WT[0] ND_WT[1] Q SEL[0] SEL[1] WB[0]
+ WB[1] WEM_AL WT[0] WT[1] DIB LOG0 LOG1 DCLKT D DINB IV_SEL[0] IV_SEL[1]
+ IV_WB[0] IV_WB[1] IV_WT[0] IV_WT[1] LDFTYBUF LYB[0] LYB[1] DLYPDB QB[0] QB[1]
+ QT[0] QT[1] SE_DB SE_DT WEM WEMB mm16a05_u_gio8_hdsp_plus
Mdcgate net118 DCLKT net118 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=5
.ends

.subckt mm16a05_u_pg_arysd_buf_dr VDDA VSS VBP VBN ARYSD ARYSD_BC1 ARYSD_BC2
+ ARYSDB ARYSDB_BC1 ARYSDB_BC2 SDCLPSB
XI12 VDDA VSS VBP VBN ARYSD ARYSDB_SDCLPSB mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1
+ wn=430n wp=430n
XI9 VDDA VSS VBP VBN ARYSD_BC1 ARYSDB_BC1 mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=320n wp=320n
XI11 VDDA VSS VBP VBN ARYSD_BC2 ARYSDB_BC2 mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=320n wp=320n
XI17 VDDA VSS VBP VBN ARYSDB_SDCLPSB ARYSDB SDCLPSB
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=320n
+ wp2=320n
.ends

.subckt mm16a05_u_hdsp_plus_gcenbuf_dr VDDA VDDP VDDPI VSS VBP VBN DCLKT LYB[0]
+ LYB[1] RASSIST[0] RASSIST[1] ARYSD ARYSDB ARYSDB_BC1 ARYSDB_BC2 ARYSD_BC1
+ ARYSD_BC2 DLYPDB GSE_DB GSE_DT LDFTYBUF LOG0 LOG1 LCLKBIO LY[0] LY[1]
+ LYADR[2] LYADR[3] RAB[0] RAB[1] SDCLPSB
XDCLKT VDDPI VSS VBP VBN net137 LCLKBIO mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=400n
+ wp=400n
XDCLK VDDPI VSS VBP VBN DCLKT net137 mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1 wn=400n
+ wp=600n
XINV_LY[0] VDDPI VSS VBP VBN LYB[0] LY[0] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=5 m_p=5 nf_n=1 nf_p=1
+ wn=400n wp=600n
XINV_LY[1] VDDPI VSS VBP VBN LYB[1] LY[1] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=5 m_p=5 nf_n=1 nf_p=1
+ wn=400n wp=600n
XIRA[0] VDDPI VSS VBP VBN RASSIST[0] RAB[0] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=400.0n wp=400.0n
XIRA[1] VDDPI VSS VBP VBN RASSIST[1] RAB[1] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=400.0n wp=400.0n
XIPG_ARYSD_BUF VDDA VSS VBP VBN ARYSD ARYSD_BC1 ARYSD_BC2 ARYSDB ARYSDB_BC1
+ ARYSDB_BC2 SDCLPSB mm16a05_u_pg_arysd_buf_dr
.ends

.subckt mm16a05_u_inv_bulk_n_vt3_p_vt3 VDD VSS VBP VBN X A CPP=104n P_LA_n=4n
+ P_LA_p=4n ULP=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=758n wp=1092n
MNA X A VSS VBN slvtnfet cpp=cpp p_la=p_la_n ulp=ulp nf=nf_n l=ln w=wn m=m_n
MPA X A VDD VBP slvtpfet cpp=cpp p_la=p_la_p ulp=ulp nf=nf_p l=lp w=wp m=m_p
.ends

.subckt mm16a05_u_tg_bulk_n_vt2_p_vt2 VBP VBN A B S SB CPP=104n P_LA_n=4n
+ P_LA_p=4n ULP=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=320n wp=320n
MNS A S B VBN slvtnfet cpp=cpp p_la=p_la_n ulp=ulp nf=nf_n l=ln w=wn m=m_n
MPSB A SB B VBP slvtpfet cpp=cpp p_la=p_la_p ulp=ulp nf=nf_p l=lp w=wp m=m_p
.ends

.subckt mm16a05_u_pg_lsltch_sp VDDP VDDPI VSS VBP VBN LITESLP RWLCKB LS RFLOAT
+ WFLOAT
XI27 VDDPI VSS VBP VBN LDPB LDP RWLCKT RWLCKB
+ mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XI23 VDDPI VSS VBP VBN LSB LS mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=283.0n wp=283.0n
XI3 VDDPI VSS VBP VBN LDP LDPB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI26 VDDP VSS VBP VBN RWLCKB RWLCKT mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=280.0n
+ wp=280.0n
XI32 VDDPI VSS VBP VBN LITESLP LDPB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=5 m_p=5 nf_n=1 nf_p=1 wn=280n
+ wp=280n
XI1 VDDPI VSS VBP VBN RWLCKT RFLOAT mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=280n
+ wp=280n
XI33 VBP VBN LSB LDPB RWLCKB RWLCKT mm16a05_u_tg_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
.ends

.subckt mm16a05_u_rm4to1 VDDP VDDPI VSS VBP VBN AT BT CT DT A B C D SEL[0]
+ SEL[1]
*XI8 VBP VBN net39 mm16a05_u_init1
*XI9 VBP VBN net40 mm16a05_u_init0
XI1 VBP VBN B BT SEL[1] SEL[0] mm16a05_u_tg_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
XI0 VBP VBN A AT SEL[1] SEL[0] mm16a05_u_tg_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
XI2 VBP VBN C CT SEL[1] SEL[0] mm16a05_u_tg_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
XI3 VBP VBN D DT SEL[1] SEL[0] mm16a05_u_tg_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
.ends

.subckt mm16a05_u_blatch_rm VDDPI VNWP VSS VBP VBN OUT OUTB CB CT IN
XI0 VDDPI VSS VBP VBN OUTB IN CB CT
+ mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XI1 VDDPI VSS VBP VBN OUTB OUT CT CB
+ mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
*XI39 VBP VBN OUTB mm16a05_u_init1
XI2 VDDPI VSS VBP VBN OUT OUTB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
.ends

.subckt mm16a05_u_rmmx VDDP VDDPI VSS VBP VBN QB A BCB BCT TA
XA VDDPI VSS VBP VBN QB A BCB BCT
+ mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n
+ wp1=240n wp2=240n
XTA VDDPI VSS VBP VBN QB TA BCT BCB
+ mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n
+ wp1=240n wp2=240n
.ends

.subckt mm16a05_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 VDD VSS
+ VBP VBN X A1 A2 A3 CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_n3=4n P_LA_p1=4n
+ P_LA_p2=4n P_LA_p3=4n ULP=0 ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n
+ m_n1=1 m_n2=1 m_n3=1 m_p1=1 m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1
+ nf_p2=1 nf_p3=1 wn1=120n wn2=120n wn3=120n wp1=120n wp2=120n wp3=120n
MNA1 X A1 net19 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 net19 A2 net018 VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2
+ w=wn2 m=m_n2
MNA3 net018 A3 VSS VBN slvtnfet cpp=cpp p_la=p_la_n3 ulp=ulp nf=nf_n3 l=ln3
+ w=wn3 m=m_n3
MPA1 X A1 VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MPA3 X A3 VDD VBP slvtpfet cpp=cpp p_la=p_la_p3 ulp=ulp nf=nf_p3 l=lp3 w=wp3
+ m=m_p3
MPA2 X A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
.ends

.subckt mm16a05_u_hdsp_rm2to4_procom_change1_plus VDDP VDDPI VSS VBP VBN
+ SEL_RM0 SEL_RM0123 SEL_RM0B SEL_RM1 SEL_RM1B SEL_RM2 SEL_RM2B SEL_RM3
+ SEL_RM3B SEL_RM4 SEL_RM5 LOG0 LOG1 LCLKB LCLKT RM[0] RM[1] RM[2] RME RMENI[0]
+ RMENI[1] RMENI[2]
XLRM1 VDDPI VDDP VSS VBP VBN LRMB[1] LRM[1] LCLKB LCLKT RM_RMI[1]
+ mm16a05_u_blatch_rm
XLRM0 VDDPI VDDP VSS VBP VBN LRMB[0] LRM[0] LCLKB LCLKT RM_RMI[0]
+ mm16a05_u_blatch_rm
XLRM2 VDDPI VDDP VSS VBP VBN LRMB[2] LRM[2] LCLKB LCLKT RM_RMI[2]
+ mm16a05_u_blatch_rm
XIRM_RMI0 VDDP VDDPI VSS VBP VBN RM_RMI[0] RM[0] RME RMEB RMENI[0]
+ mm16a05_u_rmmx
XIRM_RMI1 VDDP VDDPI VSS VBP VBN RM_RMI[1] RM[1] RME RMEB RMENI[1]
+ mm16a05_u_rmmx
XIRM_RMI2 VDDP VDDPI VSS VBP VBN RM_RMI[2] RM[2] RME RMEB RMENI[2]
+ mm16a05_u_rmmx
MI57 net163 LRMB[0] SEL_RM5 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=320n m=1
MI58 net163 LRMB[1] SEL_RM5 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=320n m=1
MPA VDDPI LRMB[2] net163 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
MNA SEL_RM5 LRMB[1] net169 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=320n m=1
MI56 SEL_RM5 LRMB[2] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
MI55 net169 LRMB[0] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
XI78 VDDPI VSS VBP VBN SEL_RM1B LRM[0] LRMB[1] LRMB[2]
+ mm16a05_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=320n
+ wn2=320n wn3=320n wp1=320n wp2=320n wp3=320n
XI79 VDDPI VSS VBP VBN SEL_RM0B LRMB[0] LRMB[1] LRMB[2]
+ mm16a05_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=320n
+ wn2=320n wn3=320n wp1=320n wp2=320n wp3=320n
XI71 VDDPI VSS VBP VBN SEL_RM2B LRMB[0] LRM[1] LRMB[2]
+ mm16a05_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=320n
+ wn2=320n wn3=320n wp1=320n wp2=320n wp3=320n
XI76 VDDPI VSS VBP VBN SEL_RM4B LRM[2] LRMB[1] LRMB[0]
+ mm16a05_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=320n
+ wn2=320n wn3=320n wp1=320n wp2=320n wp3=320n
XI80 VDDPI VSS VBP VBN SEL_RM3B SEL_RM3 mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=320n
Xnr2_ckdel1 VDDPI VSS VBP VBN SEL_RM0123 LRM[2] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI74 VDDPI VSS VBP VBN SEL_RM4 SEL_RM4B mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI4 VDDPI VSS VBP VBN SEL_RM0 SEL_RM0B mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI61 VDDPI VSS VBP VBN RMEB RME mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI68 VDDPI VSS VBP VBN SEL_RM1 SEL_RM1B mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI72 VDDPI VSS VBP VBN SEL_RM2 SEL_RM2B mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI69 VDDPI VSS VBP VBN SEL_RM3 LRMB[2] net234
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=320n
+ wp2=320n
XI81 VDDPI VSS VBP VBN net234 LRM[0] LRM[1]
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=320n
+ wp2=320n
.ends

.subckt mm16a05_u_rm4to1_pmos VDDP VBP VBN AT BT CT DT A B C D SELB[1]
MI5 A SELB[1] AT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M2 D SELB[1] DT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M1 C SELB[1] CT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M0 B SELB[1] BT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
.ends

.subckt mm16a05_u_hdsp_plus_rm_wm_ctrl_procom_change VDDP VDDPI VDDMINB VSS VBP
+ VBN DEF1 DEF1B DEF2 DEF2B DEF_MODE FAST1_MODE FAST2_MODE RT[0] RT[1] RT[2]
+ RT[3] WT[0] WT[1] WT[2] WT[3] LOG0 LOG1 DEF12B_PROG DEF12_PROG DEF_PROG LCLKB
+ LCLKT RM[0] RM[1] RM[2] RMDEF1[0] RMDEF1[1] RMDEF1[2] RMDEF1[3] RMDEF2[0]
+ RMDEF2[1] RMDEF2[2] RMDEF2[3] RME RMENI[0] RMENI[1] RMENI[2] RMSLOW[0]
+ RMSLOW[1] RMSLOW[2] RMSLOW[3] WMDEF1[0] WMDEF1[1] WMDEF1[2] WMDEF1[3]
+ WMDEF2[0] WMDEF2[1] WMDEF2[2] WMDEF2[3] WMSLOW[0] WMSLOW[1] WMSLOW[2]
+ WMSLOW[3]
XI121 VDDP VDDPI VSS VBP VBN WT[0] WT[1] WT[2] WT[3] WMDEF1[0] WMDEF1[1]
+ WMDEF1[2] WMDEF1[3] DEF_PROGB DEF_PROG mm16a05_u_rm4to1
XI122 VDDP VDDPI VSS VBP VBN RT[0] RT[1] RT[2] RT[3] RMDEF1[0] RMDEF1[1]
+ RMDEF1[2] RMDEF1[3] DEF_PROGB DEF_PROG mm16a05_u_rm4to1
XI59 VDDP VDDPI VSS VBP VBN WT[0] WT[1] WT[2] WT[3] WMSLOW[0] WMSLOW[1]
+ WMSLOW[2] WMSLOW[3] SLOWB SLOW mm16a05_u_rm4to1
XI58 VDDP VDDPI VSS VBP VBN WT[0] WT[1] WT[2] WT[3] WMDEF2[0] WMDEF2[1]
+ WMDEF2[2] WMDEF2[3] DEF12B_PROG DEF12_PROG mm16a05_u_rm4to1
XI53 VDDP VDDPI VSS VBP VBN RT[0] RT[1] RT[2] RT[3] RMSLOW[0] RMSLOW[1]
+ RMSLOW[2] RMSLOW[3] SLOWB SLOW mm16a05_u_rm4to1
XRMD VDDP VDDPI VSS VBP VBN RT[0] RT[1] RT[2] RT[3] RMDEF2[0] RMDEF2[1]
+ RMDEF2[2] RMDEF2[3] DEF12B_PROG DEF12_PROG mm16a05_u_rm4to1
XIRM_MUX VDDP VDDPI VSS VBP VBN VDDMIN DEF_MODE VDDMINB SLOW SLOWB DEF2 DEF2B
+ DEF1 DEF1B FAST1_MODE FAST2_MODE LOG0 LOG1 LCLKB LCLKT RM[0] RM[1] RM[2] RME
+ RMENI[0] RMENI[1] RMENI[2] mm16a05_u_hdsp_rm2to4_procom_change1_plus
XI123 VDDPI VSS VBP VBN DEF_PROGB DEF_PROG mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI57 VDDP VBP VBN WT[0] WT[1] WT[2] WT[3] VDDPI VDDPI VDDPI VDDPI VDDMINB
+ mm16a05_u_rm4to1_pmos
XI52 VDDP VBP VBN RT[0] RT[1] RT[2] RT[3] VDDPI VDDPI VDDPI VDDPI VDDMINB
+ mm16a05_u_rm4to1_pmos
.ends

.subckt mm16a05_u_hdsp_plus_rm_wm_ctrl_base VDDP VDDPI VDDMINB VSS VBP VBN DEF1
+ DEF1B DEF2 DEF2B DEF_MODE FAST1_MODE FAST2_MODE RMT[0] RMT[1] RMT[2] RMT[3]
+ WMT[0] WMT[1] WMT[2] WMT[3] LOG0 LOG1 DEF12B_PROG DEF12_PROG DEF_PROG FLOAT
+ RM[0] RM[1] RM[2] RMDEF1[0] RMDEF1[1] RMDEF1[2] RMDEF1[3] RMDEF2[0] RMDEF2[1]
+ RMDEF2[2] RMDEF2[3] RME RMENI[0] RMENI[1] RMENI[2] RMSLOW[0] RMSLOW[1]
+ RMSLOW[2] RMSLOW[3] WMDEF1[0] WMDEF1[1] WMDEF1[2] WMDEF1[3] WMDEF2[0]
+ WMDEF2[1] WMDEF2[2] WMDEF2[3] WMSLOW[0] WMSLOW[1] WMSLOW[2] WMSLOW[3]
XRM VDDP VDDPI VDDMINB VSS VBP VBN DEF1 DEF1B DEF2 DEF2B DEF_MODE FAST1_MODE
+ FAST2_MODE RMB[0] RMB[1] RMB[2] RMB[3] WMB[0] WMB[1] WMB[2] WMB[3] LOG0 LOG1
+ DEF12B_PROG DEF12_PROG DEF_PROG LCLKB LCLKT RM[0] RM[1] RM[2] RMDEF1[0]
+ RMDEF1[1] RMDEF1[2] RMDEF1[3] RMDEF2[0] RMDEF2[1] RMDEF2[2] RMDEF2[3] RME
+ RMENI[0] RMENI[1] RMENI[2] RMSLOW[0] RMSLOW[1] RMSLOW[2] RMSLOW[3] WMDEF1[0]
+ WMDEF1[1] WMDEF1[2] WMDEF1[3] WMDEF2[0] WMDEF2[1] WMDEF2[2] WMDEF2[3]
+ WMSLOW[0] WMSLOW[1] WMSLOW[2] WMSLOW[3]
+ mm16a05_u_hdsp_plus_rm_wm_ctrl_procom_change
XRMT3 VDDPI VSS VBP VBN LCLKB LCLKT mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI63[0] VDDPI VSS VBP VBN WMT[0] WMB[0] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI63[1] VDDPI VSS VBP VBN WMT[1] WMB[1] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI63[2] VDDPI VSS VBP VBN WMT[2] WMB[2] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI63[3] VDDPI VSS VBP VBN WMT[3] WMB[3] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XRMB3 VDDPI VSS VBP VBN LCLKT FLOAT mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI58[0] VDDPI VSS VBP VBN RMT[0] RMB[0] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI58[1] VDDPI VSS VBP VBN RMT[1] RMB[1] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI58[2] VDDPI VSS VBP VBN RMT[2] RMB[2] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI58[3] VDDPI VSS VBP VBN RMT[3] RMB[3] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=160n
+ wp=160n
.ends

.subckt mm16a05_u_hdsp_plus_rmctrl VDDP VDDPI VDDMINB VSS VBP VBN DEF1 DEF1B
+ DEF2 DEF2B DEF_MODE FAST1_MODE FAST2_MODE RM3_CORE_CNT RMT[0] RMT[1] RMT[2]
+ RMT[3] WMT[0] WMT[1] WMT[2] WMT[3] LOG0 LOG1 LOG1_RM BC0 DEF12B_PROG
+ DEF12_PROG DEF_PROG FLOAT LSDB RM[0] RM[1] RM[2] RM[3] RMDEF1[0] RMDEF1[1]
+ RMDEF1[2] RMDEF1[3] RMDEF2[0] RMDEF2[1] RMDEF2[2] RMDEF2[3] RME RMENI[0]
+ RMENI[1] RMENI[2] RMSLOW[0] RMSLOW[1] RMSLOW[2] RMSLOW[3] WMDEF1[0] WMDEF1[1]
+ WMDEF1[2] WMDEF1[3] WMDEF2[0] WMDEF2[1] WMDEF2[2] WMDEF2[3] WMSLOW[0]
+ WMSLOW[1] WMSLOW[2] WMSLOW[3]
XI43 VDDP VSS VBP VBN RM3_CORE_CNT net39 mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI53 VDDP VSS VBP VBN net39 BC0 LSDB
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=240n
+ wp2=240n
XRM net181 VDDPI VDDMINB VSS VBP VBN DEF1 DEF1B DEF2 DEF2B DEF_MODE FAST1_MODE
+ FAST2_MODE RMT[0] RMT[1] RMT[2] RMT[3] WMT[0] WMT[1] WMT[2] WMT[3] LOG0 LOG1
+ DEF12B_PROG DEF12_PROG DEF_PROG FLOAT RM[0] RM[1] RM[2] RMDEF1[0] RMDEF1[1]
+ RMDEF1[2] RMDEF1[3] RMDEF2[0] RMDEF2[1] RMDEF2[2] RMDEF2[3] RME RMENI[0]
+ RMENI[1] RMENI[2] RMSLOW[0] RMSLOW[1] RMSLOW[2] RMSLOW[3] WMDEF1[0] WMDEF1[1]
+ WMDEF1[2] WMDEF1[3] WMDEF2[0] WMDEF2[1] WMDEF2[2] WMDEF2[3] WMSLOW[0]
+ WMSLOW[1] WMSLOW[2] WMSLOW[3] mm16a05_u_hdsp_plus_rm_wm_ctrl_base
MI87 VDDP LOG0 LOG1_RM VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=360n
+ m=2
.ends

.subckt mm16a05_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=120n wn2=120n wp1=360n wp2=360n
MNA1 X A1 VSS VBN lvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 X A2 VSS VBN lvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MPA2 net10 A2 VDD VBP lvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
MPA1 X A1 net10 VBP lvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
.ends

.subckt mm16a05_u_inv_bulk_n_vt1_p_vt1 VDD VSS VBP VBN X A CPP=104n P_LA_n=4n
+ P_LA_p=4n ULP=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=758n wp=1092n
MNA X A VSS VBN lvtnfet cpp=cpp p_la=p_la_n ulp=ulp nf=nf_n l=ln w=wn m=m_n
MPA X A VDD VBP lvtpfet cpp=cpp p_la=p_la_p ulp=ulp nf=nf_p l=lp w=wp m=m_p
.ends

.subckt mm16a05_u_bc_control_hdsp VDDP VSS VBP VBN LSDB LSDB_BC1 LSDB_BC2 LOG1
+ BC1 BC2 SD
XI0[0] VDDP VSS VBP VBN LSDB_BC2 BC2B SD
+ mm16a05_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI0[1] VDDP VSS VBP VBN LSDB_BC2 BC2B SD
+ mm16a05_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI1[0] VDDP VSS VBP VBN LSDB_BC1 BC1B SD
+ mm16a05_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI1[1] VDDP VSS VBP VBN LSDB_BC1 BC1B SD
+ mm16a05_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI22 VDDP_SD VSS VBP VBN BC1B BC1 BCB12
+ mm16a05_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=240n
+ wp2=240n
XI20 VDDP_SD VSS VBP VBN BCB12 BC1 BC2
+ mm16a05_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=240n
+ wp2=240n
XI21 VDDP_SD VSS VBP VBN BC2B LOG1 BCB12
+ mm16a05_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=240n
+ wp2=240n
XI18 VDDP VSS VBP VBN LSDB SD mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
M9 VDDP SD VDDP_SD VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=2
.ends

.subckt mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 VDD VSS VBP VBN X A S0
+ S1 CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=120n wn2=120n wp1=120n wp2=120n
MNA net020 A VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MNS0 X S0 net020 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MPA net16 A VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MPS1 X S1 net16 VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
.ends

.subckt mm16a05_u_hdsp_plus_blatch_addr_vt2 VDDPI VSS VBP VBN OUT OUTB CB CT IN
*XI5 VBP VBN OUTB mm16a05_u_init0
XI2 VDDPI VSS VBP VBN OUT OUTB mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=0
+ p_la_p=0 ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1 wn=283n wp=283n
*XI6 OUTB mm16a05_u_lat_int_node
*XI8 VBP VBN OUTB VDDPI mm16a05_u_lat_set_op_pfv
XI17 VDDPI VSS VBP VBN OUTB IN CB CT
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=0 p_la_n2=0
+ p_la_p1=0 p_la_p2=0 ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=174n wn2=174n wp1=174n
+ wp2=174n
XI1 VDDPI VSS VBP VBN OUTB OUT CT CB
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=0 p_la_n2=0
+ p_la_p1=0 p_la_p2=0 ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=174n wn2=174n wp1=174n
+ wp2=174n
XI0 VDDPI VSS VBP VBN OUTB IN CB CT
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=0 p_la_n2=0
+ p_la_p1=0 p_la_p2=0 ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=174n wn2=174n wp1=174n
+ wp2=174n
.ends

.subckt mm16a05_u_hdsp_plus_blatch_addr_vt4 VDDP VDDPI VSS VBP VBN OUT OUTB CB
+ CT IN
*XI5 VBP VBN OUTB mm16a05_u_init0
XI2 VDDPI VSS VBP VBN OUT OUTB mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=0
+ p_la_p=0 ulp=0 ln=20n lp=20n m_n=5 m_p=5 nf_n=1 nf_p=1 wn=283n wp=283n
*XI6 OUTB mm16a05_u_lat_int_node
*XI8 VBP VBN OUTB VDDPI mm16a05_u_lat_set_op_pfv
XI0_1 VDDPI VSS VBP VBN OUTB IN CB CT
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=0 p_la_n2=0
+ p_la_p1=0 p_la_p2=0 ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=174n wn2=174n wp1=174n
+ wp2=174n
XI0 VDDPI VSS VBP VBN OUTB IN CB CT
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=0 p_la_n2=0
+ p_la_p1=0 p_la_p2=0 ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=174n wn2=174n wp1=174n
+ wp2=174n
XI11 VDDPI VSS VBP VBN OUTB OUT CT CB
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=0 p_la_n2=0
+ p_la_p1=0 p_la_p2=0 ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=174n wn2=174n wp1=174n
+ wp2=174n
.ends

.subckt mm16a05_u_hdsp_plus_adr_latches_cm16bk8 VDDP VDDPI VSS VBP VBN
+ LBKADR[0] LBKADR[1] LBKADR[2] LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+ LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] LYADR[2] LYADR[3] LYADRB[2]
+ LYADRB[3] BKADRA[0] BKADRA[1] BKADRA[2] CLKB CLKI XADRA[0] XADRA[1] XADRA[2]
+ XADRA[3] XADRA[4] XADRA[5] XADRA[6] XADRA[7] YADRA[0] YADRA[1] YADRA[2]
+ YADRA[3]
XYADR[2] VDDPI VSS VBP VBN LYADR[2] LYADRB[2] CLKB CLKI YADRA[2]
+ mm16a05_u_hdsp_plus_blatch_addr_vt2
XYADR[3] VDDPI VSS VBP VBN LYADR[3] LYADRB[3] CLKB CLKI YADRA[3]
+ mm16a05_u_hdsp_plus_blatch_addr_vt2
XBKADDR[0] VDDP VDDPI VSS VBP VBN LBKADR[0] LBKADRQB[0] CLKB CLKI BKADRA[0]
+ mm16a05_u_hdsp_plus_blatch_addr_vt4
XBKADDR[1] VDDP VDDPI VSS VBP VBN LBKADR[1] LBKADRQB[1] CLKB CLKI BKADRA[1]
+ mm16a05_u_hdsp_plus_blatch_addr_vt4
XRADR[0] VDDP VDDPI VSS VBP VBN LXADR[0] LXADRQB[0] CLKB CLKI XADRA[0]
+ mm16a05_u_hdsp_plus_blatch_addr_vt4
XRADR[1] VDDP VDDPI VSS VBP VBN LXADR[1] LXADRQB[1] CLKB CLKI XADRA[1]
+ mm16a05_u_hdsp_plus_blatch_addr_vt4
XRADR[2] VDDP VDDPI VSS VBP VBN LXADR[2] LXADRQB[2] CLKB CLKI XADRA[2]
+ mm16a05_u_hdsp_plus_blatch_addr_vt4
XRADR[3] VDDP VDDPI VSS VBP VBN LXADR[3] LXADRQB[3] CLKB CLKI XADRA[3]
+ mm16a05_u_hdsp_plus_blatch_addr_vt4
XRADR[4] VDDP VDDPI VSS VBP VBN LXADR[4] LXADRQB[4] CLKB CLKI XADRA[4]
+ mm16a05_u_hdsp_plus_blatch_addr_vt4
XRADR[5] VDDP VDDPI VSS VBP VBN LXADR[5] LXADRQB[5] CLKB CLKI XADRA[5]
+ mm16a05_u_hdsp_plus_blatch_addr_vt4
XRADR[6] VDDP VDDPI VSS VBP VBN LXADR[6] LXADRQB[6] CLKB CLKI XADRA[6]
+ mm16a05_u_hdsp_plus_blatch_addr_vt4
XRADR[7] VDDP VDDPI VSS VBP VBN LXADR[7] LXADRQB[7] CLKB CLKI XADRA[7]
+ mm16a05_u_hdsp_plus_blatch_addr_vt4
XYADR[0] VDDP VDDPI VSS VBP VBN LYADR[0] LYADRQB[0] CLKB CLKI YADRA[0]
+ mm16a05_u_hdsp_plus_blatch_addr_vt4
XYADR[1] VDDP VDDPI VSS VBP VBN LYADR[1] LYADRQB[1] CLKB CLKI YADRA[1]
+ mm16a05_u_hdsp_plus_blatch_addr_vt4
XI17 VDDP VDDPI VSS VBP VBN LBKADR[2] LBKADRQB[2] CLKB CLKI BKADRA[2]
+ mm16a05_u_hdsp_plus_blatch_addr_vt4
.ends

.subckt mm16a05_u_hdsp_plus_tclk VDDP VDDPI VSS VBP VBN FLOAT T1T TCLKB
Xinv_tckrd[0] VDDPI VSS VBP VBN TCK TCLKB T1T
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=240n
+ wp2=240n
Xinv_tckrd[1] VDDPI VSS VBP VBN TCK TCLKB T1T
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=240n
+ wp2=240n
M8 net33 TCK FLOAT VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=200n m=4
M7 net29 T1T net33 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=400n m=2
M6 VSS net28 net29 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=400n m=2
MP_trd VDDP TCK FLOAT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=960n m=4
XI5 VDDPI VSS VBP VBN net28 FLOAT mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=240n
.ends

.subckt mm16a05_u_latch_pass VDDP VDDPI VSS VBP VBN Q QB A CB CT
Xinv_lat1 VDDPI VSS VBP VBN QB Q mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
Xinv_feed VDDPI VSS VBP VBN Q QB CT CB
+ mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XI3 VBP VBN A Q CB CT mm16a05_u_tg_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n wp=120n
.ends

.subckt mm16a05_u_lat_pass_new_me VDDP VDDPI VSS VBP VBN Q QB A CB CT
XI3 VBP VBN A Q CB CT mm16a05_u_tg_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n wp=120n
Xinv_lat1 VDDPI VSS VBP VBN QB Q mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
*XI8 Q mm16a05_u_lat_int_node
*XI9 VBP VBN QB VDDPI mm16a05_u_lat_set_op_pfv
Xinv_feed VDDPI VSS VBP VBN Q QB CT CB
+ mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
.ends

.subckt mm16a05_u_hdsp_control_dft VDDP VDDPI VSS VBP VBN CLKB LME LMEWRB LWE
+ LWE_DFT MCLKB MCLKT MEB_LT MEORDFTCLKEN T1T DFTCLKENB CLK DFTCLKEN LCLKB
+ LCLKT LDFTX ME MEB_I TEST1 WE
XI27 VDDPI VSS VBP VBN MEB_LT ME mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=160n
Xinv_web VDDPI VSS VBP VBN WEB WE mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=140n
Xinv_test1 VDDPI VSS VBP VBN TEST1B TEST1 mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=120n wp=180n
Xinv_tclkb VDDPI VSS VBP VBN CLKB CLK mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
Xinv_mclk VDDPI VSS VBP VBN MCLKT MCLKB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1 wn=215n
+ wp=215n
Xinv_mclkb VDDPI VSS VBP VBN MCLKB CLK mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1 wn=215n
+ wp=215n
Xinv_swt VDDPI VSS VBP VBN DFTCLKENB DFTCLKEN mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=160n wp=160n
XI35 VDDPI VSS VBP VBN LWE LWEB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=200n
+ wp=280n
Xnd2_lmewr VDDPI VSS VBP VBN MEORDFTCLKEN DFTCLKENB MEB_I
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=240n
+ wp2=240n
XI20[0] VDDPI VSS VBP VBN LWE_DFT LWEB LDFTX
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=200n
+ wp2=200n
XI20[1] VDDPI VSS VBP VBN LWE_DFT LWEB LDFTX
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=200n
+ wp2=200n
XI20[2] VDDPI VSS VBP VBN LWE_DFT LWEB LDFTX
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=200n
+ wp2=200n
XI20[3] VDDPI VSS VBP VBN LWE_DFT LWEB LDFTX
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=200n
+ wp2=200n
XI15[0] VDDPI VSS VBP VBN T1T TEST1B LDFTX
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=200n
+ wp2=200n
XI15[1] VDDPI VSS VBP VBN T1T TEST1B LDFTX
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=200n
+ wp2=200n
XI15[2] VDDPI VSS VBP VBN T1T TEST1B LDFTX
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=200n
+ wp2=200n
XI15[3] VDDPI VSS VBP VBN T1T TEST1B LDFTX
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=200n
+ wp2=200n
Xlat_wr VDDP VDDPI VSS VBP VBN LWEB net63 WEB LCLKB LCLKT mm16a05_u_latch_pass
Xlat_mewr VDDP VDDPI VSS VBP VBN LMEWRB LME MEB_I MCLKB MCLKT
+ mm16a05_u_lat_pass_new_me
.ends

.subckt mm16a05_u_nr3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 VDD VSS
+ VBP VBN X A1 A2 A3 CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_n3=4n P_LA_p1=4n
+ P_LA_p2=4n P_LA_p3=4n ULP=0 ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n
+ m_n1=1 m_n2=1 m_n3=1 m_p1=1 m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1
+ nf_p2=1 nf_p3=1 wn1=120n wn2=120n wn3=120n wp1=240n wp2=240n wp3=240n
MNA1 X A1 VSS VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA3 X A3 VSS VBN slvtnfet cpp=cpp p_la=p_la_n3 ulp=ulp nf=nf_n3 l=ln3 w=wn3
+ m=m_n3
MNA2 X A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MPA3 net10 A3 VDD VBP slvtpfet cpp=cpp p_la=p_la_p3 ulp=ulp nf=nf_p3 l=lp3
+ w=wp3 m=m_p3
MPA2 net029 A2 net10 VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2
+ w=wp2 m=m_p2
MPA1 X A1 net029 VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
.ends

.subckt mm16a05_u_hdsp_plus_pw_gen VDDP VDDPI VSS VBP VBN PW CLKFLT CLPSEBUF
+ DFTMASK DLYPW FLOAT_RET LS SE_IN
Xnr2_clmp VDDPI VSS VBP VBN LSORDLTPWB DLYPW net313 LS
+ mm16a05_u_nr3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=120n
+ wn2=120n wn3=120n wp1=200n wp2=200n wp3=200n
M12 PW PWB1 CKGDN VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n m=2
M0 net267 CLKFLT net268 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n
+ m=2
M65 net268 FLTBAR net267 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n
+ m=3
M8 VDDPI CLMP net267 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
XI82 VDDPI VSS VBP VBN net313 DFTMASK net310
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=200n wn2=200n wp1=200n
+ wp2=200n
Xnr2_ckdel1 VDDPI VSS VBP VBN CLKDELB CLKFLT CLMP
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=240n
+ wp2=240n
XI73 VDDPI_PWGEN VSS VBP VBN net284 CLPSEBUF mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=160n wp=160n
XI84 VDDPI VSS VBP VBN net310 SE_IN mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
Xinv_ckdel2 VDDP VSS VBP VBN CLKDEL CLKDELB mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=200n
XI40 VDDPI VSS VBP VBN FLTBAR FLOAT_RET mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=240n
Xinv_clmp VDDP VSS VBP VBN CLMP LSORDLTPWB mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XFWD VDDPI VSS VBP VBN PWB1 PW net284
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
*XI38 VBP VBN PW mm16a05_u_init1
MI72 PW CLPSEBUF VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n m=2
Mckdrv pwsvs CLKFLT VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n
+ m=2
M11 PW CLMP VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
Mxback1ck CKGDN CLKDEL VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=160n m=2
MN3 pwsvs FLTBAR PW VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n m=3
M9 net268 PWB1 PW VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n m=2
Mclkpull VDDPI_PWGEN CLKDEL PW VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=160n m=2
MI70 VDDPI CLPSEBUF VDDPI_PWGEN VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=160n m=2
.ends

.subckt mm16a05_u_nd3_bulk_n1_vt4_n2_vt4_n3_vt4_p1_vt4_p2_vt4_p3_vt4 VDD VSS
+ VBP VBN X A1 A2 A3 CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_n3=4n P_LA_p1=4n
+ P_LA_p2=4n P_LA_p3=4n ULP=0 ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n
+ m_n1=1 m_n2=1 m_n3=1 m_p1=1 m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1
+ nf_p2=1 nf_p3=1 wn1=120n wn2=120n wn3=120n wp1=120n wp2=120n wp3=120n
MNA1 X A1 net19 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 net19 A2 net018 VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2
+ w=wn2 m=m_n2
MNA3 net018 A3 VSS VBN slvtnfet cpp=cpp p_la=p_la_n3 ulp=ulp nf=nf_n3 l=ln3
+ w=wn3 m=m_n3
MPA1 X A1 VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MPA3 X A3 VDD VBP slvtpfet cpp=cpp p_la=p_la_p3 ulp=ulp nf=nf_p3 l=lp3 w=wp3
+ m=m_p3
MPA2 X A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
.ends

.subckt mm16a05_u_hdsp_data_latch_clock_gen VDDP VDDPI VSS VBP VBN FLTIO
+ LCLKBIO FLOATBD LS_INT OUT_2INV OUT_4INV OUT_6INV CLKB_LATCH FLOAT IN_2INV
+ IN_4INV IN_6INV LS WE_GATE_CLK
Xnr2_ls VDDPI VSS VBP VBN FLTIO FLOATBD LS_INT
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI42[0] VDDPI VSS VBP VBN LCLKBIO CLKB_LATCH FLOAT FLTIO
+ mm16a05_u_nd3_bulk_n1_vt4_n2_vt4_n3_vt4_p1_vt4_p2_vt4_p3_vt4 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=120n
+ wn2=120n wn3=120n wp1=240n wp2=240n wp3=240n
XI42[1] VDDPI VSS VBP VBN LCLKBIO CLKB_LATCH FLOAT FLTIO
+ mm16a05_u_nd3_bulk_n1_vt4_n2_vt4_n3_vt4_p1_vt4_p2_vt4_p3_vt4 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=120n
+ wn2=120n wn3=120n wp1=240n wp2=240n wp3=240n
.ends

.subckt mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=600n wn2=600n wp1=450n wp2=450n
MPA2 X A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
MPA1 X A1 VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MNA1 X A1 net22 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 net22 A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2
+ w=wn2 m=m_n2
.ends

.subckt mm16a05_u_hdsp_plus_float_gen VDDP VDDPI VSS VBP VBN CKGATE FLOAT CLKB
+ CLPSEBUF DLYPW LDFTX LMEB PW
*XI39 VBP VBN FLOAT mm16a05_u_init1
MI84 LDFTXB LDFTX VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=2
M73 CKGATE PWB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=210n m=4
M58 CKGATE CLKB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=210n m=4
MLPCPLP FLOATB DLYPW VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
MNgate FLOAT CKGATE VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=1680n
+ m=4
MI89 FLOATB FLOAT VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=200n m=1
MI82 FLOATB FLOAT VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=440n m=1
MI78 FLOATB CLPSEBUF VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
M64 NET_B FLOATB VDDP VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=280n m=4
M50 FLOAT CKGATE NET_B VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=280n
+ m=4
MI81 FLOATB FLOAT VDDPI VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=210n
+ m=2
MI85 LDFTXB LDFTX VDDPI VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=560n
+ m=2
M72 NET_A CLKB CKGATE VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=420n m=4
M52 VDDPI PWB NET_A VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=168n m=10
XI74[0] VDDPI VSS VBP VBN MEDFT LDFTXB LMEB
+ mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=160n
+ wp2=160n
XI74[1] VDDPI VSS VBP VBN MEDFT LDFTXB LMEB
+ mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=160n
+ wp2=160n
XI61[0] VDDP VSS VBP VBN PWB PW MEDFT
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=270n wn2=270n wp1=220n
+ wp2=220n
XI61[1] VDDP VSS VBP VBN PWB PW MEDFT
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=270n wn2=270n wp1=220n
+ wp2=220n
XI61[2] VDDP VSS VBP VBN PWB PW MEDFT
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=270n wn2=270n wp1=220n
+ wp2=220n
.ends

.subckt mm16a05_u_nd3_bulk_n1_vt3_n2_vt3_n3_vt3_p1_vt3_p2_vt3_p3_vt3 VDD VSS
+ VBP VBN X A1 A2 A3 CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_n3=4n P_LA_p1=4n
+ P_LA_p2=4n P_LA_p3=4n ULP=0 ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n
+ m_n1=1 m_n2=1 m_n3=1 m_p1=1 m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1
+ nf_p2=1 nf_p3=1 wn1=120n wn2=120n wn3=120n wp1=120n wp2=120n wp3=120n
MNA1 X A1 net19 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 net19 A2 net018 VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2
+ w=wn2 m=m_n2
MNA3 net018 A3 VSS VBN slvtnfet cpp=cpp p_la=p_la_n3 ulp=ulp nf=nf_n3 l=ln3
+ w=wn3 m=m_n3
MPA1 X A1 VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MPA3 X A3 VDD VBP slvtpfet cpp=cpp p_la=p_la_p3 ulp=ulp nf=nf_p3 l=lp3 w=wp3
+ m=m_p3
MPA2 X A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
.ends

.subckt mm16a05_u_hdsp_add_we_latch_clk_gen VDDPI VSS VBP VBN CLKB_LATCH FLTBL
+ LCLKB LCLKT LSB CLKFLT DFTCLKEN FLOAT FLOATB LS
XLSB VDDPI VSS VBP VBN LSB FLOATB LS
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160.0n wn2=160.0n
+ wp1=160.0n wp2=160.0n
Xinv_lclk VDDPI VSS VBP VBN FLT FLTBL mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=280n
+ wp=280n
Xinv_lclkb VDDPI VSS VBP VBN LCLKB FLTBL mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=14 m_p=7 nf_n=1 nf_p=1
+ wn=200n wp=400n
Xinv_lclkt VDDPI VSS VBP VBN LCLKT FLT mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=0 p_la_p=4n ulp=0 ln=20n lp=20n m_n=11 m_p=10 nf_n=1 nf_p=1 wn=280n
+ wp=280n
Xnd2_clkenab VDDPI VSS VBP VBN CLKB_LATCH CLKFLT DFTCLKEN
+ mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=440n wn2=440n wp1=240n
+ wp2=240n
Xnd3_lclk[0] VDDPI VSS VBP VBN FLTBL LSB CLKB_LATCH FLOAT
+ mm16a05_u_nd3_bulk_n1_vt3_n2_vt3_n3_vt3_p1_vt3_p2_vt3_p3_vt3 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=120n
+ wn2=120n wn3=120n wp1=240n wp2=240n wp3=240n
Xnd3_lclk[1] VDDPI VSS VBP VBN FLTBL LSB CLKB_LATCH FLOAT
+ mm16a05_u_nd3_bulk_n1_vt3_n2_vt3_n3_vt3_p1_vt3_p2_vt3_p3_vt3 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=120n
+ wn2=120n wn3=120n wp1=240n wp2=240n wp3=240n
.ends

.subckt mm16a05_u_hdsp_plus_cenclock_dft VDDP VDDPI VSS VBP VBN FLOAT FLOATT
+ FLTBL LCLKB LCLKBIO LCLKT CKGATE FLOATB FLOATBD IN_2INV IN_2INV_ADDR IN_4INV
+ IN_6INV LS_INT OUT_2INV OUT_4INV OUT_6INV CLKB CLKFLT CLPSEBUF DFTCLKEN DLYPW
+ FLOAT_RET LDFTX LMEB LS LS_ONLY SE_IN
Xinv_fltt VDDP VSS VBP VBN FLOATT FLOATB mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=240n wp=120n
XI63 VDDPI VSS VBP VBN FLOATB FLOAT mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XPWGEN VDDP VDDPI VSS VBP VBN PW CLKFLT CLPSEBUF LDFTX DLYPW FLOAT_RET LS_ONLY
+ SE_IN mm16a05_u_hdsp_plus_pw_gen
XIDCLK_GEN VDDP VDDPI VSS VBP VBN FLTIO LCLKBIO FLOATBD LS_INT OUT_2INV
+ OUT_4INV OUT_6INV CLKB_LATCH FLOAT IN_2INV IN_4INV IN_6INV LS net471
+ mm16a05_u_hdsp_data_latch_clock_gen
XIFLOAT_GEN VDDP VDDPI VSS VBP VBN CKGATE FLOAT CLKB CLPSEBUF DLYPW LDFTX LMEB
+ PW mm16a05_u_hdsp_plus_float_gen
XADDR_LATCH_GEN VDDPI VSS VBP VBN CLKB_LATCH FLTBL LCLKB LCLKT net475 CLKFLT
+ DFTCLKEN FLOAT FLOATB LS mm16a05_u_hdsp_add_we_latch_clk_gen
.ends

.subckt mm16a05_u_hdsp_plus_gcen_base VDDP VDDPI VSS VBP VBN CLKB CLKDEL FLOAT
+ FLOATT LBKADR[0] LBKADR[1] LBKADR[2] LCLKB LCLKBIO LCLKT LME LWE LWE_DFT
+ LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+ LYADR[0] LYADR[1] LYADR[2] LYADR[3] MCLKB MCLKT MEB_LT T1T CKGATE DFTCLKEN
+ LDFTX LOG1 MEORDFTCLKEN BKADR[0] BKADR[1] BKADR[2] CLK CLKFLT CLK_MUXB
+ CLPSEBUF DLYPW FLOAT_RET LS ME MEB_I MEORDFTCLKEN_IN SE_IN TEST1 WE XADR[0]
+ XADR[1] XADR[2] XADR[3] XADR[4] XADR[5] XADR[6] XADR[7] YADR[0] YADR[1]
+ YADR[2] YADR[3]
XADDR_LATCH VDDP VDDPI VSS VBP VBN LBKADR[0] LBKADR[1] LBKADR[2] LXADR[0]
+ LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+ LYADR[1] LYADR[2] LYADR[3] LYADRB[2] LYADRB[3] BKADR[0] BKADR[1] BKADR[2]
+ LCLKB LCLKT XADR[0] XADR[1] XADR[2] XADR[3] XADR[4] XADR[5] XADR[6] XADR[7]
+ YADR[0] YADR[1] YADR[2] YADR[3] mm16a05_u_hdsp_plus_adr_latches_cm16bk8
XTCLK_GEN VDDP VDDPI VSS VBP VBN FLOAT T1T TCLKB mm16a05_u_hdsp_plus_tclk
XI108[0] VDDPI VSS VBP VBN LSORMEORDFTCLKEN net190 MEORDFTCLKEN_IN
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160.0n wn2=160.0n
+ wp1=160.0n wp2=160.0n
XI108[1] VDDPI VSS VBP VBN LSORMEORDFTCLKEN net190 MEORDFTCLKEN_IN
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160.0n wn2=160.0n
+ wp1=160.0n wp2=160.0n
XCONTROL VDDP VDDPI VSS VBP VBN TCLKB LME LMEWRB LWE LWE_DFT MCLKB MCLKT MEB_LT
+ MEORDFTCLKEN T1T DFTCLKENB CLKFLT DFTCLKEN LCLKB LCLKT LDFTX ME MEB_I TEST1
+ WE mm16a05_u_hdsp_control_dft
XCLOCK VDDP VDDPI VSS VBP VBN FLOAT FLOATT FLTBL LCLKB LCLKBIO LCLKT CKGATE
+ FLOATB FLOATB FLOATB LOG1 LOG1 LOG1 LSORMEORDFTCLKEN LSORMEORDFTCLKEN net212
+ net211 CLK_MUXB CLKFLT CLPSEBUF DFTCLKEN DLYPW FLOAT_RET LDFTX LMEWRB
+ LSORMEORDFTCLKEN LS SE_IN mm16a05_u_hdsp_plus_cenclock_dft
Xinv_clk VDDPI VSS VBP VBN CLKB CLK mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1 wn=160n
+ wp=240n
Xinv_clkb VDDPI VSS VBP VBN CLKDEL CLKB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=8 nf_n=1 nf_p=1 wn=160n
+ wp=240n
XI106 VDDPI VSS VBP VBN net190 LS mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=200n
+ wp=200n
.ends

.subckt mm16a05_u_hdsp_plus_gcen VDDA VDDF VDDP VDDPI VDDMINB VSS VBP VBN
+ ARYSDB ARYSDB_BC1 ARYSDB_BC2 CLKDEL DEF1 DEF1B DEF2 DEF2B DEF_MODE FAST1_MODE
+ FAST2_MODE LBKADR[0] LBKADR[1] LBKADR[2] LCLKB LCLKBIO LCLKT LITESLP LME LSDB
+ LSDB_BC1 LSDB_BC2 LWE LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+ LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] LYADR[2] LYADR[3] MCLKB MCLKT
+ MEB_LT RAB[0] RAB[1] RM3_CORE_CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLCKB T1T
+ TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0]
+ WPBUF[1] WPBUF[2] CLKB CLPSEBUF FISO FLOAT FLOATT LOG0 LOG1 LOG1_RM
+ MEORDFTCLKEN MEORDFTCLKEN_IN RM3CLPSB RSCEN RSCIN RSCLK RSCOUT RSCRST SDCLPSB
+ WFLOAT BC0 BC1 BC2 BKADR[0] BKADR[1] BKADR[2] CENDP CLK CLKFLT CLK_MUXB
+ DEF12B_PROG DEF12_PROG DEF_PROG DFTCLKEN DISCHG DLYPW FLOAT_RET LDFTX LS ME
+ MEB_I RA[0] RA[1] RM[0] RM[1] RM[2] RM[3] RMDEF1[0] RMDEF1[1] RMDEF1[2]
+ RMDEF1[3] RMDEF2[0] RMDEF2[1] RMDEF2[2] RMDEF2[3] RME RMENI[0] RMENI[1]
+ RMENI[2] RMSLOW[0] RMSLOW[1] RMSLOW[2] RMSLOW[3] SD SE_IN TEST1 TEST_RNM
+ WA[0] WA[1] WE WMDEF1[0] WMDEF1[1] WMDEF1[2] WMDEF1[3] WMDEF2[0] WMDEF2[1]
+ WMDEF2[2] WMDEF2[3] WMSLOW[0] WMSLOW[1] WMSLOW[2] WMSLOW[3] WPULSE[0]
+ WPULSE[1] WPULSE[2] XADR[0] XADR[1] XADR[2] XADR[3] XADR[4] XADR[5] XADR[6]
+ XADR[7] YADR[0] YADR[1] YADR[2] YADR[3]
XI126[0] VDDPI VSS VBP VBN WABUF[0] WA[0] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=400n wp=400n
XI126[1] VDDPI VSS VBP VBN WABUF[1] WA[1] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=400n wp=400n
XI122[0] VDDPI VSS VBP VBN RAB[0] RA[0] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=400n
+ wp=400n
XI122[1] VDDPI VSS VBP VBN RAB[1] RA[1] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=400n
+ wp=400n
XI127[0] VDDPI VSS VBP VBN WPBUF[0] WPULSE[0] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=400n wp=400n
XI127[1] VDDPI VSS VBP VBN WPBUF[1] WPULSE[1] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=400n wp=400n
XI127[2] VDDPI VSS VBP VBN WPBUF[2] WPULSE[2] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=400n wp=400n
Xinv_testrnm VDDPI VSS VBP VBN TEST_RNMB TEST_RNM
+ mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=400n wp=400n
XINV_WE1 VDDPI VSS VBP VBN LWEIB LWE_DFT mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1
+ wn=400n wp=400n
XLSLTCH VDDP VDDPI VSS VBP VBN LITESLP RWLCKB LS FLOAT WFLOAT
+ mm16a05_u_pg_lsltch_sp
XRMCTRL VDDP VDDPI VDDMINB VSS VBP VBN DEF1 DEF1B DEF2 DEF2B DEF_MODE
+ FAST1_MODE FAST2_MODE RM3_CORE_CNT RMT[0] RMT[1] RMT[2] RMT[3] WMT[0] WMT[1]
+ WMT[2] WMT[3] LOG0 LOG1 LOG1_RM BC0 DEF12B_PROG DEF12_PROG DEF_PROG FLOAT
+ LSDB RM[0] RM[1] RM[2] RM[3] RMDEF1[0] RMDEF1[1] RMDEF1[2] RMDEF1[3]
+ RMDEF2[0] RMDEF2[1] RMDEF2[2] RMDEF2[3] RME RMENI[0] RMENI[1] RMENI[2]
+ RMSLOW[0] RMSLOW[1] RMSLOW[2] RMSLOW[3] WMDEF1[0] WMDEF1[1] WMDEF1[2]
+ WMDEF1[3] WMDEF2[0] WMDEF2[1] WMDEF2[2] WMDEF2[3] WMSLOW[0] WMSLOW[1]
+ WMSLOW[2] WMSLOW[3] mm16a05_u_hdsp_plus_rmctrl
XI203 VDDPI VSS VBP VBN WABUF[2] WA[0] WA[1]
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=380.0n wn2=380.0n
+ wp1=600.0n wp2=600.0n
XI205 VDDPI VSS VBP VBN WABUF[2] WA[0] WA[1]
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=220.0n wn2=220.0n
+ wp1=600.0n wp2=600.0n
XLSDB_BC_CTRL VDDP VSS VBP VBN LSDB LSDB_BC1 LSDB_BC2 LOG1 BC1 BC2 SD
+ mm16a05_u_bc_control_hdsp
XCTRLWR VDDP VDDPI VSS VBP VBN CLKB CLKDEL FLOAT FLOATT LBKADR[0] LBKADR[1]
+ LBKADR[2] LCLKB LCLKBIO LCLKT LME LWE LWE_DFT LXADR[0] LXADR[1] LXADR[2]
+ LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] LYADR[2]
+ LYADR[3] MCLKB MCLKT MEB_LT T1T CKGATE DFTCLKEN LDFTX LOG1 MEORDFTCLKEN
+ BKADR[0] BKADR[1] BKADR[2] CLK CLKFLT CLK_MUXB CLPSEBUF DLYPW FLOAT_RET LS ME
+ MEB_I MEORDFTCLKEN_IN SE_IN TEST1 WE XADR[0] XADR[1] XADR[2] XADR[3] XADR[4]
+ XADR[5] XADR[6] XADR[7] YADR[0] YADR[1] YADR[2] YADR[3]
+ mm16a05_u_hdsp_plus_gcen_base
.ends

.subckt mm16a05_u_pg_arysd_buf VDDA VSS VBP VBN ARYSD ARYSD_BC1 ARYSD_BC2
+ ARYSDB ARYSDB_BC1 ARYSDB_BC2 SDCLPSB
XI12 VDDA VSS VBP VBN ARYSD ARYSDB_SDCLPSB mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=320n wp=320n
XI9 VDDA VSS VBP VBN ARYSD_BC1 ARYSDB_BC1 mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=320n wp=320n
XI11 VDDA VSS VBP VBN ARYSD_BC2 ARYSDB_BC2 mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=320n wp=320n
XI17 VDDA VSS VBP VBN ARYSDB_SDCLPSB ARYSDB SDCLPSB
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=320n
+ wp2=320n
.ends

.subckt mm16a05_u_hdsp_plus_gcenbuf VDDA VDDP VDDPI VSS VBP VBN DCLKT LYB[0]
+ LYB[1] RASSIST[0] RASSIST[1] ARYSD ARYSDB ARYSDB_BC1 ARYSDB_BC2 ARYSD_BC1
+ ARYSD_BC2 DLYPDB GSE_DB GSE_DT LDFTYBUF LOG0 LOG1 LCLKBIO LY[0] LY[1]
+ LYADR[2] LYADR[3] RAB[0] RAB[1] SDCLPSB
XDCLKT VDDPI VSS VBP VBN net126 LCLKBIO mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=200n
+ wp=200n
XDCLK VDDPI VSS VBP VBN DCLKT net126 mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=12 m_p=12 nf_n=1 nf_p=1 wn=200n
+ wp=300n
XINV_LY[0] VDDPI VSS VBP VBN LYB[0] LY[0] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=5 m_p=5 nf_n=1 nf_p=1
+ wn=400n wp=600n
XINV_LY[1] VDDPI VSS VBP VBN LYB[1] LY[1] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=5 m_p=5 nf_n=1 nf_p=1
+ wn=400n wp=600n
XIRA[0] VDDPI VSS VBP VBN RASSIST[0] RAB[0] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=200.0n wp=200.0n
XIRA[1] VDDPI VSS VBP VBN RASSIST[1] RAB[1] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=200.0n wp=200.0n
XIPG_ARYSD_BUF VDDP VSS VBP VBN ARYSD ARYSD_BC1 ARYSD_BC2 ARYSDB ARYSDB_BC1
+ ARYSDB_BC2 SDCLPSB mm16a05_u_pg_arysd_buf
.ends

.subckt mm16a05_u_hdsp_plus_capsac_wa VDDP VDDPI VSS VBP VBN LOG0 LOG1 PWDO
+ VEDGE WAPRCLKBUF WAPRCLKBUFB_RET
XIWR_RETURN VDDPI VSS VBP VBN WAPRCLKBUFB_RET WAPRCLKBUF
+ mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=16 m_p=16 nf_n=1 nf_p=1 wn=120n wp=120n
.ends

.subckt mm16a05_u_WA_CAP_NMOSPD_RPB64 VSS VSS_WA VBP VBN CC_0 CC_1 PRCHBWA
MI232 CC_0 VSS_WA CC_0 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=667n
+ m=3
MI233 CC_1 VSS_WA CC_1 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=1250n
+ m=4
MI230 VSS_WA PRCHBWA VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=334n
+ m=6
.ends

.subckt mm16a05_u_WA_CELL_RPB64_CM4 VDDP VDDPI VSS VSS_WA VBP VBN WA[0] WA[1]
+ WAPRCLK
XI81 VDDPI VSS VBP VBN PRCHB_WA WAPRCLK mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI80 VDDPI VSS VBP VBN net599 PRCHB_WA mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI76 VSS VSS_WA VBP VBN CC_0 CC_1 PRCHB_WA mm16a05_u_WA_CAP_NMOSPD_RPB64
XI78 VDDPI VSS VBP VBN CC_1 net599 WA[1]
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=400n wn2=400n wp1=160n
+ wp2=160n
XI79 VDDPI VSS VBP VBN CC_0 net599 WA[0]
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=533n wn2=533n wp1=160n
+ wp2=160n
.ends

.subckt mm16a05_u_hdsp_plus_hs_sacm4x1_wa_64 VDDP VDDPI VSS VSS_WA VBP VBN QB
+ QT RB RT SEL WA[0] WA[1] WAPRCLKBUF WAPRCLKBUFB_RET WB WB_IN WT WT_IN
XI204 VDDPI VSS VBP VBN WAPRCLKBUFB_INT WAPRCLKBUF SEL
+ mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XSFF_WA VDDP VDDPI VSS VSS_WA VBP VBN WA[0] WA[1] WAPRCLKBUF_INT
+ mm16a05_u_WA_CELL_RPB64_CM4
XI219 VDDPI VSS VBP VBN WAPRCLKBUF_INT WAPRCLKBUFB_INT
+ mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
.ends

.subckt mm16a05_u_hdsp_plus_sacbuf_wa VDDA VDDP VDDPI VSS VBP VBN WA[0] WA[1]
+ WAPRCLKBUF ARYSD ARYSD_BC1 ARYSD_BC2 LCGTH RASSIST[0] RASSIST[1]
+ WAPRCLKBUFB_RET WAB[0] WAB[1] WAPRCLK
XI119[0] VDDPI VSS VBP VBN WAB_INT[0] WAB[0] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=160n wp=160n
XI119[1] VDDPI VSS VBP VBN WAB_INT[1] WAB[1] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=160n wp=160n
XIWA_DR[0] VDDPI VSS VBP VBN WA[0] WAB_INT[0] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=320n wp=320n
XIWA_DR[1] VDDPI VSS VBP VBN WA[1] WAB_INT[1] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=320n wp=320n
XIWAPRCLK_DR VDDPI VSS VBP VBN WAPRCLKBUF WAPRCLK
+ mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=8 m_p=8 nf_n=1 nf_p=1 wn=253n wp=320n
.ends

.subckt mm16a05_u_hdsp_WACLK_PG_DELAY VDDP VDDPI VSS VBP VBN TAP1 TAP2 TAP3
+ LOG0 LOG1 TAP0
XITAP2_DR1 VDDPI VSS VBP VBN net214 TAP1 TAP1 TAP1
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XITAP3_DR2 VDDPI VSS VBP VBN TAP3 net221 net221 net221
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XITAP1_DR1 VDDPI VSS VBP VBN net213 TAP0 TAP0 TAP0
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XITAP3_DR1 VDDPI VSS VBP VBN net221 TAP2 TAP2 TAP2
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XITAP_DR2 VDDPI VSS VBP VBN TAP1 net213 net213 net213
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XITAP2_DR2 VDDPI VSS VBP VBN TAP2 net214 net214 net214
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
.ends

.subckt mm16a05_u_tg_bulk_n_vt3_p_vt3 VBP VBN A B S SB CPP=104n P_LA_n=4n
+ P_LA_p=4n ULP=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=320n wp=320n
MNS A S B VBN slvtnfet cpp=cpp p_la=p_la_n ulp=ulp nf=nf_n l=ln w=wn m=m_n
MPSB A SB B VBP slvtpfet cpp=cpp p_la=p_la_p ulp=ulp nf=nf_p l=lp w=wp m=m_p
.ends

.subckt mm16a05_u_WACLK_DELAY VDDP VDDPI VSS VBP VBN WAPRCLK_OUT WAPRCLK_IN
+ WPBUFB[0] WPBUFB[1]
XI10_NAND VDDPI VSS VBP VBN CB WPBUFB[0] WP[1]
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI00_NAND VDDPI VSS VBP VBN AB WPBUFB[0] WPBUFB[1]
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI11_NAND VDDPI VSS VBP VBN DB WP[0] WP[1]
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI01_NAND VDDPI VSS VBP VBN BB WP[0] WPBUFB[1]
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XIWP_INV[0] VDDPI VSS VBP VBN WP[0] WPBUFB[0] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XIWP_INV[1] VDDPI VSS VBP VBN WP[1] WPBUFB[1] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI11_DR1 VDDPI VSS VBP VBN net76 net77 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI11_DR2 VDDPI VSS VBP VBN net74 net76 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI10_DR1 VDDPI VSS VBP VBN net72 net73 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI01_DR1 VDDPI VSS VBP VBN net68 WAPRCLK_IN mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI01_DR2 VDDPI VSS VBP VBN net73 net68 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI10_DR2 VDDPI VSS VBP VBN net77 net72 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI01_INV VDDPI VSS VBP VBN B BB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI10_INV VDDPI VSS VBP VBN C CB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI11_INV VDDPI VSS VBP VBN D DB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI00_INV VDDPI VSS VBP VBN A AB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI11_TR VBP VBN net74 WAPRCLK_OUT D DB mm16a05_u_tg_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI10_TR VBP VBN net77 WAPRCLK_OUT C CB mm16a05_u_tg_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI01_TR VBP VBN net73 WAPRCLK_OUT B BB mm16a05_u_tg_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI00_TR VBP VBN WAPRCLK_IN WAPRCLK_OUT A AB mm16a05_u_tg_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=120n wp=120n
.ends

.subckt mm16a05_u_nd2_bulk_n1_vt4_n2_vt4_p1_vt4_p2_vt4 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=600n wn2=600n wp1=450n wp2=450n
MPA2 X A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
MPA1 X A1 VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MNA1 X A1 net22 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 net22 A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2
+ w=wn2 m=m_n2
.ends

.subckt mm16a05_u_nr3_bulk_n1_vt4_n2_vt4_n3_vt4_p1_vt4_p2_vt4_p3_vt4 VDD VSS
+ VBP VBN X A1 A2 A3 CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_n3=4n P_LA_p1=4n
+ P_LA_p2=4n P_LA_p3=4n ULP=0 ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n
+ m_n1=1 m_n2=1 m_n3=1 m_p1=1 m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1
+ nf_p2=1 nf_p3=1 wn1=120n wn2=120n wn3=120n wp1=240n wp2=240n wp3=240n
MNA1 X A1 VSS VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA3 X A3 VSS VBN slvtnfet cpp=cpp p_la=p_la_n3 ulp=ulp nf=nf_n3 l=ln3 w=wn3
+ m=m_n3
MNA2 X A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MPA3 net10 A3 VDD VBP slvtpfet cpp=cpp p_la=p_la_p3 ulp=ulp nf=nf_p3 l=lp3
+ w=wp3 m=m_p3
MPA2 net029 A2 net10 VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2
+ w=wp2 m=m_p2
MPA1 X A1 net029 VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
.ends

.subckt mm16a05_u_hdsp_plus_wa_cntrl VDDP VDDPI VSS VBP VBN TAP0 TAP1 TAP2 TAP3
+ WAPRCLK LOG0 LOG1 RBLWA TEST_RNMB WABUF[2] WPBUF[0] WPBUF[1] WPBUF[2]
+ FLOAT_RET LWEIB PRCKDLY
XI41 VDDP VDDPI VSS VBP VBN TAP1 TAP2 TAP3 LOG0 LOG1 TAP0
+ mm16a05_u_hdsp_WACLK_PG_DELAY
XI47 VDDP VDDPI VSS VBP VBN PRCKDLY_INT PRCKDLY WPBUF[0] WPBUF[1]
+ mm16a05_u_WACLK_DELAY
XI77 VDDPI VSS VBP VBN WAPRCLK TAP0 PRCKDLY_INT
+ mm16a05_u_nd2_bulk_n1_vt4_n2_vt4_p1_vt4_p2_vt4 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=4 m_n2=4
+ m_p1=4 m_p2=4 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=120n
+ wp2=120n
XI64 VDDPI VSS VBP VBN net187 net188 WABUF[2] LWEIB
+ mm16a05_u_nr3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=120n
+ wn2=120n wn3=120n wp1=480n wp2=480n wp3=480n
XI92 VDDPI VSS VBP VBN TAP0 RBLWA net312 FLOAT_RET
+ mm16a05_u_nr3_bulk_n1_vt4_n2_vt4_n3_vt4_p1_vt4_p2_vt4_p3_vt4 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=120n
+ wn2=120n wn3=120n wp1=600n wp2=600n wp3=600n
XI65 VDDPI VSS VBP VBN net188 TEST_RNMB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI63 VDDPI VSS VBP VBN net312 net187 mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
.ends

.subckt mm16a05_u_hdsp_plus_sactrl_wa VDDA VDDMINB VDDP VDDPI VSS VBP VBN TAP0
+ TAP1 TAP2 TAP3 WAPRCLK DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOAT_RET
+ LBKADR[0] LBKADR[1] LBKADR[2] LCGTH_PCHG LMATCHB LOG0 LOG1 LWERD LWEWR PM[0]
+ PM[1] PM[2] PM[3] PRCKE RBLWA RM3CNT TEST_RNMB WABUF[0] WABUF[1] WABUF[2]
+ WAPRCLKBUFB_RET WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] CENDP
+ FLOATT LDFTX LITESLP LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+ LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PRCKDLY RMT[0] RMT[1] RMT[2]
+ RMT[3] T1T
XWACTRL VDDP VDDPI VSS VBP VBN TAP0 TAP1 TAP2 TAP3 WAPRCLK LOG0 LOG1 RBLWA
+ TEST_RNMB WABUF[2] WPBUF[0] WPBUF[1] WPBUF[2] FLOAT_RET LWEIB PRCKDLY
+ mm16a05_u_hdsp_plus_wa_cntrl
XITAP3_DR1 VDDPI VSS VBP VBN net440 net442 net442 net442
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XITAP2_DR2 VDDPI VSS VBP VBN net442 net441 net441 net441
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XI237 VDDPI VSS VBP VBN net448 net445 net445 net445
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XITAP3_DR2 VDDPI VSS VBP VBN net446 net440 net440 net440
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XITAP2_DR1 VDDPI VSS VBP VBN net441 LOG0 LOG0 LOG0
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XI236 VDDPI VSS VBP VBN net445 net446 net446 net446
+ mm16a05_u_cinv_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
.ends

.subckt mm16a05_u_hdsp_plus_capsac VDDP VDDPI VSS VBP VBN SAED LOG0 LOG1 PWDO
+ VEDGE SAEB
MI18 VDDPI SAEB SAED VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120.0n
+ m=17
MI21 SAED SAEB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120.0n m=7
.ends

.subckt mm16a05_u_wrdrv VDDP VDDPI VSS VSS_WA VBP VBN WB WT RB RT WB_IN WT_IN
XWB VDDPI VSS_WA VBP VBN WB WB_IN mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=360n
+ wp=240n
XWT VDDPI VSS_WA VBP VBN WT WT_IN mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=360n
+ wp=240n
.ends

.subckt mm16a05_u_blatch_scan VDDP VDDPI VSS VBP VBN OUT OUTB CB CT IN
XI2 VDDPI VSS VBP VBN OUT OUTB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
*XI8 VBP VBN OUTB mm16a05_u_init1
XI0 VDDPI VSS VBP VBN OUTB IN CB CT
+ mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
XI1 VDDPI VSS VBP VBN OUTB OUT CT CB
+ mm16a05_u_cinv_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n
+ wp1=120n wp2=120n
.ends

.subckt mm16a05_u_lsa_gf22_hd1p VDDP VDDPI VSS VBP VBN XB XT LOG0 LOG1 RB RT
+ SAEN SAEP SAPR
M7_OFF XT LOG0 net60 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=780n m=1
M6_OFF XB LOG0 net60 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=780n m=1
M9 net60 SAEN VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=800n m=2
M7 XT XB net60 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n w=780n m=6
M6 XB XT net60 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n w=780n m=6
M2_OFF XB LOG1 XT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=375.0n m=1
M4 XT SAEP RT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=375n m=2
M3 XB SAEP RB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=375n m=2
M2 XB SAPR XT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=375.0n m=1
M0 VDDPI SAPR XB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=140n m=2
M1 VDDPI SAPR XT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=140n m=2
M5 VDDPI XT XB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=375n m=2
M11 VDDPI XB XT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=375n m=2
.ends

.subckt mm16a05_u_sac_st_base_plus VDDP VDDPI VSS VBP VBN LOG0 LOG1 RB RT XB XT
+ SAEB SAPRB SEL
XSAEB VDDPI VSS VBP VBN SAEBAR SAET LSEL
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=2 nf_p2=2 wn1=220n wn2=220n wp1=260n
+ wp2=260n
XSAPR VDDPI VSS VBP VBN SAPR SAPRB SAEBAR
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=130n
+ wp2=130n
XLSEL VDDP VDDPI VSS VBP VBN LSEL net45 CKSAEB CKSAET SEL mm16a05_u_blatch_scan
XSAE VDDPI VSS VBP VBN SAE SAEBAR mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=150n
+ wp=260n
XCKSAEB VDDPI VSS VBP VBN CKSAEB SAET mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XSAET VDDPI VSS VBP VBN SAET SAEB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=130n
+ wp=260n
XCKSAET VDDPI VSS VBP VBN CKSAET CKSAEB mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XLSA VDDP VDDPI VSS VBP VBN XB XT LOG0 LOG1 RB RT SAE SAE SAPR
+ mm16a05_u_lsa_gf22_hd1p
M0 VDDPI LSEL XB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=140n m=1
M1 VDDPI LSEL XT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=140n m=1
.ends

.subckt mm16a05_u_sac_base_nor VDDP VDDPI VSS VBP VBN QBOUT QTOUT LOG0 QB_IN
+ QB_NORIN QT_IN QT_NORIN XB XT
XI73 VDDPI VSS VBP VBN QTOUT QT_NORIN QBI
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=3 m_n2=3
+ m_p1=3 m_p2=3 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=480n wn2=480n wp1=214n
+ wp2=214n
XI78 VDDPI VSS VBP VBN QBOUT QTI QB_NORIN
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=3 m_n2=3
+ m_p1=3 m_p2=3 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=480n wn2=480n wp1=214n
+ wp2=214n
XI76 VDDPI VSS VBP VBN QTI XB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=460n wp=234n
XSAE VDDPI VSS VBP VBN QBI XT mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=460n wp=234n
.ends

.subckt mm16a05_u_sac_nor_plus VDDP VDDPI VSS VSS_WA VBP VBN QBOUT QTOUT LOG0
+ LOG1 RB RT WB WT QB_IN QB_NORIN QT_IN QT_NORIN SAEB SAPRB SEL WB_IN WT_IN
XW VDDP VDDPI VSS VSS_WA VBP VBN WB WT RB RT WB_IN WT_IN mm16a05_u_wrdrv
XS VDDP VDDPI VSS VBP VBN LOG0 LOG1 RB RT XB XT SAEB SAPRB SEL
+ mm16a05_u_sac_st_base_plus
XI27 VDDP VDDPI VSS VBP VBN QBOUT QTOUT LOG0 QB_IN QB_NORIN QT_IN QT_NORIN XB
+ XT mm16a05_u_sac_base_nor
.ends

.subckt mm16a05_u_hdsp_plus_sacm4x1_nor VDDP VDDPI VSS VSS_WA VBP VBN QBOUT
+ QTOUT BYPASS BYPASS_RET LCGTH LOG0 LOG1 RASSISTT[0] RASSISTT[1] RB RT SAED WB
+ WB_IN WT WT_IN QB_IN QB_NORIN QT_IN QT_NORIN SAEB SAPRB SEL
XSFF VDDP VDDPI VSS VSS_WA VBP VBN QBOUT QTOUT LOG0 LOG1 RB RT WB WT QB_IN
+ QB_NORIN QT_IN QT_NORIN SAEB SAPRB SEL WB_IN WT_IN mm16a05_u_sac_nor_plus
.ends

.subckt mm16a05_u_hdsp_plus_sacbuf VDDA VDDP VDDPI VSS VBP VBN LCGTH SAEB SAPRB
+ ARYSD ARYSD_BC1 ARYSD_BC2 BYPASS BYPASS_RET LOG0 LOG1 RASSIST[0] RASSIST[1]
+ RASSISTT[0] RASSISTT[1] SAED LCGTHB LCGTHB_IN LCGTHHV SAET SAPRT
XI78[0] VDDPI VSS VBP VBN RASSISTT[0] RASSISTB[0]
+ mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=320n wp=320n
XI78[1] VDDPI VSS VBP VBN RASSISTT[1] RASSISTB[1]
+ mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=320n wp=320n
XI77[0] VDDPI VSS VBP VBN RASSISTB[0] RASSIST[0] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI77[1] VDDPI VSS VBP VBN RASSISTB[1] RASSIST[1] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=240n
XLCGTHB VDDA VSS VBP VBN LCGTH LCGTHB_IN mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=280n wp=335n
XI57 VDDPI VSS VBP VBN SAPRB SAPRT mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=8 m_p=8 nf_n=1 nf_p=1 wn=400n
+ wp=350n
MI2 VDDPI SAET SAEB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=300n m=10
MI1 SAEB SAET VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=400n m=10
.ends

.subckt mm16a05_u_inv_bulk_n_vt4_p_vt4 VDD VSS VBP VBN X A CPP=104n P_LA_n=4n
+ P_LA_p=4n ULP=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=758n wp=1092n
MNA X A VSS VBN slvtnfet cpp=cpp p_la=p_la_n ulp=ulp nf=nf_n l=ln w=wn m=m_n
MPA X A VDD VBP slvtpfet cpp=cpp p_la=p_la_p ulp=ulp nf=nf_p l=lp w=wp m=m_p
.ends

.subckt mm16a05_u_complex_nor_prclk_vt4_plus VDDP VSS VBP VBN OUT PULLUP BK
+ LMATCH LMATCHB
M36 net137 LMATCHB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
M37 OUT BK net137 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
MI72 OUT LMATCH net137 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
MI68 net127 BK OUT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
MI75 PULLUP LMATCHB OUT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
MI74 PULLUP LMATCH net127 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
.ends

.subckt mm16a05_u_bk_sel_dft_prclk_vt4_plus VDDP VDDPI VSS VBP VBN PRCKE_B
+ PRCKE_T LMATCH LMATCHB_I_BBK LMATCHB_I_TBK LOG1 BBKB LMATCHB TBKB
XPRCLKB VDDP VSS VBP VBN net106 VDDPI BBKB LMATCH LMATCHB_I_BBK
+ mm16a05_u_complex_nor_prclk_vt4_plus
XPRCLKT VDDP VSS VBP VBN net105 VDDPI TBKB LMATCH LMATCHB_I_TBK
+ mm16a05_u_complex_nor_prclk_vt4_plus
XI50 VDDPI VSS VBP VBN PRCKE_T net105 mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI54 VDDPI VSS VBP VBN PRCKE_B net106 mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=240n
+ wp=240n
.ends

.subckt mm16a05_u_hdsp_mux_2x1_hd VDDP VDDPI VSS VBP VBN OUT 0_1 1 SEL
XI34 VDDPI VSS VBP VBN SELB SEL mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI35 VBP VBN 1 OUT SEL SELB mm16a05_u_tg_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=300n wp=300n
XI29 VBP VBN 0_1 OUT SELB SEL mm16a05_u_tg_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=300n wp=300n
.ends

.subckt mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt4_p2_vt4 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=600n wn2=600n wp1=450n wp2=450n
MPA2 X A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
MPA1 X A1 VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MNA1 X A1 net22 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 net22 A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2
+ w=wn2 m=m_n2
.ends

.subckt mm16a05_u_nr2_bulk_n1_vt4_n2_vt4_p1_vt4_p2_vt4 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=120n wn2=120n wp1=360n wp2=360n
MNA1 X A1 VSS VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 X A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MPA2 net10 A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2
+ w=wp2 m=m_p2
MPA1 X A1 net10 VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
.ends

.subckt mm16a05_u_tinv_bulk_n1_vt4_n2_vt4_p1_vt4_p2_vt4 VDD VSS VBP VBN X A S0
+ S1 CPP=104n P_LA_n1=0 P_LA_n2=0 P_LA_p1=0 P_LA_p2=0 ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=240n wn2=240n wp1=960n wp2=960n
MNA net020 S0 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2
+ w=wn2 m=m_n2
MNS0 X A net020 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MPA net16 S1 VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MPS1 X A net16 VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
.ends

.subckt mm16a05_u_tg_bulk_n_vt4_p_vt4 VBP VBN A B S SB CPP=104n P_LA_n=4n
+ P_LA_p=4n ULP=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=320n wp=320n
MNS A S B VBN slvtnfet cpp=cpp p_la=p_la_n ulp=ulp nf=nf_n l=ln w=wn m=m_n
MPSB A SB B VBP slvtpfet cpp=cpp p_la=p_la_p ulp=ulp nf=nf_p l=lp w=wp m=m_p
.ends

.subckt mm16a05_u_hdsp_plus_timer_sactrl VDDP VDDPI VSS VBP VBN FAST1B STCLK
+ DEF FLOAT_RETB FLOAT_RET_TIMER_PROG FT1 FT2 REFBP REFST RMT3
XI119 VDDPI VSS VBP VBN STCLK FLOAT_RETB sactrl_rblwr_wa
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt4_p2_vt4 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=6 m_n2=6
+ m_p1=6 m_p2=6 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=120n
+ wp2=120n
XI137 VDDPI VSS VBP VBN FAST2 FAST1B FLOAT_RET_TIMER_PROG
+ mm16a05_u_nr2_bulk_n1_vt4_n2_vt4_p1_vt4_p2_vt4 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=0 p_la_p2=0 ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=130n
+ wp2=130n
MI99_P VDDPI net355 DEFAULT VBP slvtpfet cpp=104n p_la=0 ulp=0 nf=1 l=20n
+ w=160n m=4
MI98_2P VDDPI FAST1 FAST1B VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=1
XI123 VDDPI VSS VBP VBN FAST1 REFST RMT3B RMT3
+ mm16a05_u_tinv_bulk_n1_vt4_n2_vt4_p1_vt4_p2_vt4 cpp=104n p_la_n1=0 p_la_n2=0
+ p_la_p1=0 p_la_p2=0 ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=960n
+ wp2=960n
XI124 VDDPI VSS VBP VBN FAST1 REFBP RMT3 RMT3B
+ mm16a05_u_tinv_bulk_n1_vt4_n2_vt4_p1_vt4_p2_vt4 cpp=104n p_la_n1=4n
+ p_la_n2=4n p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1
+ m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n
+ wp1=960n wp2=960n
MI99_N DEFAULT net355 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n
+ m=2
MI98_2N FAST1B FAST1 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=2
XI127 VDDPI VSS VBP VBN RMT3B RMT3 mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI98 VDDPI VSS VBP VBN net355 FAST2 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI102 VDDPI VSS VBP VBN net211 DEF mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI105 VDDPI VSS VBP VBN net225 FT2 mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI104 VDDPI VSS VBP VBN net233 FT1 mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI103 VBP VBN FAST2 sactrl_rblwr_wa FT1 net233 mm16a05_u_tg_bulk_n_vt4_p_vt4
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI94 VBP VBN DEFAULT sactrl_rblwr_wa DEF net211 mm16a05_u_tg_bulk_n_vt4_p_vt4
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI106 VBP VBN FAST1 sactrl_rblwr_wa FT2 net225 mm16a05_u_tg_bulk_n_vt4_p_vt4
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=240n wp=240n
.ends

.subckt mm16a05_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt2_p2_vt2 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=120n wn2=120n wp1=360n wp2=360n
MNA1 X A1 VSS VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 X A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MPA2 net10 A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2
+ w=wp2 m=m_p2
MPA1 X A1 net10 VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
.ends

.subckt mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt3_p2_vt3 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=120n wn2=120n wp1=360n wp2=360n
MNA1 X A1 VSS VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 X A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MPA2 net10 A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2
+ w=wp2 m=m_p2
MPA1 X A1 net10 VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
.ends

.subckt mm16a05_u_mux_2x1_hdsp VDDP VDDPI VSS VBP VBN OUT 0_1 1 SEL
XI34 VDDPI VSS VBP VBN SELB SEL mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI35 VBP VBN 1 OUT SEL SELB mm16a05_u_tg_bulk_n_vt4_p_vt4 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
XI29 VBP VBN 0_1 OUT SELB SEL mm16a05_u_tg_bulk_n_vt4_p_vt4 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
.ends

.subckt mm16a05_u_inv_bulk_n_vt2_p_vt3 VDD VSS VBP VBN X A CPP=104n P_LA_n=4n
+ P_LA_p=4n ULP=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=758n wp=1092n
MNA X A VSS VBN slvtnfet cpp=cpp p_la=p_la_n ulp=ulp nf=nf_n l=ln w=wn m=m_n
MPA X A VDD VBP slvtpfet cpp=cpp p_la=p_la_p ulp=ulp nf=nf_p l=lp w=wp m=m_p
.ends

.subckt mm16a05_u_float_selftimed_wa_hdsp_plus VDDA VDDP VDDPI VSS VBP VBN
+ FAST1B FLOAT_RET FLTRET_1INV FLTRET_3INV RWLB RWLBLV STCLK DEF FLOAT FT1 FT2
+ RMT[2] RMT[3] WABUFB WAPRCLKBUFB_RET BKSA_T1TB FLOAT_RET_TIMER_PROG FLTRET
+ LWEIB RBL RWLBHV STCLK_RST_PGM TRNM
XTIMER VDDP VDDPI VSS VBP VBN FAST1B STCLK DEF float_retb_wa
+ FLOAT_RET_TIMER_PROG FT1 FT2 net280 RBL RMT[3]
+ mm16a05_u_hdsp_plus_timer_sactrl
XI55 VDDPI VSS VBP VBN net358 BKSA_T1TB FLOAT
+ mm16a05_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=360n wn2=360n wp1=200.0n
+ wp2=200.0n
XI54 VDDPI VSS VBP VBN net350 BKSA_T1TB FLOAT
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=24n ln2=24n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=720n
+ wp2=720n
XMUX VDDP VDDPI VSS VBP VBN net280 net205 RWLB RMT[2] mm16a05_u_mux_2x1_hdsp
MI53 VDDPI WAPRCLKBUFB_RET float_retb_wa VBP slvtpfet cpp=104n p_la=4n ulp=0
+ nf=1 l=20n w=240n m=1
MI67 FLOAT STCLK VDDP VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=570n
+ m=10
MI52 VDDPI net296 float_retb_wa VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=1
XI19 VDDP VSS VBP VBN RWLB net239 mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1 wn=270n
+ wp=270n
XI8 VDDP VSS VBP VBN net94 RWLB mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI7 VDDP VSS VBP VBN net205 net94 mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI94 VDDPI VSS VBP VBN net16 FLOAT mm16a05_u_inv_bulk_n_vt2_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=2 nf_n=1 nf_p=1 wn=200n
+ wp=360n
XI93 VDDP VSS VBP VBN FLOAT_RET net16 mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=8 m_p=8 nf_n=1 nf_p=1 wn=200.0n
+ wp=200.0n
XI39 VDDP VSS VBP VBN net239 RWLBHV mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=200n
XI40 VDDP VSS VBP VBN RWLBLV net350 mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=200n
MI50 float_retb_wa net296 net286 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=1
MI64 net14 net358 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=150n m=2
MI51 net286 WAPRCLKBUFB_RET VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=1
MI66 net14 STCLK FLOAT VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=150n
+ m=2
XI117 VDDPI VSS VBP VBN net296 WABUFB LWEIB TRNM
+ mm16a05_u_nr3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=3 m_n2=3 m_n3=3 m_p1=3
+ m_p2=3 m_p3=3 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=240n
+ wn2=240n wn3=240n wp1=400n wp2=400n wp3=400n
.ends

.subckt mm16a05_u_bk_sel_t1t_hdsp VDDP VDDPI VSS VBP VBN BBKB BKSA BKSA_T1TB
+ TBKB A0 A1 A2 AB0 PRCKE_B PRCKE_T T1T
XI44 VDDPI VSS VBP VBN BKSA_T1TB BKSA net96
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=640n wn2=640n wp1=400n
+ wp2=400n
XI16 VDDPI VSS VBP VBN BKSA PRCKE_T PRCKE_B
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=640n wn2=640n wp1=400n
+ wp2=400n
XI39 VDDPI VSS VBP VBN BBKB A2 A1 AB0
+ mm16a05_u_nd3_bulk_n1_vt4_n2_vt4_n3_vt4_p1_vt4_p2_vt4_p3_vt4 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=4 m_n2=4 m_n3=4 m_p1=4
+ m_p2=4 m_p3=4 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=640n
+ wn2=640n wn3=640n wp1=240n wp2=240n wp3=240n
Xnd3_cmuxt VDDPI VSS VBP VBN TBKB A2 A1 A0
+ mm16a05_u_nd3_bulk_n1_vt4_n2_vt4_n3_vt4_p1_vt4_p2_vt4_p3_vt4 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=4 m_n2=4 m_n3=4 m_p1=4
+ m_p2=4 m_p3=4 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=640n
+ wn2=640n wn3=640n wp1=240n wp2=240n wp3=240n
XI31 VDDPI VSS VBP VBN net96 T1T mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
.ends

.subckt mm16a05_u_log01_gen VDDP VNWP VSS VBP VBN LOG0
*XI11 VBP VBN always1 mm16a05_u_init1
XI10 VDDP VSS VBP VBN alway0 always1 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
Xinv_1 VDDP VSS VBP VBN always1 ST0 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
M0 LOG0 always1 VSS VBN lvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=2
M1 ST0 always1 VSS VBN lvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
M2 ST0 alway0 VSS VBN lvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
.ends

.subckt mm16a05_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=120n wn2=120n wp1=360n wp2=360n
MNA1 X A1 VSS VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 X A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2 w=wn2
+ m=m_n2
MPA2 net10 A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2
+ w=wp2 m=m_p2
MPA1 X A1 net10 VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
.ends

.subckt mm16a05_u_hdsp_predec_2to4 VDDP VDDPI VSS VBP VBN PM[0] PM[1] PM[2]
+ PM[3] AB[0] AB[1]
Xinv_adr1 VDDPI VSS VBP VBN A[1] AB[1] mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
Xinv_adr0 VDDPI VSS VBP VBN A[0] AB[0] mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI77 VDDPI VSS VBP VBN PM[2] AB[0] A[1]
+ mm16a05_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=240n
+ wp2=240n
XI78 VDDPI VSS VBP VBN PM[1] A[0] AB[1]
+ mm16a05_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=240n
+ wp2=240n
XI79 VDDPI VSS VBP VBN PM[0] AB[0] AB[1]
+ mm16a05_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=240n
+ wp2=240n
XI80 VDDPI VSS VBP VBN PM[3] A[0] A[1]
+ mm16a05_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=240n
+ wp2=240n
.ends

.subckt mm16a05_u_logrep VDDP VSS VBP VBN LOG0 LOG1
MPLOG VDDP LOG0 LOG1 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=200n m=4
M0 LOG0 LOG1 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=200n m=4
.ends

.subckt mm16a05_u_mux_2x1_modesel VDDP VDDPI VSS VBP VBN OUT 0_1 1 SEL SELB
XI35 VBP VBN 1 OUT SEL SELB mm16a05_u_tg_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
XI29 VBP VBN 0_1 OUT SELB SEL mm16a05_u_tg_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
.ends

.subckt mm16a05_u_sac_pwmg_hdsp VDDA VDDP VDDPI VSS VBP VBN LCGTB LCGTHB
+ LCGTHLV LCGTH_PCHG ENLPGB LCGTHHV LITESLP RM3CNT
XI16 VDDPI VSS VBP VBN LCGTH_PCHG LCGTB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160.0n
+ wp=160.0n
XI0 VDDP VSS VBP VBN LCGTHB LCGTHHV mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=240.0n
XI7 VDDP VSS VBP VBN LCGTB ENLPGB LITESLP
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI22 VDDP VSS VBP VBN LCGTHLV RM3CNT LCGTB
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
.ends

.subckt mm16a05_u_hdsp_plus_rdctrl VDDP VDDPI VSS VBP VBN LWERD LWEWR SAOFF
+ FLOAT FLOATT TEST_RNM BKSA LDFTX LWEIB
XI6 VDDPI VSS VBP VBN SAOFF LWERD BKSA CCLK
+ mm16a05_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=4 m_n2=4 m_n3=4 m_p1=4
+ m_p2=4 m_p3=4 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=400n
+ wn2=400n wn3=400n wp1=120n wp2=120n wp3=120n
XI16 VDDPI VSS VBP VBN LWEWR net57 LWEIB
+ mm16a05_u_nd2_bulk_n1_vt4_n2_vt4_p1_vt4_p2_vt4 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=4 m_n2=4
+ m_p1=4 m_p2=4 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=200n
+ wp2=200n
XI15 VDDPI VSS VBP VBN CCLK FLOAT FLOATT
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=4 m_n2=4
+ m_p1=4 m_p2=4 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=160n
+ wp2=160n
Xnr2_lwebk VDDPI VSS VBP VBN LWERD net38 TEST_RNM
+ mm16a05_u_nr2_bulk_n1_vt4_n2_vt4_p1_vt4_p2_vt4 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=4 m_n2=4
+ m_p1=4 m_p2=4 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=320n
+ wp2=320n
XI7 VDDPI VSS VBP VBN net38 LWEIB mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=200n
+ wp=160n
XI14 VDDPI VSS VBP VBN net57 LDFTX mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=200n
+ wp=160n
.ends

.subckt mm16a05_u_sacbuf_dly_hdsp_plus VDDP VDDPI VSS VBP VBN SAOFFOUT RDT1B
+ SAOFF
XI35 VDDPI VSS VBP VBN sadlyb0 SAOFF mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI34 VDDPI VSS VBP VBN sadlyt0 sadlyb0 mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI22 VDDPI VSS VBP VBN T1T RDT1B mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI30 VDDPI VSS VBP VBN sadlyt1 sadlyb1 mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI33 VDDPI VSS VBP VBN sadlyb1 sadlyt0 mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI28 VBP VBN SAOFFOUT sadlyt1 RDT1B T1T mm16a05_u_tg_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI29 VBP VBN SAOFFOUT SAOFF T1T RDT1B mm16a05_u_tg_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=160n
+ wp=160n
.ends

.subckt mm16a05_u_saetrack VDDPI VNWP VSS VBP VBN SAPRCH SAED SAOFF
*XI54 VBP VBN SAPRCH mm16a05_u_init0
M4 VDDPI SAOFF SAPRCH VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=2
M7 net0148 SAED SAPRCH VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
MPA VDDPI SAPRCHB net0148 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
XFWD VDDPI VSS VBP VBN SAPRCHB SAPRCH mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
M0 net047 SAED VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n m=2
M1 SAPRCH SAOFF net047 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=160n
+ m=2
M3 net0137 SAPRCHB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
M2 SAPRCH SAOFF net0137 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
.ends

.subckt mm16a05_u_sacbufctrl_hdsp_plus VDDP VDDPI VSS VBP VBN SAET SAPRT FLOAT
+ SAEDL SAEDR SAOFF STCLK
XI62 VDDPI VSS VBP VBN net81 FLOAT mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI50 VDDPI VSS VBP VBN SAPRCHB SAPRCHT mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI52 VDDPI VDDP VSS VBP VBN SAPRCHT SAEDR SAOFF mm16a05_u_saetrack
MI5 VDDPI STCLK XP VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=280n m=6
MI4 XP SAPRCHB SAET VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=280n m=6
MI173 VDDPI net81 XP VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=280n m=6
M92 SAET SAPRCHB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=6
MI6 SAET STCLK net78 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=6
MI7 net78 net81 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=6
XGPRCH VDDPI VSS VBP VBN SAPRT SAOFF SAPRCHB
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=8 m_n2=8
+ m_p1=4 m_p2=8 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=120n
+ wp2=200n
.ends

.subckt mm16a05_u_hdsp_plus_rdctrl_sa VDDP VDDPI VSS VBP VBN LWERD LWEWR SAET
+ SAPRT FLOAT FLOATT TEST_RNM BKSA LDFTX LWEIB SAEDL SAEDR STCLK T1T
XI17 VDDP VDDPI VSS VBP VBN LWERD LWEWR net81 FLOAT FLOATT TEST_RNM BKSA LDFTX
+ LWEIB mm16a05_u_hdsp_plus_rdctrl
XI69 VDDP VDDPI VSS VBP VBN net96 T1T net81 mm16a05_u_sacbuf_dly_hdsp_plus
XI15 VDDP VDDPI VSS VBP VBN SAET SAPRT FLOAT SAEDL SAEDR net96 STCLK
+ mm16a05_u_sacbufctrl_hdsp_plus
.ends

.subckt mm16a05_u_hdsp_plus_sactrl VDDA VDDMINB VDDP VDDPI VSS VBP VBN FAST1B
+ LCGTB LCGTHB LCGTHLV LCGTH_PCHG LLBKADRB[0] LLBKADRB[1] LLBKADRB[2]
+ LLBKADRT[0] LLBKADRT[1] LLBKADRT[2] LMATCH LWERD LWEWR PM[0] PM[1] PM[2]
+ PM[3] PRCKE_B PRCKE_T PRCLKB RWLBLV SAET SAPRT BYPASS BYP_VLOAD DEF_MODE
+ FAST1_MODE FAST2_MODE FLOAT FLOATT_PGM FLOAT_RET LOG0 LOG1 RBLRD RBLWA RBLWR
+ RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2]
+ WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] CENDP ENLPGB FLOATT
+ FLOAT_RET_TIMER_PROG LBKADR[0] LBKADR[1] LBKADR[2] LCGTHHV LDFTX LITESLP
+ LMATCHB LMATCHB_I_BBK LMATCHB_I_TBK LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3]
+ LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PLBKADR[0] PLBKADR[1]
+ PLBKADR[2] PLBKADRB[0] RM3CNT RWLBHV SAEDL SAEDR WAPRCLKBUFB_RET
XI74 VDDPI VSS VBP VBN LMATCH LMATCHB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=200n
+ wp=200n
XI122 VDDPI VSS VBP VBN TEST_RNM TEST_RNMB mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI48[0] VDDPI VSS VBP VBN LLBKADRT[0] LOG0 mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=480n wp=480n
XI48[1] VDDPI VSS VBP VBN LLBKADRT[1] LOG0 mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=480n wp=480n
XI48[2] VDDPI VSS VBP VBN LLBKADRT[2] LOG0 mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=480n wp=480n
Xinv_lbk[0] VDDPI VSS VBP VBN LLBKADRB[0] LBKADR[0]
+ mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=480n wp=480n
Xinv_lbk[1] VDDPI VSS VBP VBN LLBKADRB[1] LBKADR[1]
+ mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=480n wp=480n
Xinv_lbk[2] VDDPI VSS VBP VBN LLBKADRB[2] LBKADR[2]
+ mm16a05_u_inv_bulk_n_vt4_p_vt4 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=480n wp=480n
XI548 VDDPI VSS VBP VBN LWEIBB LWEIB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
Xbk_sel_prck VDDP VDDPI VSS VBP VBN PRCKE_B PRCKE_T LMATCH LMATCHB_I_BBK
+ LMATCHB_I_TBK LOG1 BBKB LMATCHB TBKB mm16a05_u_bk_sel_dft_prclk_vt4_plus
XI515 VDDP VDDPI VSS VBP VBN RBL RBLWR RBLRD LWEIB mm16a05_u_hdsp_mux_2x1_hd
XLCEN_SELFTIMED_WR VDDA VDDP VDDPI VSS VBP VBN FAST1B PRCLKB net1484 net1483
+ RWLB_SAC RWLBLV STCLK DEF_MODE FLOAT FAST1_MODE FAST2_MODE INT[2] INT[3]
+ WABUF[2] WAPRCLKBUFB_RET BKSA_T1TB FLOAT_RET_TIMER_PROG net1482 LWEIB RBL
+ RWLBHV net1484 TEST_RNM mm16a05_u_float_selftimed_wa_hdsp_plus
Xbk_sel VDDP VDDPI VSS VBP VBN BBKB BKSA BKSA_T1TB TBKB PLBKADR[0] PLBKADR[1]
+ PLBKADR[2] PLBKADRB[0] PRCKE_B PRCKE_T T1T mm16a05_u_bk_sel_t1t_hdsp
XI400 VDDP VDDP VSS VBP VBN LOG0 mm16a05_u_log01_gen
XI360 VDDP VDDPI VSS VBP VBN PM[0] PM[1] PM[2] PM[3] LYADR[0] LYADR[1]
+ mm16a05_u_hdsp_predec_2to4
XI401 VDDP VSS VBP VBN LOG0 LOG1 mm16a05_u_logrep
XRMWMSEL[0] VDDP VDDPI VSS VBP VBN INT[2] WMT[2] RMT[2] LWEIB LWEIBB
+ mm16a05_u_mux_2x1_modesel
XRMWMSEL[1] VDDP VDDPI VSS VBP VBN INT[3] WMT[3] RMT[3] LWEIB LWEIBB
+ mm16a05_u_mux_2x1_modesel
XI337 VDDA VDDP VDDPI VSS VBP VBN LCGTB LCGTHB LCGTHLV LCGTH_PCHG ENLPGB
+ LCGTHHV LITESLP RM3CNT mm16a05_u_sac_pwmg_hdsp
XRDCTRL VDDP VDDPI VSS VBP VBN LWERD LWEWR SAET SAPRT FLOAT FLOATT_PGM TEST_RNM
+ BKSA LDFTX LWEIB SAEDL SAEDR STCLK T1T mm16a05_u_hdsp_plus_rdctrl_sa
.ends

.subckt mm16a05_u_ram6t_corner_hs1prf VSS VBA
MNPD_corner noconnect1 noconnect_gate1 VSS VBA spjnfetpd cpp=110n p_la=0 ulp=0
+ nf=1 l=30n w=100n m=1
.ends

.subckt mm16a05_u_hdsp_plus_capmux VDDA VDDP VDDPI VSS VBP VBN BOTEDGE LOG0
+ LOG1 PGIOI PO VBA VEDGE
XDUMMY0 VSS VBA mm16a05_u_ram6t_corner_hs1prf
XI8 VDDP VSS VBP VBN LOG0 LOG1 mm16a05_u_logrepedge
.ends

.subckt mm16a05_u_strap_x1_hc_gf22 VDDA VDDAI VSS VBP VBN VBA bb diff_nc1
+ strap_diff strap_gate
MPPU_strap VDDAI netg1 nocon VBA spjpfetpu cpp=110n p_la=0 ulp=0 nf=1 l=30n
+ w=50n m=1
MNPD_strap VSS netg1 net6 VBA spjnfetpd cpp=110n p_la=0 ulp=0 nf=1 l=30n w=100n
+ m=1
MNPG_strap bb VSS net7 VBA spjnfetwl cpp=110n p_la=0 ulp=0 nf=1 l=30n w=96n m=1
.ends

.subckt mm16a05_u_ram6t_strapx4_hc_gf22 VDDA VDDAI VSS VBP VBN BB[0] BB[1]
+ BB[2] BB[3] VBA strap_diff_left strap_diff_right strap_gate_left
+ strap_gate_right
Xtr1 VDDA VDDAI VSS VBP VBN VBA BB[1] net3 net2 net1 mm16a05_u_strap_x1_hc_gf22
Xtr2 VDDA VDDAI VSS VBP VBN VBA BB[2] net4ab net2 net1
+ mm16a05_u_strap_x1_hc_gf22
Xtr3 VDDA VDDAI VSS VBP VBN VBA BB[3] net4 strap_diff_right strap_gate_right
+ mm16a05_u_strap_x1_hc_gf22
Xtr0 VDDA VDDAI VSS VBP VBN VBA BB[0] net3ab strap_diff_left strap_gate_left
+ mm16a05_u_strap_x1_hc_gf22
.ends

.subckt mm16a05_u_hc_cmux_ckprchb VDDP VDDPI VSS VBP VBN PRCHB BADB CKPRCHB
Xckprchb VDDPI VSS VBP VBN PRCHB CKPRCHB mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=120.0n wp=240.0n
.ends

.subckt mm16a05_u_hc_cmux_pg_hdsp VDDP VSS VBP VBN BB BT LOG1 RB RT WB WT RPASS
+ WPASS
MPRT BT RPASS RT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=383n m=1
MPRB BB RPASS RB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=383n m=1
MI42 BB LOG1 RT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=383n m=1
MNWT BT WPASS WT VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=350n m=3
MNWB BB WPASS WB VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=350n m=3
.ends

.subckt mm16a05_u_hc_cmux_pch VDDPI VBP VBN BB BT PRCHB
MBB_PCH VDDPI PRCHB BB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=383.0n
+ m=1
M_EQU BT PRCHB BB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=383.0n m=1
MBT_PCH VDDPI PRCHB BT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=383.0n
+ m=1
.ends

.subckt mm16a05_u_hc_cmux_plus VDDA VDDAI VDDP VDDPI VSS VBP VBN BB BT LOG1 RB
+ RT WB WT PCWRX PRCHB RPASS
XWPASS VDDA VSS VBP VBN WPASS PCWRX mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=2 nf_p=2 wn=240.0n
+ wp=330n
XPG VDDP VSS VBP VBN BB BT LOG1 RB RT WB WT RPASS WPASS
+ mm16a05_u_hc_cmux_pg_hdsp
XPCH VDDPI VBP VBN BB BT PRCHB mm16a05_u_hc_cmux_pch
.ends

.subckt mm16a05_u_hc_cmux2_plus VDDA VDDAI VDDP VDDPI VSS VBP VBN BB[0] BB[1]
+ BT[0] BT[1] LOG1 RB[0] RB[1] RT[0] RT[1] WB[0] WB[1] WT[0] WT[1] PRCHB
+ PRCHWRB[0] PRCHWRB[1] RPASS[0] RPASS[1]
X[0] VDDA VDDAI VDDP VDDPI VSS VBP VBN BB[0] BT[0] LOG1 RB[0] RT[0] WB[0] WT[0]
+ PRCHWRB[0] PRCHB RPASS[0] mm16a05_u_hc_cmux_plus
X[1] VDDA VDDAI VDDP VDDPI VSS VBP VBN BB[1] BT[1] LOG1 RB[1] RT[1] WB[1] WT[1]
+ PRCHWRB[1] PRCHB RPASS[1] mm16a05_u_hc_cmux_plus
.ends

.subckt mm16a05_u_hdsp_plus_hc_cmux4x1 VDDA VDDAI VDDP VDDPI VSS VBP VBN BB[0]
+ BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3] LOG0 LOG1 PO[0] PO[1] POWINT[0]
+ POWINT[1] QB QT RB RT VBA WB WBI WT WTI CKPRCH PRCHRDB[0] PRCHRDB[1]
+ PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] SEL
XDUMMY VDDA VDDAI VSS VBP VBN BB[0] BB[1] BB[2] BB[3] VBA net146 net147 net148
+ net149 mm16a05_u_ram6t_strapx4_hc_gf22
XINV_RD[0] VDDPI VSS VBP VBN RPASS[0] SEL PRCHRDB[0]
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=165.0n
+ wp2=165.0n
XINV_RD[1] VDDPI VSS VBP VBN RPASS[1] SEL PRCHRDB[1]
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=165.0n
+ wp2=165.0n
XINV_RD[2] VDDPI VSS VBP VBN RPASS[2] SEL PRCHRDB[2]
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=165.0n
+ wp2=165.0n
XINV_RD[3] VDDPI VSS VBP VBN RPASS[3] SEL PRCHRDB[3]
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=165.0n
+ wp2=165.0n
XICKPRCHB VDDP VDDPI VSS VBP VBN PRCHB net150 CKPRCH mm16a05_u_hc_cmux_ckprchb
XMX00 VDDA VDDA VDDP VDDPI VSS VBP VBN BB[0] BB[1] BT[0] BT[1] LOG1 RB RB RT RT
+ WB WB WT WT PRCHB PRCHWRB[0] PRCHWRB[1] RPASS[0] RPASS[1]
+ mm16a05_u_hc_cmux2_plus
XMXFF VDDA VDDA VDDP VDDPI VSS VBP VBN BB[2] BB[3] BT[2] BT[3] LOG1 RB RB RT RT
+ WB WB WT WT PRCHB PRCHWRB[2] PRCHWRB[3] RPASS[2] RPASS[3]
+ mm16a05_u_hc_cmux2_plus
.ends

.subckt mm16a05_u_pg_wlstkrw_plus1 VDDA VDDWL VSS VBP VBN LCGTHB LCGTH
MI11 VDDWL VDDWL VDDA VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=300n m=1
MI10 VDDA LCGTH VDDWL VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=345n
+ m=10
M0 VDDA LCGTH VDDWL VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=345n m=20
M1 VDDA VDDWL VDDWL VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=300n m=1
XI15 VDDA VSS VBP VBN LCGTHB LCGTH mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240.0n
+ wp=240.0n
.ends

.subckt mm16a05_u_hdsp_plus_lcenbuf_int VDDA VDDP VDDPI VDDWL VNWP VSS VBP VBN
+ LCGTHB PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+ PRCHWRB[2] PRCHWRB[3] RASSISTB[0] RASSISTB[1] LCGTH PRCHRD[0] PRCHRD[1]
+ PRCHRD[2] PRCHRD[3] PRCHWR[0] PRCHWR[1] PRCHWR[2] PRCHWR[3] PROCOML
+ RASSIST[0] RASSIST[1]
XI22 VDDA VDDWL VSS VBP VBN LCGTHB LCGTH mm16a05_u_pg_wlstkrw_plus1
XI78[0] VDDPI VSS VBP VBN RASSISTB[0] RASSIST[0] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI78[1] VDDPI VSS VBP VBN RASSISTB[1] RASSIST[1] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=240n
XI6[0] VDDPI VSS VBP VBN PRCHRDB[0] PRCHRD[0] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=750n wp=950n
XI6[1] VDDPI VSS VBP VBN PRCHRDB[1] PRCHRD[1] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=750n wp=950n
XI6[2] VDDPI VSS VBP VBN PRCHRDB[2] PRCHRD[2] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=750n wp=950n
XI6[3] VDDPI VSS VBP VBN PRCHRDB[3] PRCHRD[3] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1
+ wn=750n wp=950n
XI12[0] VDDA VSS VBP VBN PRCHWRB[0] PRCHWR[0] mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1
+ wn=640n wp=500n
XI12[1] VDDA VSS VBP VBN PRCHWRB[1] PRCHWR[1] mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1
+ wn=640n wp=500n
XI12[2] VDDA VSS VBP VBN PRCHWRB[2] PRCHWR[2] mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1
+ wn=640n wp=500n
XI12[3] VDDA VSS VBP VBN PRCHWRB[3] PRCHWR[3] mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1
+ wn=640n wp=500n
.ends

.subckt mm16a05_u_hdsp_plus_lcenbuf_base VDDA VDDP VDDPI VDDWL VSS VBP VBN
+ CKPRCH LCGTHB PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0]
+ PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] RASSISTB[0] RASSISTB[1] CKPRCHB LCGTH
+ PRCHRD[0] PRCHRD[1] PRCHRD[2] PRCHRD[3] PRCHWR[0] PRCHWR[1] PRCHWR[2]
+ PRCHWR[3] RASSIST[0] RASSIST[1]
XI126[0] VDDPI VSS VBP VBN PRCHRD_INT[0] net244[0]
+ mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=350n wp=350n
XI126[1] VDDPI VSS VBP VBN PRCHRD_INT[1] net244[1]
+ mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=350n wp=350n
XI126[2] VDDPI VSS VBP VBN PRCHRD_INT[2] net244[2]
+ mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=350n wp=350n
XI126[3] VDDPI VSS VBP VBN PRCHRD_INT[3] net244[3]
+ mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=350n wp=350n
XI129 VDDPI VSS VBP VBN CKPRCHBB CKPRCHB mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=2 nf_p=2
+ wn=350n wp=700n
XI127[0] VDDPI VSS VBP VBN net244[0] PRCHRD[0] mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=240n
XI127[1] VDDPI VSS VBP VBN net244[1] PRCHRD[1] mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=240n
XI127[2] VDDPI VSS VBP VBN net244[2] PRCHRD[2] mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=240n
XI127[3] VDDPI VSS VBP VBN net244[3] PRCHRD[3] mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=240n
XINV_PRCH VDDPI VSS VBP VBN CKPRCH CKPRCHBB mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=12 m_p=12 nf_n=1 nf_p=1
+ wn=460n wp=300n
Xinv_prckwr[0] VDDA VSS VBP VBN net276[0] PRCHWR[0]
+ mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=500n wp=700n
Xinv_prckwr[1] VDDA VSS VBP VBN net276[1] PRCHWR[1]
+ mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=500n wp=700n
Xinv_prckwr[2] VDDA VSS VBP VBN net276[2] PRCHWR[2]
+ mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=500n wp=700n
Xinv_prckwr[3] VDDA VSS VBP VBN net276[3] PRCHWR[3]
+ mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=500n wp=700n
Xprch VDDA VDDP VDDPI VDDWL VDDP VSS VBP VBN LCGTHB PRCHRDB[0] PRCHRDB[1]
+ PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] RASSISTB[0]
+ RASSISTB[1] LCGTH PRCHRD_INT[0] PRCHRD_INT[1] PRCHRD_INT[2] PRCHRD_INT[3]
+ net276[0] net276[1] net276[2] net276[3] LCGTH RASSIST[0] RASSIST[1]
+ mm16a05_u_hdsp_plus_lcenbuf_int
.ends

.subckt mm16a05_u_hdsp_plus_lcenbuf VDDA VDDP VDDPI VDDWL VSS VBP VBN CKPRCH
+ LCGTHB PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+ PRCHWRB[2] PRCHWRB[3] RASSISTB[0] RASSISTB[1] ARYSD ARYSD_BC1 ARYSD_BC2
+ BOTEDGE PO VBA CKPRCHB LCGTH LOG0 LOG1 PRCHRD[0] PRCHRD[1] PRCHRD[2]
+ PRCHRD[3] PRCHWRH[0] PRCHWRH[1] PRCHWRH[2] PRCHWRH[3] RASSIST[0] RASSIST[1]
Xlcbuf VDDA VDDP VDDPI VDDWL VSS VBP VBN CKPRCH LCGTHB PRCHRDB[0] PRCHRDB[1]
+ PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] RASSISTB[0]
+ RASSISTB[1] CKPRCHB LCGTH PRCHRD[0] PRCHRD[1] PRCHRD[2] PRCHRD[3] PRCHWRH[0]
+ PRCHWRH[1] PRCHWRH[2] PRCHWRH[3] RASSIST[0] RASSIST[1]
+ mm16a05_u_hdsp_plus_lcenbuf_base
XDUMMY0 VSS VBA mm16a05_u_ram6t_corner_hs1prf
.ends

.subckt mm16a05_u_aoi21_bulk_local_lcen VDD VSS VBP VBN X A1 A2 B
MNA1 X A1 net13 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=300n m=1
MNA2 net13 A2 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=300n m=1
MNB X B VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=200n m=1
MPA2 XP A2 X VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=500n m=1
M4 XP A1 X VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=250n m=1
M0 VDD B XP VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=500n m=1
.ends

.subckt mm16a05_u_hs1prf_cdec_nd3_rd VDDPI VNWP VSS VBP VBN PRCH DECB_CMN A
+ CMUX_CLK LLWE
M31 VDDPI LLWE PRCH VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
M20 VDDPI CMUX_CLK PRCH VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n
+ m=1
M18 VDDPI A PRCH VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
M17 PRCH A DECB_CMN VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=3
.ends

.subckt mm16a05_u_cdec VDDP VDDPI VSS VBP VBN PRCH[0] PRCH[1] PRCH[2] PRCH[3]
+ A[0] A[1] A[2] A[3] CMUX_CLK LLWE
M17 CMN_LLWE LLWE VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=3
M27 CMUX_CLKB CMUX_CLK CMN_LLWE VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=3
XI26 VDDPI VDDP VSS VBP VBN PRCH[0] CMUX_CLKB A[0] CMUX_CLK LLWE
+ mm16a05_u_hs1prf_cdec_nd3_rd
XI25 VDDPI VDDP VSS VBP VBN PRCH[1] CMUX_CLKB A[1] CMUX_CLK LLWE
+ mm16a05_u_hs1prf_cdec_nd3_rd
XI24 VDDPI VDDP VSS VBP VBN PRCH[2] CMUX_CLKB A[2] CMUX_CLK LLWE
+ mm16a05_u_hs1prf_cdec_nd3_rd
XI23 VDDPI VDDP VSS VBP VBN PRCH[3] CMUX_CLKB A[3] CMUX_CLK LLWE
+ mm16a05_u_hs1prf_cdec_nd3_rd
.ends

.subckt mm16a05_u_xpredec_3to8 VDDP VDDPI VSS VBP VBN POUT[0] POUT[1] POUT[2]
+ POUT[3] POUT[4] POUT[5] POUT[6] POUT[7] PD A[0] A[1] A[2]
XI86 VDDPI PD VBP VBN POUT[7] A[0] A[1] A[2]
+ mm16a05_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=640n
+ wn2=640n wn3=640n wp1=240n wp2=240n wp3=240n
XI85 VDDPI PD VBP VBN POUT[6] AB[0] A[1] A[2]
+ mm16a05_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=640n
+ wn2=640n wn3=640n wp1=240n wp2=240n wp3=240n
XI84 VDDPI PD VBP VBN POUT[5] A[0] AB[1] A[2]
+ mm16a05_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=640n
+ wn2=640n wn3=640n wp1=240n wp2=240n wp3=240n
XI95 VDDPI PD VBP VBN POUT[1] A[0] AB[1] AB[2]
+ mm16a05_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=640n
+ wn2=640n wn3=640n wp1=240n wp2=240n wp3=240n
XI96 VDDPI PD VBP VBN POUT[2] AB[0] A[1] AB[2]
+ mm16a05_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=640n
+ wn2=640n wn3=640n wp1=240n wp2=240n wp3=240n
XI94 VDDPI PD VBP VBN POUT[0] AB[0] AB[1] AB[2]
+ mm16a05_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=640n
+ wn2=640n wn3=640n wp1=240n wp2=240n wp3=240n
XI97 VDDPI PD VBP VBN POUT[3] A[0] A[1] AB[2]
+ mm16a05_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=640n
+ wn2=640n wn3=640n wp1=240n wp2=240n wp3=240n
XI60 VDDPI PD VBP VBN POUT[4] AB[0] AB[1] A[2]
+ mm16a05_u_nd3_bulk_n1_vt2_n2_vt2_n3_vt2_p1_vt2_p2_vt2_p3_vt2 cpp=104n
+ p_la_n1=4n p_la_n2=4n p_la_n3=4n p_la_p1=4n p_la_p2=4n p_la_p3=4n ulp=0
+ ln1=20n ln2=20n ln3=20n lp1=20n lp2=20n lp3=20n m_n1=1 m_n2=1 m_n3=1 m_p1=1
+ m_p2=1 m_p3=1 nf_n1=1 nf_n2=1 nf_n3=1 nf_p1=1 nf_p2=1 nf_p3=1 wn1=640n
+ wn2=640n wn3=640n wp1=240n wp2=240n wp3=240n
XINV_ADD[0] VDDPI VSS VBP VBN AB[0] A[0] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=160n wp=240n
XINV_ADD[1] VDDPI VSS VBP VBN AB[1] A[1] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=160n wp=240n
XINV_ADD[2] VDDPI VSS VBP VBN AB[2] A[2] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=160n wp=240n
.ends

.subckt mm16a05_u_predec_2to4_bk VDDP VDDPI VSS VBP VBN PMB[0] PMB[1] PMB[2]
+ PMB[3] A[0] A[1]
Xinv_adr[0] VDDPI VSS VBP VBN AB[0] A[0] mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
Xinv_adr[1] VDDPI VSS VBP VBN AB[1] A[1] mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI72 VDDPI VSS VBP VBN PMB[1] AB[1] A[0]
+ mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=120n
+ wp2=120n
XI74 VDDPI VSS VBP VBN PMB[0] AB[1] AB[0]
+ mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=120n
+ wp2=120n
XI71 VDDPI VSS VBP VBN PMB[3] A[0] A[1]
+ mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=120n
+ wp2=120n
XI69 VDDPI VSS VBP VBN PMB[2] AB[0] A[1]
+ mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=120n
+ wp2=120n
.ends

.subckt mm16a05_u_pdec_nr2 VDDA VSS VBP VBN WCLK DECB_CMN CLK_WL XPRB
XI27 VDDA VSS VBP VBN WCLK WCLKB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=10 m_p=10 nf_n=1 nf_p=1 wn=520n
+ wp=225n
M17 WCLKB XPRB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=450n m=1
MI34 WCLKB CLK_WL VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=450n m=2
M31 DECB_CMN XPRB WCLKB VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=624n
+ m=3
.ends

.subckt mm16a05_u_predec_2to4_ckb VDDA VSS VBP VBN WCLKB[0] WCLKB[1] WCLKB[2]
+ WCLKB[3] CLK_WLB XPRB[0] XPRB[1] XPRB[2] XPRB[3]
M31 VDDA CLK_WLB DECB_CMN VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=1087n m=4
XI28 VDDA VSS VBP VBN WCLKB[0] DECB_CMN CLK_WLB XPRB[0] mm16a05_u_pdec_nr2
XI27 VDDA VSS VBP VBN WCLKB[3] DECB_CMN CLK_WLB XPRB[3] mm16a05_u_pdec_nr2
XI26 VDDA VSS VBP VBN WCLKB[2] DECB_CMN CLK_WLB XPRB[2] mm16a05_u_pdec_nr2
XI25 VDDA VSS VBP VBN WCLKB[1] DECB_CMN CLK_WLB XPRB[1] mm16a05_u_pdec_nr2
.ends

.subckt mm16a05_u_xpred VDDA VDDP VDDPI VSS VBP VBN PBB[0] PBB[1] PBB[2] PBB[3]
+ PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6]
+ PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] LOG1 XPRBH[0] XPRBH[1] XPRBH[2]
+ XPRBH[3] XPRBL[0] XPRBL[1] XPRBL[2] XPRBL[3] CLK_WLB LDFTX LMATCHB XADR[0]
+ XADR[1] XADR[2] XADR[3] XADR[4] XADR[5] XADR[6] XADR[7]
XI62 VDDP VDDPI VSS VBP VBN PC[0] PC[1] PC[2] PC[3] PC[4] PC[5] PC[6] PC[7] VSS
+ XADR[5] XADR[6] XADR[7] mm16a05_u_xpredec_3to8
XI61 VDDP VDDPI VSS VBP VBN PB[0] PB[1] PB[2] PB[3] PB[4] PB[5] PB[6] PB[7]
+ net134 XADR[2] XADR[3] XADR[4] mm16a05_u_xpredec_3to8
XI63[0] VDDPI VSS VBP VBN PCB[0] PC[0] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=320n
XI63[1] VDDPI VSS VBP VBN PCB[1] PC[1] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=320n
XI63[2] VDDPI VSS VBP VBN PCB[2] PC[2] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=320n
XI63[3] VDDPI VSS VBP VBN PCB[3] PC[3] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=320n
XI63[4] VDDPI VSS VBP VBN PCB[4] PC[4] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=320n
XI63[5] VDDPI VSS VBP VBN PCB[5] PC[5] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=320n
XI63[6] VDDPI VSS VBP VBN PCB[6] PC[6] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=320n
XI63[7] VDDPI VSS VBP VBN PCB[7] PC[7] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=250n
+ wp=320n
XI59[0] VDDPI VSS VBP VBN PBB[0] PB[0] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=500n
+ wp=640n
XI59[1] VDDPI VSS VBP VBN PBB[1] PB[1] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=500n
+ wp=640n
XI59[2] VDDPI VSS VBP VBN PBB[2] PB[2] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=500n
+ wp=640n
XI59[3] VDDPI VSS VBP VBN PBB[3] PB[3] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=500n
+ wp=640n
XI59[4] VDDPI VSS VBP VBN PBB[4] PB[4] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=500n
+ wp=640n
XI59[5] VDDPI VSS VBP VBN PBB[5] PB[5] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=500n
+ wp=640n
XI59[6] VDDPI VSS VBP VBN PBB[6] PB[6] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=500n
+ wp=640n
XI59[7] VDDPI VSS VBP VBN PBB[7] PB[7] mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=500n
+ wp=640n
MI64 net134 LMATCHB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=640n
+ m=2
XI53 VDDP VDDPI VSS VBP VBN XPRBL[0] XPRBL[1] XPRBL[2] XPRBL[3] XADR[0] XADR[1]
+ mm16a05_u_predec_2to4_bk
XI52 VDDA VSS VBP VBN WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] CLK_WLB XPRBH[0]
+ XPRBH[1] XPRBH[2] XPRBH[3] mm16a05_u_predec_2to4_ckb
MI60[0] VDDPI LMATCHB PB[0] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=620n m=1
MI60[1] VDDPI LMATCHB PB[1] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=620n m=1
MI60[2] VDDPI LMATCHB PB[2] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=620n m=1
MI60[3] VDDPI LMATCHB PB[3] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=620n m=1
MI60[4] VDDPI LMATCHB PB[4] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=620n m=1
MI60[5] VDDPI LMATCHB PB[5] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=620n m=1
MI60[6] VDDPI LMATCHB PB[6] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=620n m=1
MI60[7] VDDPI LMATCHB PB[7] VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=620n m=1
.ends

.subckt mm16a05_u_cen_delay VDDP VDDPI VSS VBP VBN DLY_4 IN
XI12 VDDPI VSS VBP VBN net99 IN mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI31 VDDPI VSS VBP VBN net101 net106 mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI22 VDDPI VSS VBP VBN net106 net99 mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI30 VDDPI VSS VBP VBN DLY_4 net101 mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
.ends

.subckt mm16a05_u_hd1p_cdec_nd3_wr VDDPI VNWP VSS VBP VBN PRCH DECB_CMN A
+ CMUX_CLK LLWE
M31 VDDPI LLWE PRCH VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
M20 VDDPI CMUX_CLK PRCH VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n
+ m=1
M18 VDDPI A PRCH VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
M17 PRCH A DECB_CMN VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=3
.ends

.subckt mm16a05_u_hdsp_cdec_wr VDDP VDDPI VSS VBP VBN PRCH[0] PRCH[1] PRCH[2]
+ PRCH[3] A[0] A[1] A[2] A[3] CMUX_CLK LLWE
XI26 VDDPI VDDP VSS VBP VBN PRCH[0] CMUX_CLKB A[0] CMUX_CLK LLWE
+ mm16a05_u_hd1p_cdec_nd3_wr
XI25 VDDPI VDDP VSS VBP VBN PRCH[1] CMUX_CLKB A[1] CMUX_CLK LLWE
+ mm16a05_u_hd1p_cdec_nd3_wr
XI24 VDDPI VDDP VSS VBP VBN PRCH[2] CMUX_CLKB A[2] CMUX_CLK LLWE
+ mm16a05_u_hd1p_cdec_nd3_wr
XI23 VDDPI VDDP VSS VBP VBN PRCH[3] CMUX_CLKB A[3] CMUX_CLK LLWE
+ mm16a05_u_hd1p_cdec_nd3_wr
M17 CMN_LLWE LLWE VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n m=3
M27 CMUX_CLKB CMUX_CLK CMN_LLWE VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=3
.ends

.subckt mm16a05_u_hdsp_plus_lcen VDDA VDDMINB VDDP VDDPI VSS VSSC_WL_L
+ VSSC_WL_R VBP VBN CKPRCHB LMATCH PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5]
+ PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7]
+ PRCHRD[0] PRCHRD[1] PRCHRD[2] PRCHRD[3] PRCHWR[0] PRCHWR[1] PRCHWR[2]
+ PRCHWR[3] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] BYP_VLOAD CENDP CLK_WLBH
+ CLK_WLBL DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LDFTX LITESLP
+ LOG0 LOG1 LWEIB LWERD LWEWR PRCHWRH[0] PRCHWRH[1] PRCHWRH[2] PRCHWRH[3] RBLRD
+ RBLWA RBLWR RWLB_SAC WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3]
+ WPBUF[0] WPBUF[1] WPBUF[2] XPRBH[0] XPRBH[1] XPRBH[2] XPRBH[3] XPRBL[0]
+ XPRBL[1] XPRBL[2] XPRBL[3] LBKADR[0] LBKADR[1] LBKADR[2] LCGTHB LCGTH_PCHG
+ LMATCHB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6]
+ LXADR[7] LYADR[0] LYADR[1] PM[0] PM[1] PM[2] PM[3] PRCKE RM3CNT RMT[0] RMT[1]
+ RMT[2] RMT[3] T1T TEST_RNMB
XI145 VDDPI VSS VBP VBN TEST_RNM TEST_RNMB mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI153 VDDP VSS VBP VBN CLK_WLBL CLK_WL mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=730n
+ wp=300n
XI162 VDDPI VSS VBP VBN LDFTXB LDFTX mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI135 VDDPI VSS VBP VBN LMATCH LMATCHB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n
+ wp=240n
XI166 VDDPI VSS VBP VBN PRCKEB PRCKE mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI149 VDDPI VSS VBP VBN PRCKE_RNMB PRCKE_RNM mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=240n wp=120n
XI147 VDDPI VSS VBP VBN PRCKE_RNM PRCKE TEST_RNM
+ mm16a05_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=600n wn2=600n wp1=900n
+ wp2=900n
XI160 VDDPI VSS VBP VBN CLK_WL net246 FLOAT
+ mm16a05_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=720n
+ wp2=720n
XI150 VDDPI VSS VBP VBN PRCLK PRCKE_RNMB FLOAT
+ mm16a05_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=640n
+ wp2=640n
XI139 VDDPI VSS VBP VBN PRCK_FLT net247 FLOAT PRCKE
+ mm16a05_u_aoi21_bulk_local_lcen
XI152 VDDP VDDPI VSS VBP VBN PRCHRD[0] PRCHRD[1] PRCHRD[2] PRCHRD[3] PM[0]
+ PM[1] PM[2] PM[3] PRCLK LWERD mm16a05_u_cdec
MI188 VSSC_WL_L LCGTHB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=480.0n m=2
MI187 VSSC_WL_R LCGTHB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=480.0n m=2
Mndmy2 CKPRCHB LCGTH_PCHG VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=1
Xpredec VDDA VDDP VDDPI VSS VBP VBN PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5]
+ PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7]
+ WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] LOG1 XPRBH[0] XPRBH[1] XPRBH[2] XPRBH[3]
+ XPRBL[0] XPRBL[1] XPRBL[2] XPRBL[3] CLK_WLBH LDFTX LMATCHB LXADR[0] LXADR[1]
+ LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] mm16a05_u_xpred
XI141 VDDP VDDPI VSS VBP VBN net247 FLOAT mm16a05_u_cen_delay
XI151 VDDP VDDP VSS VBP VBN PRCHWR[0] PRCHWR[1] PRCHWR[2] PRCHWR[3] PM[0] PM[1]
+ PM[2] PM[3] PRCLK LWEWR mm16a05_u_hdsp_cdec_wr
XI146 net244 VSS VBP VBN CKPRCHB PRCK_FLT PRCKE_RNM
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=8 m_n2=8
+ m_p1=4 m_p2=4 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=200n wn2=200n wp1=150n
+ wp2=150n
XI161 VDDPI VSS VBP VBN net246 PRCKEB LDFTXB
+ mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=320n wn2=320n wp1=120n
+ wp2=120n
Mpdmy2 VDDPI LCGTH_PCHG net244 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=430n m=3
.ends

.subckt mm16a05_u_edge1_hc VSS VBP VBN VBA WL edge_bot edge_top
MNPG_edge netnc1 WL edge_top VBA spjnfetwl cpp=110n p_la=0 ulp=0 nf=1 l=30n
+ w=96n m=1
MNPD_edge edge_bot noconn netnc1 VBA spjnfetpd cpp=110n p_la=0 ulp=0 nf=1 l=30n
+ w=100n m=1
.ends

.subckt mm16a05_u_edge4_hc VSS VBP VBN VBA WL[0] WL[1] WL[2] WL[3]
Xedge3 VSS VBP VBN VBA WL[3] VSS VSS mm16a05_u_edge1_hc
Xedge2 VSS VBP VBN VBA WL[2] VSS VSS mm16a05_u_edge1_hc
Xedge1 VSS VBP VBN VBA WL[1] VSS VSS mm16a05_u_edge1_hc
Xedge0 VSS VBP VBN VBA WL[0] VSS VSS mm16a05_u_edge1_hc
.ends

.subckt mm16a05_u_hdsp_plus_edge4 VDDA VDDP VDDPI VSS VBP VBN EDGEB EDGET LOG0
+ LOG1 PGIOI VBA VEDGE WL[0] WL[1] WL[2] WL[3]
XDUMMY0 VSS VBP VBN VBA WL[0] WL[1] WL[2] WL[3] mm16a05_u_edge4_hc
.ends

.subckt mm16a05_u_ram6x_base VDDA_RB VDDA_RT VNWA VSSC_RB VSS VBP VBN BB BT RB
+ RT VBA VSCS_RT WL_RB WL_RT
MPPU_T VDDA_RT RB RT VBA spjpfetpu cpp=110n p_la=0 ulp=0 nf=1 l=30n w=50n m=1
MPPU_B VDDA_RB RT RB VBA spjpfetpu cpp=110n p_la=0 ulp=0 nf=1 l=30n w=50n m=1
MNPG_B BB WL_RB RB VBA spjnfetwl cpp=110n p_la=0 ulp=0 nf=1 l=30n w=96n m=1
MNPD_T VSCS_RT RB RT VBA spjnfetpd cpp=110n p_la=0 ulp=0 nf=1 l=30n w=100n m=1
MNPG_T BT WL_RT RT VBA spjnfetwl cpp=110n p_la=0 ulp=0 nf=1 l=30n w=96n m=1
MNPD_B VSSC_RB RT RB VBA spjnfetpd cpp=110n p_la=0 ulp=0 nf=1 l=30n w=100n m=1
.ends

.subckt mm16a05_u_ram6x VDDA_RB VDDA_RT VNWA VSS VSSC_RB VBP VBN BB BT RB RT
+ VBA VSCS_RT WL_RB WL_RT
XBASE VDDA_RB VDDA_RT VNWA VSSC_RB VSS VBP VBN BB BT RB RT VBA VSCS_RT WL_RB
+ WL_RT mm16a05_u_ram6x_base
.ends

.subckt mm16a05_u_ram6t VDDA VNWA VSS VSSC VBP VBN BB BT VBA WL
XRAM VDDA VDDA VNWA VSS VSSC VBP VBN BB BT RB RT VBA VSSC WL WL mm16a05_u_ram6x
.ends

.subckt mm16a05_u_hd1p_bar4x4m4 VDDA VDDAI VDDP VSS VBP VBN BB[0] BB[1] BB[2]
+ BB[3] BT[0] BT[1] BT[2] BT[3] QBB QTB SEL VBA WBI WTI WL[0] WL[1] WL[2] WL[3]
XA00 VDDAI VDDA VSS VSS VBP VBN BB[0] BT[0] VBA WL[0] mm16a05_u_ram6t
XA01 VDDAI VDDA VSS VSS VBP VBN BB[1] BT[1] VBA WL[0] mm16a05_u_ram6t
XA02 VDDAI VDDA VSS VSS VBP VBN BB[2] BT[2] VBA WL[0] mm16a05_u_ram6t
XAFF VDDAI VDDA VSS VSS VBP VBN BB[3] BT[3] VBA WL[0] mm16a05_u_ram6t
XC00 VDDAI VDDA VSS VSS VBP VBN BB[0] BT[0] VBA WL[2] mm16a05_u_ram6t
XCFF VDDAI VDDA VSS VSS VBP VBN BB[3] BT[3] VBA WL[2] mm16a05_u_ram6t
XC01 VDDAI VDDA VSS VSS VBP VBN BB[1] BT[1] VBA WL[2] mm16a05_u_ram6t
XBFF VDDAI VDDA VSS VSS VBP VBN BB[3] BT[3] VBA WL[1] mm16a05_u_ram6t
XB02 VDDAI VDDA VSS VSS VBP VBN BB[2] BT[2] VBA WL[1] mm16a05_u_ram6t
XB01 VDDAI VDDA VSS VSS VBP VBN BB[1] BT[1] VBA WL[1] mm16a05_u_ram6t
XB00 VDDAI VDDA VSS VSS VBP VBN BB[0] BT[0] VBA WL[1] mm16a05_u_ram6t
XD02 VDDAI VDDA VSS VSS VBP VBN BB[2] BT[2] VBA WL[3] mm16a05_u_ram6t
XC02 VDDAI VDDA VSS VSS VBP VBN BB[2] BT[2] VBA WL[2] mm16a05_u_ram6t
XD01 VDDAI VDDA VSS VSS VBP VBN BB[1] BT[1] VBA WL[3] mm16a05_u_ram6t
XD00 VDDAI VDDA VSS VSS VBP VBN BB[0] BT[0] VBA WL[3] mm16a05_u_ram6t
XDFF VDDAI VDDA VSS VSS VBP VBN BB[3] BT[3] VBA WL[3] mm16a05_u_ram6t
.ends

.subckt mm16a05_u_hdsp_plus_ar4x4m4 VDDA VDDAI VDDP VDDPI VSS VBP VBN BB[0]
+ BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3] QB QT SEL VBA WBI WTI WL[0] WL[1]
+ WL[2] WL[3]
XBAR4 VDDA VDDAI VDDP VSS VBP VBN BB[0] BB[1] BB[2] BB[3] BT[0] BT[1] BT[2]
+ BT[3] QB QT SEL VBA WBI WTI WL[0] WL[1] WL[2] WL[3] mm16a05_u_hd1p_bar4x4m4
.ends

.subckt mm16a05_u_hd1p_xbuf1_gf VDDWL VDD_BK VSS VBP VBN WL WLB
MI6 VDDWL WLB WL VBP lvtpfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=1420.0n m=4
M17 WL WLB VSS VBN lvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=760.0n m=4
.ends

.subckt mm16a05_u_read_assist VDD_BULK VSS VBP VBN RD_ASSIST_BIAS[0]
+ RD_ASSIST_BIAS[1] WL
M0 WL RD_ASSIST_BIAS[0] VSS VBP lvtpfet cpp=110n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=4
M1 WL RD_ASSIST_BIAS[1] VSS VBP lvtpfet cpp=110n p_la=4n ulp=0 nf=1 l=20n
+ w=180n m=4
.ends

.subckt mm16a05_u_xbuf4_plus VDDWL VDD_BK VSS VBP VBN WL[0] WL[1] WL[2] WL[3]
+ RD_ASSIST_BIAS[0] RD_ASSIST_BIAS[1] WLB[0] WLB[1] WLB[2] WLB[3]
XWL3 VDDWL VDD_BK VSS VBP VBN WL[3] WLB[3] mm16a05_u_hd1p_xbuf1_gf
XWL2 VDDWL VDD_BK VSS VBP VBN WL[2] WLB[2] mm16a05_u_hd1p_xbuf1_gf
XWL0 VDDWL VDD_BK VSS VBP VBN WL[0] WLB[0] mm16a05_u_hd1p_xbuf1_gf
XWL1 VDDWL VDD_BK VSS VBP VBN WL[1] WLB[1] mm16a05_u_hd1p_xbuf1_gf
XI21 VDD_BK VSS VBP VBN RD_ASSIST_BIAS[0] RD_ASSIST_BIAS[1] WL[2]
+ mm16a05_u_read_assist
XI20 VDD_BK VSS VBP VBN RD_ASSIST_BIAS[0] RD_ASSIST_BIAS[1] WL[3]
+ mm16a05_u_read_assist
XI22 VDD_BK VSS VBP VBN RD_ASSIST_BIAS[0] RD_ASSIST_BIAS[1] WL[1]
+ mm16a05_u_read_assist
XI23 VDD_BK VSS VBP VBN RD_ASSIST_BIAS[0] RD_ASSIST_BIAS[1] WL[0]
+ mm16a05_u_read_assist
.ends

.subckt mm16a05_u_x4buf_base_plus VDDWL VDDA VSS VBP VBN WL[0] WL[1] WL[2]
+ WL[3] RD_ASSIST_BIAS[0] RD_ASSIST_BIAS[1] WLB[0] WLB[1] WLB[2] WLB[3]
XDEC VDDWL VDDA VSS VBP VBN WL[0] WL[1] WL[2] WL[3] RD_ASSIST_BIAS[0]
+ RD_ASSIST_BIAS[1] WLB[0] WLB[1] WLB[2] WLB[3] mm16a05_u_xbuf4_plus
.ends

.subckt mm16a05_u_hdsp_plus_x4buf VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[0] WL[1]
+ WL[2] WL[3] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB EDGET LCGTH LOG0 LOG1 RASSIST[0]
+ RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[0] WLB[1] WLB[2] WLB[3]
XBUF VDDWL VDDA VSS VBP VBN WL[0] WL[1] WL[2] WL[3] RASSISTB[0] RASSISTB[1]
+ WLB[0] WLB[1] WLB[2] WLB[3] mm16a05_u_x4buf_base_plus
XDUMMY VSS VBP VBN VBA WL[0] WL[1] WL[2] WL[3] mm16a05_u_edge4_hc
.ends

.subckt mm16a05_u_hd1p_rbl_load VSS VBP VBN LOG0 RBLRD RBLWA RBLWR RBLWR_LOAD
M0 X1 LOG0 RBLRD VBN lvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
MI16 X3 LOG0 RBLWA VBN lvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI15 X2 LOG0 RBLWA VBN lvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI14 X1 LOG0 RBLWA VBN lvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M13 X4 LOG0 RBLWR_LOAD VBN lvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M12 X4 LOG0 net52 VBN lvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
M11 X3 LOG0 RBLWR_LOAD VBN lvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M10 X3 LOG0 net52 VBN lvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
M9 X2 LOG0 RBLWR_LOAD VBN lvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI17 X4 LOG0 RBLWA VBN lvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M8 X2 LOG0 RBLRD VBN lvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
M1 X1 LOG0 RBLWR_LOAD VBN lvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
.ends

.subckt mm16a05_u_xdec_nr2_plus VDDA VSS VBP VBN WLBB SOFTVDDA DEC WCLKB
M17 WLBB WCLKB VSS VBN slvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=240n m=2
MI39 WLBB DEC VSS VBN slvtnfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=240n m=1
M33 SOFTVDDA WCLKB WLBB VBP slvtpfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=240n
+ m=2
MI43 SOFTVDDA VDDA VDDA VBP slvtpfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=240n
+ m=1
.ends

.subckt mm16a05_u_xdec_base_plus VDDA VDDP VDDPI VSS VBP VBN DEC_LV WLBB[0]
+ WLBB[1] WLBB[2] WLBB[3] LOG1 B C DEC_HV WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
XDEC_ND2 VDDPI VSS VBP VBN DEC_LV B C
+ mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=110n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=244n wn2=244n wp1=268n
+ wp2=268n
M33 VDDA DEC_HV net264 VBP slvtpfet cpp=110n p_la=4n ulp=0 nf=1 l=20n w=240n
+ m=4
XDEC_NR2[3] VDDA VSS VBP VBN WLBB[3] net264 DEC_HV WCLKB[3]
+ mm16a05_u_xdec_nr2_plus
XDEC_NR2[0] VDDA VSS VBP VBN WLBB[0] net264 DEC_HV WCLKB[0]
+ mm16a05_u_xdec_nr2_plus
XDEC_NR2[1] VDDA VSS VBP VBN WLBB[1] net264 DEC_HV WCLKB[1]
+ mm16a05_u_xdec_nr2_plus
XDEC_NR2[2] VDDA VSS VBP VBN WLBB[2] net264 DEC_HV WCLKB[2]
+ mm16a05_u_xdec_nr2_plus
.ends

.subckt mm16a05_u_hdsp_plus_x4dec VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R
+ VSS VBP VBN DECL WLBH[0] WLBH[1] WLBH[2] WLBH[3] WLBL[0] WLBL[1] WLBL[2]
+ WLBL[3] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET LDFTX
+ LMATCH LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT RMT[0]
+ RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WMT[0]
+ WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] B C CENDP DECH FLOAT
+ LBKADR[0] LBKADR[1] LBKADR[2] LITESLP LXADR[0] LXADR[1] LXADR[2] LXADR[3]
+ LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2]
+ PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5]
+ PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
XREFBL VSS VBP VBN LOG0 RBLRD RBLWA RBLWR RBLWR_LOAD mm16a05_u_hd1p_rbl_load
XINV_WLBB[0] VDDA VSSC_WL_R VBP VBN WLBH[0] WLBB[0]
+ mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=110n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=490n wp=310n
XINV_WLBB[1] VDDA VSSC_WL_R VBP VBN WLBH[1] WLBB[1]
+ mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=110n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=490n wp=310n
XINV_WLBB[2] VDDA VSSC_WL_R VBP VBN WLBH[2] WLBB[2]
+ mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=110n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=490n wp=310n
XINV_WLBB[3] VDDA VSSC_WL_R VBP VBN WLBH[3] WLBB[3]
+ mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=110n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=490n wp=310n
XI104[0] VDDA VSSC_WL_L VBP VBN WLBL[0] WLBB[0] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=110n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=490n wp=310n
XI104[1] VDDA VSSC_WL_L VBP VBN WLBL[1] WLBB[1] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=110n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=490n wp=310n
XI104[2] VDDA VSSC_WL_L VBP VBN WLBL[2] WLBB[2] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=110n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=490n wp=310n
XI104[3] VDDA VSSC_WL_L VBP VBN WLBL[3] WLBB[3] mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=110n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=490n wp=310n
XDECWR VDDA VDDP VDDPI VSS VBP VBN DECL WLBB[0] WLBB[1] WLBB[2] WLBB[3] LOG1 B
+ C DECH WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] mm16a05_u_xdec_base_plus
.ends

.subckt mm16a05_u_hdsp_plus_pg_pwedge VDDA VDDP VDDPI VSS VBP VBN LOG0 LOG1
+ PGIOI PO SDOR_OUT TOPEDGE VBA VEDGE SDOR_IN
XI17 VDDA VSS VBP VBN SDOR_OUT net20 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI13 VDDA VSS VBP VBN net20 SDOR_IN mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=2 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XDUMMY0 VSS VBA mm16a05_u_ram6t_corner_hs1prf
.ends

.subckt mm16a05_u_ram6t_strapx4_hc VDDA VDDAI VSS VBP VBN BB[0] BB[1] BB[2]
+ BB[3] VBA strap_diff_left strap_diff_right strap_gate_left strap_gate_right
Xtr1 VDDA VDDAI VSS VBP VBN VBA BB[1] net3 net2 net1 mm16a05_u_strap_x1_hc_gf22
Xtr2 VDDA VDDAI VSS VBP VBN VBA BB[2] net4 net2 net1 mm16a05_u_strap_x1_hc_gf22
Xtr3 VDDA VDDAI VSS VBP VBN VBA BB[3] net4 strap_diff_right strap_gate_right
+ mm16a05_u_strap_x1_hc_gf22
Xtr0 VDDA VDDAI VSS VBP VBN VBA BB[0] net3 strap_diff_left strap_gate_left
+ mm16a05_u_strap_x1_hc_gf22
.ends

.subckt mm16a05_u_hc_wrwlload VDDA VBP VBN RT RWL RWLD
M3 RT RWL VDDA VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=128n m=3
M2 VDDA RWLD RT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=128n m=3
.ends

.subckt mm16a05_u_corebias_gf22 VDDA VDDAI VBP VBN SDBD1 SDBD2 LLSB SDB_BC1T
+ SDB_BC2T
M0 VDDAI LLSB VDDA VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=200n m=4
M2 SDBD1 SDB_BC1T VDDAI VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=155n
+ m=2
M3 SDBD1 SDBD1 VDDA VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=210n m=5
M7 SDBD2 SDB_BC2T VDDAI VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=155n
+ m=1
M1 SDBD2 SDBD2 VDDA VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=155n m=2
.ends

.subckt mm16a05_u_hdsp_plus_rar4x1 VDDA VDDAI VDDP VDDPI VSS VBP VBN BB[0]
+ BB[1] BB[2] BB[3] LOG0 LOG1 QB QT RWLD_RD RWLD_WR RWL_RD RWL_WR SDOR SDOR_RET
+ SEL VBA WBI WTI LLSB SDB_BC1T SDB_BC2T
XDUMMY VDDA VDDAI VSS VBP VBN BB[0] BB[1] BB[2] BB[3] VBA net120 net121 net122
+ net123 mm16a05_u_ram6t_strapx4_hc
XI64 VDDA VBP VBN net113 RWL_RD RWLD_RD mm16a05_u_hc_wrwlload
XI49[0] VDDA VBP VBN net112 RWL_WR RWLD_WR mm16a05_u_hc_wrwlload
XI49[1] VDDA VBP VBN net112 RWL_WR RWLD_WR mm16a05_u_hc_wrwlload
XI65[0] VDDA VBP VBN net113 RWL_RD RWLD_RD mm16a05_u_hc_wrwlload
XI65[1] VDDA VBP VBN net113 RWL_RD RWLD_RD mm16a05_u_hc_wrwlload
XI33 VDDA VBP VBN net112 RWL_WR RWLD_WR mm16a05_u_hc_wrwlload
XCOREBIAS VDDA VDDAI VBP VBN net88 net87 LLSB SDB_BC1T SDB_BC2T
+ mm16a05_u_corebias_gf22
.ends

.subckt mm16a05_u_arysd_dly_hdsp VDDA VDDAI VSS VBP VBN OUT OUTB IN
XI12 VDDAI VSS VBP VBN net59 IN net49
+ mm16a05_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
MI20 net157 net110 VSS VBN lvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI19 net155 IN VSS VBN lvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MPA VDDAI IN net153 VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI18 VDDA net110 net104 VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
XI15 VDDA VSS VBP VBN OUT net59 mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=4 nf_n=1 nf_p=1 wn=160n
+ wp=160n
XI13 net153 net155 VBP VBN net110 IN mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
Xinv_0 net104 net157 VBP VBN inb net110 mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI10 VDDA VSS VBP VBN net49 outt mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI11 VDDAI VSS VBP VBN outt inb mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI14 VDDA VSS VBP VBN OUTB OUT mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=160n
+ wp=160n
.ends

.subckt mm16a05_u_hdsp_plus_pg_aryslpbuf VDDA VSS VBP VBN ARYSDB_BC1 ARYSDB_BC2
+ ARYSD_DELAY LLSB RESDOR_RET ARYSD_BC1 ARYSD_BC2 ARYSD_IN LCGTH SDOR_RETI
XI22 VDDA VSS VBP VBN net78 LCGTH ARYSD_DELAY
+ mm16a05_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=400n
+ wp2=400n
XI24 VDDAI_R VSS VBP VBN net74 ARYSD_BC1 ARYSD_DELAY
+ mm16a05_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=400n wn2=400n wp1=480n
+ wp2=480n
XI10 VDDAI_R VSS VBP VBN net72 ARYSD_BC2 ARYSD_DELAY
+ mm16a05_u_nr2_bulk_n1_vt1_n2_vt1_p1_vt1_p2_vt1 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=400n wn2=400n wp1=480n
+ wp2=480n
XI17 VDDA VDDA VSS VBP VBN ARYSD_DELAY net82 ARYSD_INT mm16a05_u_arysd_dly_hdsp
XI30 VDDA VSS VBP VBN ARYSDB_BC1 net74 mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=5 m_p=5 nf_n=1 nf_p=1 wn=336n
+ wp=336n
XI25 VDDA VSS VBP VBN ARYSD_INT ARYSD_IN mm16a05_u_inv_bulk_n_vt1_p_vt1
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=320n wp=400n
XI28 VDDA VSS VBP VBN ARYSDB_BC2 net72 mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=3 m_p=3 nf_n=1 nf_p=1 wn=427n
+ wp=267n
XI21 VDDA VSS VBP VBN RESDOR_RET SDOR_RETI mm16a05_u_inv_bulk_n_vt1_p_vt1
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=320n wp=400n
XI34 VDDA VSS VBP VBN LLSB net78 mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=6 m_p=6 nf_n=1 nf_p=1 wn=427n
+ wp=267n
MPA VDDA ARYSD_INT VDDAI_R VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=4
.ends

.subckt mm16a05_u_pg_wlstkrw_plus VDDA VDDWL VSS VBP VBN LCGTHB LCGTH
MI11 VDDWL VDDWL VDDA VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=300n m=1
MI10 VDDA LCGTH VDDWL VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=225n
+ m=16
M0 VDDA LCGTH VDDWL VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=525n m=16
M1 VDDA VDDWL VDDWL VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=300n m=1
XI15 VDDA VSS VBP VBN LCGTHB LCGTH mm16a05_u_inv_bulk_n_vt1_p_vt1 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=2 nf_p=2 wn=240.0n
+ wp=240.0n
.ends

.subckt mm16a05_u_hdsp_plus_rwbuf_left VDDA VDDP VDDPI VDDWL VSS VBP VBN
+ ARYSDB_BC1 ARYSDB_BC2 ARYSD_TOP LLSB RWL_RD RWL_WR ARYSD_OUT LOG0 LOG1 PO
+ RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] RWLD_RD RWLD_WR TOPEDGE VBA
+ ARYSD_BC1 ARYSD_BC2 ARYSD_IN LCGTH RWLB_RD RWLB_WR SDOR_RETI
XDUMMY VSS VBA mm16a05_u_ram6t_corner_hs1prf
XI25 VDDA VSS VBP VBN ARYSDB_BC1 ARYSDB_BC2 ARYSD_OUT LLSB ARYSD_TOP ARYSD_BC1
+ ARYSD_BC2 ARYSD_IN LCGTH SDOR_RETI mm16a05_u_hdsp_plus_pg_aryslpbuf
XWLSTACK VDDA VDDWL VSS VBP VBN net112 LCGTH mm16a05_u_pg_wlstkrw_plus
.ends

.subckt mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt3_p2_vt3 VDD VSS VBP VBN X A1 A2
+ CPP=104n P_LA_n1=4n P_LA_n2=4n P_LA_p1=4n P_LA_p2=4n ULP=0 ln1=20n ln2=20n
+ lp1=20n lp2=20n m_n1=1 m_n2=1 m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1
+ wn1=600n wn2=600n wp1=450n wp2=450n
MPA2 X A2 VDD VBP slvtpfet cpp=cpp p_la=p_la_p2 ulp=ulp nf=nf_p2 l=lp2 w=wp2
+ m=m_p2
MPA1 X A1 VDD VBP slvtpfet cpp=cpp p_la=p_la_p1 ulp=ulp nf=nf_p1 l=lp1 w=wp1
+ m=m_p1
MNA1 X A1 net22 VBN slvtnfet cpp=cpp p_la=p_la_n1 ulp=ulp nf=nf_n1 l=ln1 w=wn1
+ m=m_n1
MNA2 net22 A2 VSS VBN slvtnfet cpp=cpp p_la=p_la_n2 ulp=ulp nf=nf_n2 l=ln2
+ w=wn2 m=m_n2
.ends

.subckt mm16a05_u_complex_nor_wk_rwl VDDPI VNWP VSS VBP VBN OUT BK LMATCH
+ LMATCHB T1T
M97 VDDPI T1T net189 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=480n m=1
M94 OUT LMATCHB net189 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=480n
+ m=1
M95 net187 BK OUT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=480n m=1
M96 net189 LMATCH net187 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=480n
+ m=1
M75 VSS T1T OUT VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
M36 VSS LMATCHB net193 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
M37 OUT LMATCH net193 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
M38 OUT BK net193 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
.ends

.subckt mm16a05_u_hdsp_plus_rwlgen_gf22 VDDA VDDP VDDPI VSS VBP VBN RWLB_RD
+ RWLB_WR RWL_DLY_0 RWL_DLY_2 RWL_DLY_4 BKSEL_RW FLOAT FLOAT_RET FLOAT_RET_PROG
+ LMATCH LMATCHB LWEIB_HV RWLB_SAC RWL_DLY_RD_PGM RWL_DLY_WR_PGM T1T
XI103 VDDP VSS VBP VBN net298 LWEI_BKSEL_T1T RWL_DLY_WR_PGM
+ mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=240n
+ wp2=240n
XI86 VDDP VSS VBP VBN RWLB_RD RWL_DLY_RD_PGM LWEIB_BKSEL_T1T
+ mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=2 m_n2=2
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=640n wn2=640n wp1=320n
+ wp2=320n
XI98 VDDPI VSS VBP VBN RWL_DLY_0 FLOAT FLOAT_RET_PROG
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=2 m_p2=2 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=180n
+ wp2=180n
XI115 VDDPI VSS VBP VBN BKSEL_RW_T1TB BKSEL_RW_T1T
+ mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=240n wp=240n
XI118 VDDP VSS VBP VBN RWLB_WR net309 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1 wn=320n
+ wp=640n
XI173 VDDPI VSS VBP VBN RWL_DLY_2 net349 mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI176 VDDPI VSS VBP VBN net351 RWL_DLY_2 mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI175 VDDPI VSS VBP VBN RWL_DLY_4 net351 mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI172 VDDPI VSS VBP VBN net349 RWL_DLY_0 mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI117 VDDP VSS VBP VBN net309 net298 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=640n
XI163 VDDPI VDDP VSS VBP VBN BKSEL_RW_T1T BKSEL_RW LMATCH LMATCHB T1T
+ mm16a05_u_complex_nor_wk_rwl
XI116 VDDPI VSS VBP VBN LWEIB_BKSEL_T1T LWEI_BKSEL_T1T BKSEL_RW_T1TB
+ mm16a05_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=320n
+ wp2=320n
XI113 VDDPI VSS VBP VBN LWEI_BKSEL_T1T LWEIB_HV BKSEL_RW_T1TB
+ mm16a05_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=320n
+ wp2=320n
.ends

.subckt mm16a05_u_wrtimer_logic_hdsp_plus VSS VBP VBN DBL LOG1 RMT[0] RMT[1]
+ RMT[2] RWL_AND_RWLD
MI18 net51 RWL_AND_RWLD net64 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=1
MI19 net101 RWL_AND_RWLD VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=1
M0 W0 RWL_AND_RWLD net48 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
M1 DBL RWL_AND_RWLD W0 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
M2 DBL RWL_AND_RWLD W3 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
M3 W3 RWL_AND_RWLD net51 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
M4 W4 RMT[1] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
M5 DBL RWL_AND_RWLD W4 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
M6 DBL RWL_AND_RWLD W5 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=200n
+ m=2
M7 W5 RMT[2] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=180n m=2
MI16 net48 RWL_AND_RWLD net101 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=1
MI20 net64 RMT[0] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
.ends

.subckt mm16a05_u_rdtimer_logic_hdsp_plus VSS VBP VBN DBL LOG1 RMT[0] RMT[1]
+ RMT[2] RWL_AND_RWLD
MI31 net112 RWL_AND_RWLD VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n
+ w=120n m=1
MI20 net60 RMT[0] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n w=120n m=1
M0 W0 RWL_AND_RWLD net47 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
M1 DBL RWL_AND_RWLD W0 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
M2 DBL RWL_AND_RWLD W3 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n w=120n
+ m=1
M3 W3 RWL_AND_RWLD net60 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n w=120n
+ m=1
M4 W4 RMT[1] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n w=120n m=1
M5 DBL RWL_AND_RWLD W4 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n w=120n
+ m=1
M6 DBL RWL_AND_RWLD W5 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n w=240n
+ m=2
M7 W5 RMT[2] VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n w=240n m=2
MI18 net115 RWL_AND_RWLD net56 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n
+ w=120n m=1
MI19 net56 RWL_AND_RWLD net112 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n
+ w=120n m=1
MI17 net47 RWL_AND_RWLD net115 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=120n m=1
.ends

.subckt mm16a05_u_rwl_and_rwld_hdsp_plus VDDA VSS VBP VBN RWL_AND_RWLD RWLB
+ RWLD
XI93 VBP VBN RWLD RWL_AND_RWLD RWLT RWLB mm16a05_u_tg_bulk_n_vt4_p_vt4 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=4 m_p=3 nf_n=1 nf_p=1 wn=300n
+ wp=400n
XI6 VDDA VSS VBP VBN RWLT RWLB mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
M3 RWL_AND_RWLD RWLB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=240n
+ m=2
.ends

.subckt mm16a05_u_write_delay_slow VDDP VDDPI VSS VBP VBN OUT IN RWLB WMT2
MI30 net114 INBB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n m=1
MI23 VDDPI INBB net113 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=120n
+ m=1
XI36 VDDPI VSS VBP VBN DLY4B net213 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI34 VDDPI VSS VBP VBN WMSLOW WMT2 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI31 VDDPI VSS VBP VBN INBB INB mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI29 VDDPI VSS VBP VBN net217 net218 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI27 VDDPI VSS VBP VBN DLY4A net217 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI26 VDDPI VSS VBP VBN net213 net214 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI25 VDDPI VSS VBP VBN WMSLOWB WMSLOW mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI24 VDDPI VSS VBP VBN net218 net219 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI21 VDDPI VSS VBP VBN net214 DLY_ND1 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI18 VDDPI VSS VBP VBN INB IN mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n
+ p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
XI17 net113 net114 VBP VBN net219 INBB mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI37 VDDPI VSS VBP VBN DLY_ND2 INBB DLY4B
+ mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI39 VDDPI VSS VBP VBN DLY_ND1 INBB DLY4A
+ mm16a05_u_nd2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=120n wn2=120n wp1=120n
+ wp2=120n
XI33 VBP VBN INB DEF_BYPASS WMSLOWB WMSLOW mm16a05_u_tg_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=2 m_p=2 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI32 VBP VBN DLY_ND2 DEF_BYPASS WMSLOW WMSLOWB mm16a05_u_tg_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI22 VDDPI VSS VBP VBN OUT RWLB DEF_BYPASS
+ mm16a05_u_nr2_bulk_n1_vt3_n2_vt3_p1_vt3_p2_vt3 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=3 m_n2=3
+ m_p1=3 m_p2=3 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=374n
+ wp2=374n
.ends

.subckt mm16a05_u_hdsp_plus_rwtimer_gf22 VDDMINB VDDA VDDP VDDPI VSS VBP VBN
+ RWL_RWLD_AND RWL_RWLD_AND_WR LOG0 LOG1 RBL RWLB_RD RWLB_WR RWLD_RD RWLD_WR
+ WBL RMT[0] RMT[1] RMT[2] WMT[0] WMT[1] WMT[2] WMT[3]
XI175 VSS VBP VBN WBL LOG1 WMT[0] WMT[1] WMT[2] RWL_RWLD_AND_WR
+ mm16a05_u_wrtimer_logic_hdsp_plus
XI141 VSS VBP VBN RBL LOG1 RMT[0] RMT[1] RMT[2] RWL_RWLD_AND
+ mm16a05_u_rdtimer_logic_hdsp_plus
XI132 VDDA VSS VBP VBN RWLD_IN RWLB_RD RWLD_RD mm16a05_u_rwl_and_rwld_hdsp_plus
XI182 VDDPI net603 VBP VBN RWLD_OUT_SLOW net602 mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=24n lp=24n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI181 net597 VSS VBP VBN net602 net599 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=24n lp=24n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI183 net583 VSS VBP VBN net592 net585 mm16a05_u_inv_bulk_n_vt3_p_vt3 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=24n lp=24n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n
+ wp=120n
XI176 net567 VSS VBP VBN net572 RWLD_OUT mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=24n lp=24n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI184 VDDPI VSS VBP VBN RWLD_OUT RWLD_IN mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=240n wp=120n
XI169 VDDPI net573 VBP VBN net585 net572 mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=24n lp=24n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI180 VDDPI net589 VBP VBN net599 net592 mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=24n lp=24n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI178 VDDPI VSS VBP VBN SEL_SLOWB SEL_SLOW mm16a05_u_inv_bulk_n_vt2_p_vt2
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=120n
XI185 VDDPI VSS VBP VBN RWL_RWLD_AND MUX_OUT mm16a05_u_inv_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=120n wp=240n
XI163 VDDP VDDPI VSS VBP VBN RWL_RWLD_AND_WR RWLD_WR RWLB_WR WMT[3]
+ mm16a05_u_write_delay_slow
MI190 net597 net599 VDDPI VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=24n w=120n
+ m=1
MI186 net567 RWLD_OUT VDDPI VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=24n
+ w=120n m=1
MI174 VDDPI RWL_RWLD_AND_WR WBL VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=400n m=3
MI140 VDDPI RWL_RWLD_AND RBL VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=400n m=3
MI188 net583 net585 VDDPI VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=24n w=120n
+ m=1
MI191 net603 net602 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n w=120n
+ m=1
MI189 net589 net592 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n w=120n
+ m=1
MI187 net573 net572 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=24n w=120n
+ m=1
XI33 VBP VBN RWLD_OUT_SLOW MUX_OUT SEL_SLOW SEL_SLOWB
+ mm16a05_u_tg_bulk_n_vt3_p_vt3 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
XI32 VBP VBN RWLD_OUT MUX_OUT SEL_SLOWB SEL_SLOW mm16a05_u_tg_bulk_n_vt3_p_vt3
+ cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1
+ wn=480n wp=480n
XI22 VDDPI VSS VBP VBN SEL_SLOW RMT[2] RMT[1]
+ mm16a05_u_nr2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=160n wn2=160n wp1=240n
+ wp2=240n
.ends

.subckt mm16a05_u_logrepw VDDP VSS VBP VBN LOG0 LOG1
M0 LOG0 LOG1 VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=300n m=2
MPLOG VDDP LOG0 LOG1 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=300n m=2
.ends

.subckt mm16a05_u_complex_nor_wk_rwl_wa VDDP VDDPI VSS VBP VBN OUT BK LMATCH
+ LMATCHB
M94 OUT LMATCHB VDDPI VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
M95 net187 BK OUT VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
M96 VDDPI LMATCH net187 VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
M36 VSS LMATCHB net193 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n
+ m=1
M37 OUT LMATCH net193 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
M38 OUT BK net193 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=320n m=1
.ends

.subckt mm16a05_u_hdsp_plus_rw_gf22 VDDMINB VDDA VDDP VDDPI VSS VSSC_WL_L
+ VSSC_WL_R VBP VBN RWLB_RD RWLB_WR RWL_DLY_0 RWL_DLY_2 RWL_DLY_4 RWL_RWLD_AND
+ RWL_RWLD_AND_WR CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT_RET FLOAT_RET_PROG
+ LBKADR[0] LBKADR[1] LBKADR[2] LCGTHB LDFTX LITESLP LLBKADRB[1] LLBKADRB[2]
+ LMATCHB LMATCHB_I LOG0 LOG1 LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+ LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PLBKADR[1] PLBKADR[2] RBLRD
+ RBLWA RBLWR RM3CNT RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WPBUF[0]
+ WPBUF[1] WPBUF[2] FLOAT FLOATT LWEIB RMT[0] RMT[1] RMT[2] RMT[3] RWLD_RD
+ RWLD_WR RWLHVBRD RWLHVBWR RWL_DLY_RD_PGM RWL_DLY_WR_PGM WMT[0] WMT[1] WMT[2]
+ WMT[3]
XI101 VDDA VDDP VDDPI VSS VBP VBN RWLB_RD RWLB_WR RWL_DLY_0 RWL_DLY_2 RWL_DLY_4
+ BKSEL_RW FLOAT FLOAT_RET FLOAT_RET_PROG LMATCH LMATCHB_I LWEIB RWLB_SAC
+ RWL_DLY_RD_PGM RWL_DLY_WR_PGM T1T mm16a05_u_hdsp_plus_rwlgen_gf22
XI102 VDDMINB VDDA VDDP VDDPI VSS VBP VBN RWL_RWLD_AND RWL_RWLD_AND_WR LOG0
+ LOG1 RBLRD RWLHVBRD RWLHVBWR RWLD_RD RWLD_WR RBLWR RMT[0] RMT[1] RMT[2]
+ WMT[0] WMT[1] WMT[2] WMT[3] mm16a05_u_hdsp_plus_rwtimer_gf22
XI11 VDDP VSS VBP VBN LOG0 LOG1 mm16a05_u_logrepw
Xinv_lbk[1] VDDPI VSS VBP VBN LLBKADRB[1] LBKADR[1]
+ mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
Xinv_lbk[2] VDDPI VSS VBP VBN LLBKADRB[2] LBKADR[2]
+ mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n p_la_n=4n p_la_p=4n ulp=0 ln=20n
+ lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=120n wp=120n
XI38 VDDPI VSS VBP VBN LMATCH LMATCHB mm16a05_u_inv_bulk_n_vt2_p_vt2 cpp=104n
+ p_la_n=4n p_la_p=4n ulp=0 ln=20n lp=20n m_n=1 m_p=1 nf_n=1 nf_p=1 wn=320n
+ wp=320n
XI163 VDDP VDDPI VSS VBP VBN BKSEL_RW_WA BKSEL_RW LMATCH LMATCHB_I
+ mm16a05_u_complex_nor_wk_rwl_wa
MI188 VSSC_WL_L LCGTHB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=320n m=3
MI187 VSSC_WL_R LCGTHB VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=320n m=3
MI174 FLOATB_RBLWA FLOAT net634 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=200n m=1
MN1_RBLWA RBLWA FLOATB_RBLWA net612 VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=240n m=4
MN2_RBLWA net612 BKSEL_RW_WA VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=240n m=4
M92 net634 FLOAT VSS VBN slvtnfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=200n m=1
MI173 VDDPI FLOAT FLOATB_RBLWA VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n
+ w=180.0n m=2
MP1_RBLWA VDDPI FLOATB_RBLWA RBLWA VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=120n m=4
MP2_RBLWA VDDPI BKSEL_RW_WA RBLWA VBP slvtpfet cpp=104n p_la=4n ulp=0 nf=1
+ l=20n w=120n m=4
Xnd2_sa VDDPI VSS VBP VBN BKSEL_RW PLBKADR[1] PLBKADR[2]
+ mm16a05_u_nd2_bulk_n1_vt2_n2_vt2_p1_vt2_p2_vt2 cpp=104n p_la_n1=4n p_la_n2=4n
+ p_la_p1=4n p_la_p2=4n ulp=0 ln1=20n ln2=20n lp1=20n lp2=20n m_n1=1 m_n2=1
+ m_p1=1 m_p2=1 nf_n1=1 nf_n2=1 nf_p1=1 nf_p2=1 wn1=240n wn2=240n wp1=120n
+ wp2=120n
.ends

.subckt mm16a05_u_xbuf1_hd_rw_rd_plus VDDWL VDD_BK VSS VBP VBN WL WLB
MI6 VDDWL WLB WL VBP lvtpfet cpp=104n p_la=4n ulp=0 nf=1 l=20n w=1136n m=5
M17 WL WLB VSS VBN lvtnfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=608n m=5
.ends

.subckt mm16a05_u_xbuf1_hd_rw_plus VDDWL VDD_BK VSS VBP VBN WL WLB
MI6 VDDWL WLB WL VBP lvtpfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=1136n m=5
M17 WL WLB VSS VBN lvtnfet cpp=104n p_la=0 ulp=0 nf=1 l=20n w=608n m=5
.ends

.subckt mm16a05_u_hdsp_plus_rwbuf VDDA VDDP VDDPI VDDWL VSS VBP VBN ARYSDB_BC1
+ ARYSDB_BC2 ARYSD_TOP LLSB RWL_RD RWL_WR ARYSD_OUT LCGTHB LOG0 LOG1 PO
+ RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] RWLD_RD RWLD_WR TOPEDGE VBA
+ ARYSD_BC1 ARYSD_BC2 ARYSD_IN LCGTH RWLB_RD RWLB_WR SDOR_RETI
XDUMMY VSS VBA mm16a05_u_ram6t_corner_hs1prf
XWLSTACK VDDA VDDWL VSS VBP VBN LCGTHB LCGTH mm16a05_u_pg_wlstkrw_plus
XI38 VDDA VDDA VSS VBP VBN RWL_RD RWLB_RD mm16a05_u_xbuf1_hd_rw_rd_plus
XI25 VDDA VSS VBP VBN ARYSDB_BC1 ARYSDB_BC2 ARYSD_OUT LLSB ARYSD_TOP ARYSD_BC1
+ ARYSD_BC2 ARYSD_IN LCGTH SDOR_RETI mm16a05_u_hdsp_plus_pg_aryslpbuf
XI34 VDDA VDDA VSS VBP VBN RWL_WR RWLB_WR mm16a05_u_xbuf1_hd_rw_plus
.ends

.SUBCKT SNPS_SP_HD_512x8_gio_lt_seg1 CB[0] CB[1] CB[2] CB[3] CT[0] CT[1] CT[2]
+       CT[3] D[0] D[1] D[2] D[3] DCLKT DIB[0] DIB[1] DIB[2] DIB[3] DINB[0]
+       DINB[1] DINB[2] DINB[3] DLYPDB D_AL[0] D_AL[1] D_AL[2] D_AL[3] GSE_DB
+       GSE_DT IV_SEL[0] IV_SEL[1] IV_SEL[2] IV_SEL[3] IV_SEL[4] IV_SEL[5]
+       IV_SEL[6] IV_SEL[7] IV_WB[0] IV_WB[1] IV_WB[2] IV_WB[3] IV_WB[4]
+       IV_WB[5] IV_WB[6] IV_WB[7] IV_WT[0] IV_WT[1] IV_WT[2] IV_WT[3] IV_WT[4]
+       IV_WT[5] IV_WT[6] IV_WT[7] LDFTYBUF LDIB[0] LDIB[1] LDIB[2] LDIB[3] LOG0
+       LOG1 LQB[0] LQB[1] LQB[2] LQB[3] LWIB[0] LWIB[1] LWIB[2] LWIB[3] LYB[0]
+       LYB[1] ND_SEL[0] ND_SEL[1] ND_SEL[2] ND_SEL[3] ND_SEL[4] ND_SEL[5]
+       ND_SEL[6] ND_SEL[7] ND_WB[0] ND_WB[1] ND_WB[2] ND_WB[3] ND_WB[4]
+       ND_WB[5] ND_WB[6] ND_WB[7] ND_WT[0] ND_WT[1] ND_WT[2] ND_WT[3] ND_WT[4]
+       ND_WT[5] ND_WT[6] ND_WT[7] Q[0] Q[1] Q[2] Q[3] QB[0] QB[1] QB[2] QB[3]
+       QB[4] QB[5] QB[6] QB[7] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+       SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] VBN[0] VBN[1]
+       VBN[2] VBN[3] VBP[0] VBP[1] VBP[2] VBP[3] VDDP[0] VDDP[1] VDDP[2]
+       VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDPI[0] VDDPI[1] VDDPI[2]
+       VDDPI[3] VDDPI_DR[0] VDDPI_DR[1] VDDPI_DR[2] VDDPI_DR[3] VSS[0] VSS[1]
+       VSS[2] VSS[3] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5]
+       WB_IN[6] WB_IN[7] WEM[0] WEM[1] WEM[2] WEM[3] WEMB[0] WEMB[1] WEMB[2]
+       WEMB[3] WEM_AL[0] WEM_AL[1] WEM_AL[2] WEM_AL[3] WT_IN[0] WT_IN[1]
+       WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7]

*** Jumper Report ***
* Jumper: DINB[0] D_AL[0]
* Jumper: DINB[1] D_AL[1]
* Jumper: DINB[2] D_AL[2]
* Jumper: DINB[3] D_AL[3]
* Jumper: IV_SEL[0] ND_SEL[0]
* Jumper: IV_SEL[1] ND_SEL[1]
* Jumper: IV_SEL[2] ND_SEL[2]
* Jumper: IV_SEL[3] ND_SEL[3]
* Jumper: IV_SEL[4] ND_SEL[4]
* Jumper: IV_SEL[5] ND_SEL[5]
* Jumper: IV_SEL[6] ND_SEL[6]
* Jumper: IV_SEL[7] ND_SEL[7]
* Jumper: IV_WB[0] ND_WB[0]
* Jumper: IV_WB[1] ND_WB[1]
* Jumper: IV_WB[2] ND_WB[2]
* Jumper: IV_WB[3] ND_WB[3]
* Jumper: IV_WB[4] ND_WB[4]
* Jumper: IV_WB[5] ND_WB[5]
* Jumper: IV_WB[6] ND_WB[6]
* Jumper: IV_WB[7] ND_WB[7]
* Jumper: IV_WT[0] ND_WT[0]
* Jumper: IV_WT[1] ND_WT[1]
* Jumper: IV_WT[2] ND_WT[2]
* Jumper: IV_WT[3] ND_WT[3]
* Jumper: IV_WT[4] ND_WT[4]
* Jumper: IV_WT[5] ND_WT[5]
* Jumper: IV_WT[6] ND_WT[6]
* Jumper: IV_WT[7] ND_WT[7]
* Jumper: VDDP[0] VDDPI[0]
* Jumper: VDDP[2] VDDPI[1]
* Jumper: VDDP[4] VDDPI[2]
* Jumper: VDDP[6] VDDPI[3]
* Jumper: WEMB[0] WEM_AL[0]
* Jumper: WEMB[1] WEM_AL[1]
* Jumper: WEMB[2] WEM_AL[2]
* Jumper: WEMB[3] WEM_AL[3]

X_mm16a05_u_hdsp_plus_giom8x1_S0 VDDP[0] VDDPI[0] VDDPI_DR[0] VDDP[1] VSS[0]
+   VBP[0] VBN[0] CB[0] CT[0] D_AL[0] LDIB[0] LQB[0] LWIB[0] ND_SEL[0] ND_SEL[1]
+   ND_WB[0] ND_WB[1] ND_WT[0] ND_WT[1] Q[0] SEL[0] SEL[1] WB_IN[0] WB_IN[1]
+   WEM_AL[0] WT_IN[0] WT_IN[1] DIB[0] LOG0 LOG1 LYB[0] LYB[1] QB[0] QB[1] QT[0]
+   QT[1] D[0] DCLKT DINB[0] DLYPDB IV_SEL[0] IV_SEL[1] IV_WB[0] IV_WB[1]
+   IV_WT[0] IV_WT[1] LDFTYBUF GSE_DB GSE_DT WEM[0] WEMB[0]
+   mm16a05_u_hdsp_plus_giom8x1
X_mm16a05_u_hdsp_plus_giom8x1_S1 VDDP[2] VDDPI[1] VDDPI_DR[1] VDDP[3] VSS[1]
+   VBP[1] VBN[1] CB[1] CT[1] D_AL[1] LDIB[1] LQB[1] LWIB[1] ND_SEL[2] ND_SEL[3]
+   ND_WB[2] ND_WB[3] ND_WT[2] ND_WT[3] Q[1] SEL[2] SEL[3] WB_IN[2] WB_IN[3]
+   WEM_AL[1] WT_IN[2] WT_IN[3] DIB[1] LOG0 LOG1 LYB[0] LYB[1] QB[2] QB[3] QT[2]
+   QT[3] D[1] DCLKT DINB[1] DLYPDB IV_SEL[2] IV_SEL[3] IV_WB[2] IV_WB[3]
+   IV_WT[2] IV_WT[3] LDFTYBUF GSE_DB GSE_DT WEM[1] WEMB[1]
+   mm16a05_u_hdsp_plus_giom8x1
X_mm16a05_u_hdsp_plus_giom8x1_F1 VDDP[4] VDDPI[2] VDDPI_DR[2] VDDP[5] VSS[2]
+   VBP[2] VBN[2] CB[2] CT[2] D_AL[2] LDIB[2] LQB[2] LWIB[2] ND_SEL[4] ND_SEL[5]
+   ND_WB[4] ND_WB[5] ND_WT[4] ND_WT[5] Q[2] SEL[4] SEL[5] WB_IN[4] WB_IN[5]
+   WEM_AL[2] WT_IN[4] WT_IN[5] DIB[2] LOG0 LOG1 LYB[0] LYB[1] QB[4] QB[5] QT[4]
+   QT[5] D[2] DCLKT DINB[2] DLYPDB IV_SEL[4] IV_SEL[5] IV_WB[4] IV_WB[5]
+   IV_WT[4] IV_WT[5] LDFTYBUF GSE_DB GSE_DT WEM[2] WEMB[2]
+   mm16a05_u_hdsp_plus_giom8x1
X_mm16a05_u_hdsp_plus_giom8x1_F0 VDDP[6] VDDPI[3] VDDPI_DR[3] VDDP[7] VSS[3]
+   VBP[3] VBN[3] CB[3] CT[3] D_AL[3] LDIB[3] LQB[3] LWIB[3] ND_SEL[6] ND_SEL[7]
+   ND_WB[6] ND_WB[7] ND_WT[6] ND_WT[7] Q[3] SEL[6] SEL[7] WB_IN[6] WB_IN[7]
+   WEM_AL[3] WT_IN[6] WT_IN[7] DIB[3] LOG0 LOG1 LYB[0] LYB[1] QB[6] QB[7] QT[6]
+   QT[7] D[3] DCLKT DINB[3] DLYPDB IV_SEL[6] IV_SEL[7] IV_WB[6] IV_WB[7]
+   IV_WT[6] IV_WT[7] LDFTYBUF GSE_DB GSE_DT WEM[3] WEMB[3]
+   mm16a05_u_hdsp_plus_giom8x1
.ENDS
.SUBCKT SNPS_SP_HD_512x8_gio_lt CB[0] CB[1] CB[2] CB[3] CT[0] CT[1] CT[2] CT[3]
+       D[0] D[1] D[2] D[3] DCLKT DIB[0] DIB[1] DIB[2] DIB[3] DINB[0] DINB[1]
+       DINB[2] DINB[3] DLYPDBL D_AL[0] D_AL[1] D_AL[2] D_AL[3] GSE_DB GSE_DT
+       IV_SEL[0] IV_SEL[1] IV_SEL[2] IV_SEL[3] IV_SEL[4] IV_SEL[5] IV_SEL[6]
+       IV_SEL[7] IV_WB[0] IV_WB[1] IV_WB[2] IV_WB[3] IV_WB[4] IV_WB[5] IV_WB[6]
+       IV_WB[7] IV_WT[0] IV_WT[1] IV_WT[2] IV_WT[3] IV_WT[4] IV_WT[5] IV_WT[6]
+       IV_WT[7] LDFTYBUF LDIB[0] LDIB[1] LDIB[2] LDIB[3] LOG0 LOG1 LQB[0]
+       LQB[1] LQB[2] LQB[3] LWIB[0] LWIB[1] LWIB[2] LWIB[3] LYB[0] LYB[1]
+       ND_SEL[0] ND_SEL[1] ND_SEL[2] ND_SEL[3] ND_SEL[4] ND_SEL[5] ND_SEL[6]
+       ND_SEL[7] ND_WB[0] ND_WB[1] ND_WB[2] ND_WB[3] ND_WB[4] ND_WB[5] ND_WB[6]
+       ND_WB[7] ND_WT[0] ND_WT[1] ND_WT[2] ND_WT[3] ND_WT[4] ND_WT[5] ND_WT[6]
+       ND_WT[7] PWDO Q[0] Q[1] Q[2] Q[3] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5]
+       QB[6] QB[7] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0]
+       SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] VBN[0] VBN[1] VBN[2]
+       VBN[3] VBN[4] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VDDP[0] VDDP[1] VDDP[2]
+       VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0] VDDPI[1]
+       VDDPI[2] VDDPI[3] VDDPI[4] VDDPI_DR[0] VDDPI_DR[1] VDDPI_DR[2]
+       VDDPI_DR[3] VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] WB_IN[0] WB_IN[1]
+       WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WEM[0] WEM[1]
+       WEM[2] WEM[3] WEMB[0] WEMB[1] WEMB[2] WEMB[3] WEM_AL[0] WEM_AL[1]
+       WEM_AL[2] WEM_AL[3] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4]
+       WT_IN[5] WT_IN[6] WT_IN[7]
X_mm16a05_u_hdsp_plus_capgio VDDP[0] VDDPI[0] VSS[0] VBP[0] VBN[0] LOG0 LOG1
+   PWDO VEDGE mm16a05_u_hdsp_plus_capgio
X_gio_lt_seg1 CB[0] CB[1] CB[2] CB[3] CT[0] CT[1] CT[2] CT[3] D[0] D[1] D[2]
+   D[3] DCLKT DIB[0] DIB[1] DIB[2] DIB[3] DINB[0] DINB[1] DINB[2] DINB[3]
+   DLYPDBL D_AL[0] D_AL[1] D_AL[2] D_AL[3] GSE_DB GSE_DT IV_SEL[0] IV_SEL[1]
+   IV_SEL[2] IV_SEL[3] IV_SEL[4] IV_SEL[5] IV_SEL[6] IV_SEL[7] IV_WB[0]
+   IV_WB[1] IV_WB[2] IV_WB[3] IV_WB[4] IV_WB[5] IV_WB[6] IV_WB[7] IV_WT[0]
+   IV_WT[1] IV_WT[2] IV_WT[3] IV_WT[4] IV_WT[5] IV_WT[6] IV_WT[7] LDFTYBUF
+   LDIB[0] LDIB[1] LDIB[2] LDIB[3] LOG0 LOG1 LQB[0] LQB[1] LQB[2] LQB[3]
+   LWIB[0] LWIB[1] LWIB[2] LWIB[3] LYB[0] LYB[1] ND_SEL[0] ND_SEL[1] ND_SEL[2]
+   ND_SEL[3] ND_SEL[4] ND_SEL[5] ND_SEL[6] ND_SEL[7] ND_WB[0] ND_WB[1] ND_WB[2]
+   ND_WB[3] ND_WB[4] ND_WB[5] ND_WB[6] ND_WB[7] ND_WT[0] ND_WT[1] ND_WT[2]
+   ND_WT[3] ND_WT[4] ND_WT[5] ND_WT[6] ND_WT[7] Q[0] Q[1] Q[2] Q[3] QB[0] QB[1]
+   QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5]
+   QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] VBN[1]
+   VBN[2] VBN[3] VBN[4] VBP[1] VBP[2] VBP[3] VBP[4] VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+   VDDPI_DR[0] VDDPI_DR[1] VDDPI_DR[2] VDDPI_DR[3] VSS[1] VSS[2] VSS[3] VSS[4]
+   WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7]
+   WEM[0] WEM[1] WEM[2] WEM[3] WEMB[0] WEMB[1] WEMB[2] WEMB[3] WEM_AL[0]
+   WEM_AL[1] WEM_AL[2] WEM_AL[3] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4]
+   WT_IN[5] WT_IN[6] WT_IN[7] SNPS_SP_HD_512x8_gio_lt_seg1
.ENDS
.SUBCKT SNPS_SP_HD_512x8_gio_cnt ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1]
+       ARYSD_BC2[0] ARYSD_BC2[1] BC0 BC1 BC2 CENDP CLK CLKB CLKDEL CLKFLT
+       CLK_MUXB DCLKT[0] DCLKT[1] DEF1 DEF12B_PROG DEF12_PROG DEF1B DEF2 DEF2B
+       DEF_MODE DEF_PROG DFTCLKEN DISCHG DLYPDBL DLYPDBR DLYPW FAST1_MODE
+       FAST2_MODE FISO FLOAT FLOATT FLOAT_RET GSE_DB[0] GSE_DB[1] GSE_DT[0]
+       GSE_DT[1] LBKADR0 LBKADR1 LBKADR2 LCLKB LCLKT LDFTX LDFTYBUF[0]
+       LDFTYBUF[1] LITESLP LME LOG0 LOG1 LOG1_RM LS LWE LWEIB LXADR[0] LXADR[1]
+       LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+       LYBH[0] LYBH[1] LYBL[0] LYBL[1] LY_ONE LY_TWO MCLKB MCLKT ME MEB_I
+       MEB_LT MEORDFTCLKEN MEORDFTCLKEN_IN RA[0] RA[1] RASSIST[0] RASSIST[1]
+       RASSIST[2] RASSIST[3] RM[0] RM[1] RM[2] RM[3] RM3CNT RMDEF1[0] RMDEF1[1]
+       RMDEF1[2] RMDEF1[3] RMDEF2[0] RMDEF2[1] RMDEF2[2] RMDEF2[3] RME RMENI[0]
+       RMENI[1] RMENI[2] RMSLOW[0] RMSLOW[1] RMSLOW[2] RMSLOW[3] RMT[0] RMT[1]
+       RMT[2] RMT[3] RSCEN RSCIN RSCLK RSCOUT RSCRST RWLCKB SD SE_IN T1T TEST1
+       TEST_RNM TEST_RNMB VBN[0] VBN[1] VBN[2] VBP[0] VBP[1] VBP[2] VDDA[0]
+       VDDA[1] VDDA[2] VDDF VDDMINB VDDP[0] VDDP[1] VDDP[2] VDDPI[0] VDDPI[1]
+       VDDPI[2] VSS[0] VSS[1] VSS[2] WA[0] WA[1] WABUF[0] WABUF[1] WABUF[2] WE
+       WFLOAT WMDEF1[0] WMDEF1[1] WMDEF1[2] WMDEF1[3] WMDEF2[0] WMDEF2[1]
+       WMDEF2[2] WMDEF2[3] WMSLOW[0] WMSLOW[1] WMSLOW[2] WMSLOW[3] WMT[0]
+       WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WPULSE[0] WPULSE[1]
+       WPULSE[2] XADR[0] XADR[1] XADR[2] XADR[3] XADR[4] XADR[5] XADR[6]
+       XADR[7] XBKADR[0] XBKADR[1] XBKADR[2] YADR[0] YADR[1] YADR[2] YADR[3]

*** Jumper Report ***
* Jumper: CLKB CLK_MUXB
* Jumper: CLKDEL CLKFLT
* Jumper: DEF1 DEF_PROG
* Jumper: DEF12B_PROG DEF2B
* Jumper: DEF12_PROG DEF2
* Jumper: LOG0 CENDP DFTCLKEN DLYPW FISO GSE_DT[0] GSE_DT[1] LDFTX LDFTYBUF[0] LDFTYBUF[1] RA[0] RA[1] RMENI[2] RSCEN RSCIN RSCLK RSCRST SD SE_IN XADR[6] XADR[7] XBKADR[0] XBKADR[1] XBKADR[2] YADR[3] CLPSEBUF LY[1] LY[3]
* Jumper: LOG1 DLYPDBL DLYPDBR GSE_DB[0] GSE_DB[1] MEORDFTCLKEN_IN RMENI[0] RMENI[1] SDCLPSB
* Jumper: LOG1_RM RMDEF1[3] RMDEF2[0] RMDEF2[2] RMDEF2[3] RMSLOW[0] RMSLOW[1] RMSLOW[2] RMSLOW[3] WMDEF1[0] WMDEF1[1] WMDEF1[2] WMDEF2[2] WMDEF2[3] WMSLOW[0] WMSLOW[2] WMSLOW[3]
* Jumper: LY_ONE LY[0] LY[2]
* Jumper: MEB_I MEB_LT
* Jumper: RMDEF1[0] RMDEF1[1] RMDEF1[2] RMDEF2[1] VSS[1] WMDEF1[3] WMDEF2[0] WMDEF2[1] WMSLOW[1]
* Jumper: VDDA[0] VDDP[0] VDDPI[0]
* Jumper: VDDA[1] VDDP[1] VDDPI[1]
* Jumper: VDDA[2] VDDP[2] VDDPI[2]

X_mm16a05_u_hdsp_plus_gcenbuf_left VDDA[0] VDDP[0] VDDPI[0] VSS[0] VBP[0] VBN[0]
+   DCLKT[0] LYBL[0] LYBL[1] RASSIST[0] RASSIST[1] ARYSD[0] LSDB LSDB_BC1
+   LSDB_BC2 ARYSD_BC1[0] ARYSD_BC2[0] DLYPDBL GSE_DB[0] GSE_DT[0] LDFTYBUF[0]
+   LOG0 LOG1 LCLKBIO LY_ONE LOG0 LY_ONE LY_TWO RAB[0] RAB[1] LOG1
+   mm16a05_u_hdsp_plus_gcenbuf_dr
X_mm16a05_u_hdsp_plus_gcen VDDA[1] VDDF VDDP[1] VDDPI[1] VDDMINB VSS[1] VBP[1]
+   VBN[1] ARYSDB ARYSDB_BC1 ARYSDB_BC2 CLKDEL DEF1 DEF1B DEF2 DEF2B DEF_MODE
+   FAST1_MODE FAST2_MODE LBKADR0 LBKADR1 LBKADR2 LCLKB LCLKBIO LCLKT LITESLP
+   LME LSDB LSDB_BC1 LSDB_BC2 LWE LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3]
+   LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] LY_ONE LY_TWO MCLKB
+   MCLKT MEB_LT RAB[0] RAB[1] RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLCKB T1T
+   TEST_RNMB WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0]
+   WPBUF[1] WPBUF[2] CLKB LOG0 FISO FLOAT FLOATT LOG0 LOG1 LOG1_RM MEORDFTCLKEN
+   MEORDFTCLKEN_IN RM3CLPSB RSCEN RSCIN RSCLK RSCOUT RSCRST LOG1 WFLOAT BC0 BC1
+   BC2 XBKADR[0] XBKADR[1] XBKADR[2] CENDP CLK CLKFLT CLK_MUXB DEF12B_PROG
+   DEF12_PROG DEF_PROG DFTCLKEN DISCHG DLYPW FLOAT_RET LDFTX LS ME MEB_I RA[0]
+   RA[1] RM[0] RM[1] RM[2] RM[3] RMDEF1[0] RMDEF1[1] RMDEF1[2] RMDEF1[3]
+   RMDEF2[0] RMDEF2[1] RMDEF2[2] RMDEF2[3] RME RMENI[0] RMENI[1] RMENI[2]
+   RMSLOW[0] RMSLOW[1] RMSLOW[2] RMSLOW[3] SD SE_IN TEST1 TEST_RNM WA[0] WA[1]
+   WE WMDEF1[0] WMDEF1[1] WMDEF1[2] WMDEF1[3] WMDEF2[0] WMDEF2[1] WMDEF2[2]
+   WMDEF2[3] WMSLOW[0] WMSLOW[1] WMSLOW[2] WMSLOW[3] WPULSE[0] WPULSE[1]
+   WPULSE[2] XADR[0] XADR[1] XADR[2] XADR[3] XADR[4] XADR[5] XADR[6] XADR[7]
+   YADR[0] YADR[1] YADR[2] YADR[3] mm16a05_u_hdsp_plus_gcen
X_mm16a05_u_hdsp_plus_gcenbuf VDDA[2] VDDP[2] VDDPI[2] VSS[2] VBP[2] VBN[2]
+   DCLKT[1] LYBH[0] LYBH[1] RASSIST[2] RASSIST[3] ARYSD[1] LSDB LSDB_BC1
+   LSDB_BC2 ARYSD_BC1[1] ARYSD_BC2[1] DLYPDBR GSE_DB[1] GSE_DT[1] LDFTYBUF[1]
+   LOG0 LOG1 LCLKBIO LY_ONE LOG0 LY_ONE LY_TWO RAB[0] RAB[1] LOG1
+   mm16a05_u_hdsp_plus_gcenbuf
.ENDS
.SUBCKT SNPS_SP_HD_512x8_gio_rt CB[0] CB[1] CB[2] CB[3] CT[0] CT[1] CT[2] CT[3]
+       D[0] D[1] D[2] D[3] DCLKT DIB[0] DIB[1] DIB[2] DIB[3] DINB[0] DINB[1]
+       DINB[2] DINB[3] DLYPDBR D_AL[0] D_AL[1] D_AL[2] D_AL[3] GSE_DB GSE_DT
+       IV_SEL[0] IV_SEL[1] IV_SEL[2] IV_SEL[3] IV_SEL[4] IV_SEL[5] IV_SEL[6]
+       IV_SEL[7] IV_WB[0] IV_WB[1] IV_WB[2] IV_WB[3] IV_WB[4] IV_WB[5] IV_WB[6]
+       IV_WB[7] IV_WT[0] IV_WT[1] IV_WT[2] IV_WT[3] IV_WT[4] IV_WT[5] IV_WT[6]
+       IV_WT[7] LDFTYBUF LDIB[0] LDIB[1] LDIB[2] LDIB[3] LOG0 LOG1 LQB[0]
+       LQB[1] LQB[2] LQB[3] LWIB[0] LWIB[1] LWIB[2] LWIB[3] LYB[0] LYB[1]
+       ND_SEL[0] ND_SEL[1] ND_SEL[2] ND_SEL[3] ND_SEL[4] ND_SEL[5] ND_SEL[6]
+       ND_SEL[7] ND_WB[0] ND_WB[1] ND_WB[2] ND_WB[3] ND_WB[4] ND_WB[5] ND_WB[6]
+       ND_WB[7] ND_WT[0] ND_WT[1] ND_WT[2] ND_WT[3] ND_WT[4] ND_WT[5] ND_WT[6]
+       ND_WT[7] PWDO Q[0] Q[1] Q[2] Q[3] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5]
+       QB[6] QB[7] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0]
+       SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] VBN[0] VBN[1] VBN[2]
+       VBN[3] VBN[4] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VDDP[0] VDDP[1] VDDP[2]
+       VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0] VDDPI[1]
+       VDDPI[2] VDDPI[3] VDDPI[4] VDDPI_DR[0] VDDPI_DR[1] VDDPI_DR[2]
+       VDDPI_DR[3] VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] WB_IN[0] WB_IN[1]
+       WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WEM[0] WEM[1]
+       WEM[2] WEM[3] WEMB[0] WEMB[1] WEMB[2] WEMB[3] WEM_AL[0] WEM_AL[1]
+       WEM_AL[2] WEM_AL[3] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4]
+       WT_IN[5] WT_IN[6] WT_IN[7]
X_gio_lt_seg1 CB[0] CB[1] CB[2] CB[3] CT[0] CT[1] CT[2] CT[3] D[0] D[1] D[2]
+   D[3] DCLKT DIB[0] DIB[1] DIB[2] DIB[3] DINB[0] DINB[1] DINB[2] DINB[3]
+   DLYPDBR D_AL[0] D_AL[1] D_AL[2] D_AL[3] GSE_DB GSE_DT IV_SEL[0] IV_SEL[1]
+   IV_SEL[2] IV_SEL[3] IV_SEL[4] IV_SEL[5] IV_SEL[6] IV_SEL[7] IV_WB[0]
+   IV_WB[1] IV_WB[2] IV_WB[3] IV_WB[4] IV_WB[5] IV_WB[6] IV_WB[7] IV_WT[0]
+   IV_WT[1] IV_WT[2] IV_WT[3] IV_WT[4] IV_WT[5] IV_WT[6] IV_WT[7] LDFTYBUF
+   LDIB[0] LDIB[1] LDIB[2] LDIB[3] LOG0 LOG1 LQB[0] LQB[1] LQB[2] LQB[3]
+   LWIB[0] LWIB[1] LWIB[2] LWIB[3] LYB[0] LYB[1] ND_SEL[0] ND_SEL[1] ND_SEL[2]
+   ND_SEL[3] ND_SEL[4] ND_SEL[5] ND_SEL[6] ND_SEL[7] ND_WB[0] ND_WB[1] ND_WB[2]
+   ND_WB[3] ND_WB[4] ND_WB[5] ND_WB[6] ND_WB[7] ND_WT[0] ND_WT[1] ND_WT[2]
+   ND_WT[3] ND_WT[4] ND_WT[5] ND_WT[6] ND_WT[7] Q[0] Q[1] Q[2] Q[3] QB[0] QB[1]
+   QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5]
+   QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] VBN[0]
+   VBN[1] VBN[2] VBN[3] VBP[0] VBP[1] VBP[2] VBP[3] VDDP[0] VDDP[1] VDDP[2]
+   VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI_DR[0] VDDPI_DR[1] VDDPI_DR[2] VDDPI_DR[3] VSS[0] VSS[1] VSS[2] VSS[3]
+   WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7]
+   WEM[0] WEM[1] WEM[2] WEM[3] WEMB[0] WEMB[1] WEMB[2] WEMB[3] WEM_AL[0]
+   WEM_AL[1] WEM_AL[2] WEM_AL[3] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4]
+   WT_IN[5] WT_IN[6] WT_IN[7] SNPS_SP_HD_512x8_gio_lt_seg1
X_mm16a05_u_hdsp_plus_capgio VDDP[8] VDDPI[4] VSS[4] VBP[4] VBN[4] LOG0 LOG1
+   PWDO VEDGE mm16a05_u_hdsp_plus_capgio
.ENDS
.SUBCKT SNPS_SP_HD_512x8_gio_row ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1]
+       ARYSD_BC2[0] ARYSD_BC2[1] BC0 BC1 BC2 CB[0] CB[1] CB[2] CB[3] CB[4]
+       CB[5] CB[6] CB[7] CENDP CLK CLKB CLKDEL CLKFLT CLK_MUXB CT[0] CT[1]
+       CT[2] CT[3] CT[4] CT[5] CT[6] CT[7] D[0] D[1] D[2] D[3] D[4] D[5] D[6]
+       D[7] DEF1 DEF12B_PROG DEF12_PROG DEF1B DEF2 DEF2B DEF_MODE DEF_PROG
+       DFTCLKEN DIB[0] DIB[1] DIB[2] DIB[3] DIB[4] DIB[5] DIB[6] DIB[7] DINB[0]
+       DINB[1] DINB[2] DINB[3] DINB[4] DINB[5] DINB[6] DINB[7] DISCHG DLYPDBL
+       DLYPDBR DLYPW D_AL[0] D_AL[1] D_AL[2] D_AL[3] D_AL[4] D_AL[5] D_AL[6]
+       D_AL[7] FAST1_MODE FAST2_MODE FISO FLOAT FLOATT FLOAT_RET GSE_DB[0]
+       GSE_DB[1] GSE_DT[0] GSE_DT[1] IV_SEL[0] IV_SEL[1] IV_SEL[2] IV_SEL[3]
+       IV_SEL[4] IV_SEL[5] IV_SEL[6] IV_SEL[7] IV_SEL[8] IV_SEL[9] IV_SEL[10]
+       IV_SEL[11] IV_SEL[12] IV_SEL[13] IV_SEL[14] IV_SEL[15] IV_WB[0] IV_WB[1]
+       IV_WB[2] IV_WB[3] IV_WB[4] IV_WB[5] IV_WB[6] IV_WB[7] IV_WB[8] IV_WB[9]
+       IV_WB[10] IV_WB[11] IV_WB[12] IV_WB[13] IV_WB[14] IV_WB[15] IV_WT[0]
+       IV_WT[1] IV_WT[2] IV_WT[3] IV_WT[4] IV_WT[5] IV_WT[6] IV_WT[7] IV_WT[8]
+       IV_WT[9] IV_WT[10] IV_WT[11] IV_WT[12] IV_WT[13] IV_WT[14] IV_WT[15]
+       LBKADR0 LBKADR1 LBKADR2 LCLKB LCLKT LDFTX LDFTYBUF[0] LDFTYBUF[1]
+       LDIB[0] LDIB[1] LDIB[2] LDIB[3] LDIB[4] LDIB[5] LDIB[6] LDIB[7] LITESLP
+       LME LOG0 LOG1 LOG1_RM LQB[0] LQB[1] LQB[2] LQB[3] LQB[4] LQB[5] LQB[6]
+       LQB[7] LS LWE LWEIB LWIB[0] LWIB[1] LWIB[2] LWIB[3] LWIB[4] LWIB[5]
+       LWIB[6] LWIB[7] LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+       LXADR[6] LXADR[7] LYADR[0] LYADR[1] LY_ONE LY_TWO MCLKB MCLKT ME MEB_I
+       MEB_LT MEORDFTCLKEN MEORDFTCLKEN_IN ND_SEL[0] ND_SEL[1] ND_SEL[2]
+       ND_SEL[3] ND_SEL[4] ND_SEL[5] ND_SEL[6] ND_SEL[7] ND_SEL[8] ND_SEL[9]
+       ND_SEL[10] ND_SEL[11] ND_SEL[12] ND_SEL[13] ND_SEL[14] ND_SEL[15]
+       ND_WB[0] ND_WB[1] ND_WB[2] ND_WB[3] ND_WB[4] ND_WB[5] ND_WB[6] ND_WB[7]
+       ND_WB[8] ND_WB[9] ND_WB[10] ND_WB[11] ND_WB[12] ND_WB[13] ND_WB[14]
+       ND_WB[15] ND_WT[0] ND_WT[1] ND_WT[2] ND_WT[3] ND_WT[4] ND_WT[5] ND_WT[6]
+       ND_WT[7] ND_WT[8] ND_WT[9] ND_WT[10] ND_WT[11] ND_WT[12] ND_WT[13]
+       ND_WT[14] ND_WT[15] PWDO[0] PWDO[1] Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6]
+       Q[7] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+       QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5]
+       QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] RA[0]
+       RA[1] RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RM[0] RM[1] RM[2]
+       RM[3] RM3CNT RMDEF1[0] RMDEF1[1] RMDEF1[2] RMDEF1[3] RMDEF2[0] RMDEF2[1]
+       RMDEF2[2] RMDEF2[3] RME RMENI[0] RMENI[1] RMENI[2] RMSLOW[0] RMSLOW[1]
+       RMSLOW[2] RMSLOW[3] RMT[0] RMT[1] RMT[2] RMT[3] RSCEN RSCIN RSCLK RSCOUT
+       RSCRST RWLCKB SD SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7]
+       SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] SE_IN T1T
+       TEST1 TEST_RNM TEST_RNMB VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5]
+       VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBP[0] VBP[1] VBP[2]
+       VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+       VDDA[0] VDDA[1] VDDA[2] VDDMINB VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+       VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+       VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20]
+       VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+       VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI_DR[0] VDDPI_DR[1]
+       VDDPI_DR[2] VDDPI_DR[3] VDDPI_DR[4] VDDPI_DR[5] VDDPI_DR[6] VDDPI_DR[7]
+       VEDGE[0] VEDGE[1] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6]
+       VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] WA[0] WA[1] WABUF[0]
+       WABUF[1] WABUF[2] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5]
+       WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12]
+       WB_IN[13] WB_IN[14] WB_IN[15] WE WEM[0] WEM[1] WEM[2] WEM[3] WEM[4]
+       WEM[5] WEM[6] WEM[7] WEMB[0] WEMB[1] WEMB[2] WEMB[3] WEMB[4] WEMB[5]
+       WEMB[6] WEMB[7] WEM_AL[0] WEM_AL[1] WEM_AL[2] WEM_AL[3] WEM_AL[4]
+       WEM_AL[5] WEM_AL[6] WEM_AL[7] WFLOAT WMDEF1[0] WMDEF1[1] WMDEF1[2]
+       WMDEF1[3] WMDEF2[0] WMDEF2[1] WMDEF2[2] WMDEF2[3] WMSLOW[0] WMSLOW[1]
+       WMSLOW[2] WMSLOW[3] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+       WPBUF[2] WPULSE[0] WPULSE[1] WPULSE[2] WT_IN[0] WT_IN[1] WT_IN[2]
+       WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10]
+       WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15] XADR[0] XADR[1]
+       XADR[2] XADR[3] XADR[4] XADR[5] XADR[6] XADR[7] XBKADR[0] XBKADR[1]
+       XBKADR[2] YADR[0] YADR[1] YADR[2] YADR[3]
X_gio_lt CB[0] CB[1] CB[2] CB[3] CT[0] CT[1] CT[2] CT[3] D[0] D[1] D[2] D[3]
+   DCLKT[0] DIB[0] DIB[1] DIB[2] DIB[3] DINB[0] DINB[1] DINB[2] DINB[3] DLYPDBL
+   D_AL[0] D_AL[1] D_AL[2] D_AL[3] GSE_DB[0] GSE_DT[0] IV_SEL[0] IV_SEL[1]
+   IV_SEL[2] IV_SEL[3] IV_SEL[4] IV_SEL[5] IV_SEL[6] IV_SEL[7] IV_WB[0]
+   IV_WB[1] IV_WB[2] IV_WB[3] IV_WB[4] IV_WB[5] IV_WB[6] IV_WB[7] IV_WT[0]
+   IV_WT[1] IV_WT[2] IV_WT[3] IV_WT[4] IV_WT[5] IV_WT[6] IV_WT[7] LDFTYBUF[0]
+   LDIB[0] LDIB[1] LDIB[2] LDIB[3] LOG0 LOG1 LQB[0] LQB[1] LQB[2] LQB[3]
+   LWIB[0] LWIB[1] LWIB[2] LWIB[3] LYBL[0] LYBL[1] ND_SEL[0] ND_SEL[1]
+   ND_SEL[2] ND_SEL[3] ND_SEL[4] ND_SEL[5] ND_SEL[6] ND_SEL[7] ND_WB[0]
+   ND_WB[1] ND_WB[2] ND_WB[3] ND_WB[4] ND_WB[5] ND_WB[6] ND_WB[7] ND_WT[0]
+   ND_WT[1] ND_WT[2] ND_WT[3] ND_WT[4] ND_WT[5] ND_WT[6] ND_WT[7] PWDO[0] Q[0]
+   Q[1] Q[2] Q[3] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBP[0] VBP[1] VBP[2]
+   VBP[3] VBP[4] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6]
+   VDDP[7] VDDP[8] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI_DR[0]
+   VDDPI_DR[1] VDDPI_DR[2] VDDPI_DR[3] VEDGE[0] VSS[0] VSS[1] VSS[2] VSS[3]
+   VSS[4] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6]
+   WB_IN[7] WEM[0] WEM[1] WEM[2] WEM[3] WEMB[0] WEMB[1] WEMB[2] WEMB[3]
+   WEM_AL[0] WEM_AL[1] WEM_AL[2] WEM_AL[3] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3]
+   WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] SNPS_SP_HD_512x8_gio_lt
X_gio_cnt ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1]
+   BC0 BC1 BC2 CENDP CLK CLKB CLKDEL CLKFLT CLK_MUXB DCLKT[0] DCLKT[1] DEF1
+   DEF12B_PROG DEF12_PROG DEF1B DEF2 DEF2B DEF_MODE DEF_PROG DFTCLKEN DISCHG
+   DLYPDBL DLYPDBR DLYPW FAST1_MODE FAST2_MODE FISO FLOAT FLOATT FLOAT_RET
+   GSE_DB[0] GSE_DB[1] GSE_DT[0] GSE_DT[1] LBKADR0 LBKADR1 LBKADR2 LCLKB LCLKT
+   LDFTX LDFTYBUF[0] LDFTYBUF[1] LITESLP LME LOG0 LOG1 LOG1_RM LS LWE LWEIB
+   LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+   LYADR[0] LYADR[1] LYBH[0] LYBH[1] LYBL[0] LYBL[1] LY_ONE LY_TWO MCLKB MCLKT
+   ME MEB_I MEB_LT MEORDFTCLKEN MEORDFTCLKEN_IN RA[0] RA[1] RASSIST[0]
+   RASSIST[1] RASSIST[2] RASSIST[3] RM[0] RM[1] RM[2] RM[3] RM3CNT RMDEF1[0]
+   RMDEF1[1] RMDEF1[2] RMDEF1[3] RMDEF2[0] RMDEF2[1] RMDEF2[2] RMDEF2[3] RME
+   RMENI[0] RMENI[1] RMENI[2] RMSLOW[0] RMSLOW[1] RMSLOW[2] RMSLOW[3] RMT[0]
+   RMT[1] RMT[2] RMT[3] RSCEN RSCIN RSCLK RSCOUT RSCRST RWLCKB SD SE_IN T1T
+   TEST1 TEST_RNM TEST_RNMB VBN[5] VBN[6] VBN[7] VBP[5] VBP[6] VBP[7] VDDA[0]
+   VDDA[1] VDDA[2] VDDF VDDMINB VDDP[9] VDDP[10] VDDP[11] VDDPI[5] VDDPI[6]
+   VDDPI[7] VSS[5] VSS[6] VSS[7] WA[0] WA[1] WABUF[0] WABUF[1] WABUF[2] WE
+   WFLOAT WMDEF1[0] WMDEF1[1] WMDEF1[2] WMDEF1[3] WMDEF2[0] WMDEF2[1] WMDEF2[2]
+   WMDEF2[3] WMSLOW[0] WMSLOW[1] WMSLOW[2] WMSLOW[3] WMT[0] WMT[1] WMT[2]
+   WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WPULSE[0] WPULSE[1] WPULSE[2] XADR[0]
+   XADR[1] XADR[2] XADR[3] XADR[4] XADR[5] XADR[6] XADR[7] XBKADR[0] XBKADR[1]
+   XBKADR[2] YADR[0] YADR[1] YADR[2] YADR[3] SNPS_SP_HD_512x8_gio_cnt
X_gio_rt CB[4] CB[5] CB[6] CB[7] CT[4] CT[5] CT[6] CT[7] D[4] D[5] D[6] D[7]
+   DCLKT[1] DIB[4] DIB[5] DIB[6] DIB[7] DINB[4] DINB[5] DINB[6] DINB[7] DLYPDBR
+   D_AL[4] D_AL[5] D_AL[6] D_AL[7] GSE_DB[1] GSE_DT[1] IV_SEL[8] IV_SEL[9]
+   IV_SEL[10] IV_SEL[11] IV_SEL[12] IV_SEL[13] IV_SEL[14] IV_SEL[15] IV_WB[8]
+   IV_WB[9] IV_WB[10] IV_WB[11] IV_WB[12] IV_WB[13] IV_WB[14] IV_WB[15]
+   IV_WT[8] IV_WT[9] IV_WT[10] IV_WT[11] IV_WT[12] IV_WT[13] IV_WT[14]
+   IV_WT[15] LDFTYBUF[1] LDIB[4] LDIB[5] LDIB[6] LDIB[7] LOG0 LOG1 LQB[4]
+   LQB[5] LQB[6] LQB[7] LWIB[4] LWIB[5] LWIB[6] LWIB[7] LYBH[0] LYBH[1]
+   ND_SEL[8] ND_SEL[9] ND_SEL[10] ND_SEL[11] ND_SEL[12] ND_SEL[13] ND_SEL[14]
+   ND_SEL[15] ND_WB[8] ND_WB[9] ND_WB[10] ND_WB[11] ND_WB[12] ND_WB[13]
+   ND_WB[14] ND_WB[15] ND_WT[8] ND_WT[9] ND_WT[10] ND_WT[11] ND_WT[12]
+   ND_WT[13] ND_WT[14] ND_WT[15] PWDO[1] Q[4] Q[5] Q[6] Q[7] QB[8] QB[9] QB[10]
+   QB[11] QB[12] QB[13] QB[14] QB[15] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13]
+   QT[14] QT[15] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15]
+   VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12]
+   VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19]
+   VDDP[20] VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI_DR[4]
+   VDDPI_DR[5] VDDPI_DR[6] VDDPI_DR[7] VEDGE[1] VSS[8] VSS[9] VSS[10] VSS[11]
+   VSS[12] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14]
+   WB_IN[15] WEM[4] WEM[5] WEM[6] WEM[7] WEMB[4] WEMB[5] WEMB[6] WEMB[7]
+   WEM_AL[4] WEM_AL[5] WEM_AL[6] WEM_AL[7] WT_IN[8] WT_IN[9] WT_IN[10]
+   WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15] SNPS_SP_HD_512x8_gio_rt
.ENDS
.SUBCKT SNPS_SP_HD_512x8_sampwa QB[0] QB[1] QT[0] QT[1] RB[0] RB[1] RT[0] RT[1]
+       SEL[0] SEL[1] VBN[0] VBN[1] VBP[0] VBP[1] VDDP[0] VDDP[1] VDDPI[0]
+       VDDPI[1] VSS[0] VSS[1] VSS_WA[0] VSS_WA[1] WA[0] WA[1] WAPRCLKBUF
+       WAPRCLKBUFB_RET WB[0] WB[1] WB_IN[0] WB_IN[1] WT[0] WT[1] WT_IN[0]
+       WT_IN[1]

*** Jumper Report ***
* Jumper: VDDP[0] VDDPI[0]
* Jumper: VDDP[1] VDDPI[1]

X_mm16a05_u_hdsp_plus_hs_sacm4x1_wa_64_S0 VDDP[0] VDDPI[0] VSS[0] VSS_WA[0]
+   VBP[0] VBN[0] QB[0] QT[0] RB[0] RT[0] SEL[0] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RET WB[0] WB_IN[0] WT[0] WT_IN[0]
+   mm16a05_u_hdsp_plus_hs_sacm4x1_wa_64
X_mm16a05_u_hdsp_plus_hs_sacm4x1_wa_64_F0 VDDP[1] VDDPI[1] VSS[1] VSS_WA[1]
+   VBP[1] VBN[1] QB[1] QT[1] RB[1] RT[1] SEL[1] WA[0] WA[1] WAPRCLKBUF
+   WAPRCLKBUFB_RET WB[1] WB_IN[1] WT[1] WT_IN[1]
+   mm16a05_u_hdsp_plus_hs_sacm4x1_wa_64
.ENDS
.SUBCKT SNPS_SP_HD_512x8_sacwa_lt_seg1 QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6]
+       QB[7] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] RB[0] RB[1] RB[2]
+       RB[3] RB[4] RB[5] RB[6] RB[7] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6]
+       RT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] VBN[0]
+       VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBP[0] VBP[1] VBP[2]
+       VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+       VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+       VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4]
+       VSS[5] VSS[6] VSS[7] VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4]
+       VSS_WA[5] VSS_WA[6] VSS_WA[7] WA[0] WA[1] WAPRCLKBUF WAPRCLKBUFB_RET
+       WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB_IN[0] WB_IN[1]
+       WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WT[0] WT[1] WT[2]
+       WT[3] WT[4] WT[5] WT[6] WT[7] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3]
+       WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7]
X_sampwa_S0 QB[0] QB[1] QT[0] QT[1] RB[0] RB[1] RT[0] RT[1] SEL[0] SEL[1] VBN[0]
+   VBN[1] VBP[0] VBP[1] VDDP[0] VDDP[1] VDDPI[0] VDDPI[1] VSS[0] VSS[1]
+   VSS_WA[0] VSS_WA[1] WA[0] WA[1] WAPRCLKBUF WAPRCLKBUFB_RET WB[0] WB[1]
+   WB_IN[0] WB_IN[1] WT[0] WT[1] WT_IN[0] WT_IN[1] SNPS_SP_HD_512x8_sampwa
X_sampwa_S1 QB[2] QB[3] QT[2] QT[3] RB[2] RB[3] RT[2] RT[3] SEL[2] SEL[3] VBN[2]
+   VBN[3] VBP[2] VBP[3] VDDP[2] VDDP[3] VDDPI[2] VDDPI[3] VSS[2] VSS[3]
+   VSS_WA[2] VSS_WA[3] WA[0] WA[1] WAPRCLKBUF WAPRCLKBUFB_RET WB[2] WB[3]
+   WB_IN[2] WB_IN[3] WT[2] WT[3] WT_IN[2] WT_IN[3] SNPS_SP_HD_512x8_sampwa
X_sampwa_F1 QB[4] QB[5] QT[4] QT[5] RB[4] RB[5] RT[4] RT[5] SEL[4] SEL[5] VBN[4]
+   VBN[5] VBP[4] VBP[5] VDDP[4] VDDP[5] VDDPI[4] VDDPI[5] VSS[4] VSS[5]
+   VSS_WA[4] VSS_WA[5] WA[0] WA[1] WAPRCLKBUF WAPRCLKBUFB_RET WB[4] WB[5]
+   WB_IN[4] WB_IN[5] WT[4] WT[5] WT_IN[4] WT_IN[5] SNPS_SP_HD_512x8_sampwa
X_sampwa_F0 QB[6] QB[7] QT[6] QT[7] RB[6] RB[7] RT[6] RT[7] SEL[6] SEL[7] VBN[6]
+   VBN[7] VBP[6] VBP[7] VDDP[6] VDDP[7] VDDPI[6] VDDPI[7] VSS[6] VSS[7]
+   VSS_WA[6] VSS_WA[7] WA[0] WA[1] WAPRCLKBUF WAPRCLKBUFB_RET WB[6] WB[7]
+   WB_IN[6] WB_IN[7] WT[6] WT[7] WT_IN[6] WT_IN[7] SNPS_SP_HD_512x8_sampwa
.ENDS
.SUBCKT SNPS_SP_HD_512x8_sacwa_lt LOG0 LOG1 PWDO QB[0] QB[1] QB[2] QB[3] QB[4]
+       QB[5] QB[6] QB[7] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] RB[0]
+       RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RT[0] RT[1] RT[2] RT[3] RT[4]
+       RT[5] RT[6] RT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+       SEL[7] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+       VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDP[0]
+       VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+       VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+       VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6]
+       VSS_WA[7] WAL[0] WAL[1] WAPRCLKBUF WAPRCLKBUFB_RETL WB[0] WB[1] WB[2]
+       WB[3] WB[4] WB[5] WB[6] WB[7] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3]
+       WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5]
+       WT[6] WT[7] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5]
+       WT_IN[6] WT_IN[7]
X_mm16a05_u_hdsp_plus_capsac_wa_left VDDP[0] VDDPI[0] VSS[0] VBP[0] VBN[0] LOG0
+   LOG1 PWDO VEDGE WAPRCLKBUF WAPRCLKBUFB_RET mm16a05_u_hdsp_plus_capsac_wa
X_sacwa_lt_seg1 QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5]
+   RB[6] RB[7] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5]
+   VBN[6] VBN[7] VBN[8] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[1]
+   VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS_WA[0] VSS_WA[1] VSS_WA[2]
+   VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7] WAL[0] WAL[1] WAPRCLKBUF
+   WAPRCLKBUFB_RETL WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB_IN[0]
+   WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WT[0] WT[1]
+   WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3]
+   WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] SNPS_SP_HD_512x8_sacwa_lt_seg1
.ENDS
.SUBCKT SNPS_SP_HD_512x8_sacwa_cnt ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1]
+       ARYSD_BC2[0] ARYSD_BC2[1] CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT
+       FLOATT FLOAT_RET LBKADR0 LBKADR1 LBKADR2 LCGTH[0] LCGTH[1] LCGTH_PCHG
+       LDFTX LITESLP LMATCHB LOG0 LOG1 LWEIB LWERD LWEWR LXADR[0] LXADR[1]
+       LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+       PM[0] PM[1] PM[2] PM[3] PRCKE_B RASSIST[0] RASSIST[1] RASSIST[2]
+       RASSIST[3] RBLWA RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] T1T TEST_RNMB VBN[0]
+       VBN[1] VBN[2] VBP[0] VBP[1] VBP[2] VDDA[0] VDDA[1] VDDA[2] VDDMINB
+       VDDP[0] VDDP[1] VDDP[2] VDDPI[0] VDDPI[1] VDDPI[2] VSS[0] VSS[1] VSS[2]
+       WABUF[0] WABUF[1] WABUF[2] WAL[0] WAL[1] WAPRCLKBUF[0] WAPRCLKBUF[1]
+       WAPRCLKBUFB_RET WAPRCLKBUFB_RETL WAR[0] WAR[1] WMT[0] WMT[1] WMT[2]
+       WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]

*** Jumper Report ***
* Jumper: PRCKDLY TAP0
* Jumper: VDDP[1] VDDPI[1]
* Jumper: VDDP[2] VDDPI[2]

X_mm16a05_u_hdsp_plus_sacbuf_wa_left VDDA[0] VDDP[0] VDDPI[0] VSS[0] VBP[0]
+   VBN[0] WAL[0] WAL[1] WAPRCLKBUF[0] ARYSD[0] ARYSD_BC1[0] ARYSD_BC2[0]
+   LCGTH[0] RASSIST[0] RASSIST[1] WAPRCLKBUFB_RETL WABUF[0] WABUF[1] WAPRCLK
+   mm16a05_u_hdsp_plus_sacbuf_wa
X_mm16a05_u_hdsp_plus_sactrlwa_64 VDDA[1] VDDMINB VDDP[1] VDDPI[1] VSS[1] VBP[1]
+   VBN[1] PRCKDLY TAP1 TAP2 TAP3 WAPRCLK DEF_MODE FAST1_MODE FAST2_MODE FLOAT
+   FLOAT_RET LBKADR0 LBKADR1 LBKADR2 LCGTH_PCHG LMATCHB LOG0 LOG1 LWERD LWEWR
+   PM[0] PM[1] PM[2] PM[3] PRCKE_B RBLWA RM3CNT TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WAPRCLKBUFB_RET WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] CENDP FLOATT LDFTX LITESLP LWEIB LXADR[0] LXADR[1] LXADR[2]
+   LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PRCKDLY
+   RMT[0] RMT[1] RMT[2] RMT[3] T1T mm16a05_u_hdsp_plus_sactrl_wa
X_mm16a05_u_hdsp_plus_sacbuf_wa VDDA[2] VDDP[2] VDDPI[2] VSS[2] VBP[2] VBN[2]
+   WAR[0] WAR[1] WAPRCLKBUF[1] ARYSD[1] ARYSD_BC1[1] ARYSD_BC2[1] LCGTH[1]
+   RASSIST[2] RASSIST[3] WAPRCLKBUFB_RET WABUF[0] WABUF[1] WAPRCLK
+   mm16a05_u_hdsp_plus_sacbuf_wa
.ENDS
.SUBCKT SNPS_SP_HD_512x8_sacwa_rt LOG0 LOG1 PWDO QB[0] QB[1] QB[2] QB[3] QB[4]
+       QB[5] QB[6] QB[7] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] RB[0]
+       RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RT[0] RT[1] RT[2] RT[3] RT[4]
+       RT[5] RT[6] RT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+       SEL[7] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+       VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDP[0]
+       VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+       VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+       VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6]
+       VSS_WA[7] WAPRCLKBUF WAPRCLKBUFB_RET WAR[0] WAR[1] WB[0] WB[1] WB[2]
+       WB[3] WB[4] WB[5] WB[6] WB[7] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3]
+       WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5]
+       WT[6] WT[7] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5]
+       WT_IN[6] WT_IN[7]
X_sacwa_lt_seg1 QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5]
+   RB[6] RB[7] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4]
+   VBN[5] VBN[6] VBN[7] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7]
+   VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VSS[0] VSS[1]
+   VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS_WA[0] VSS_WA[1] VSS_WA[2]
+   VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7] WAR[0] WAR[1] WAPRCLKBUF
+   WAPRCLKBUFB_RET WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB_IN[0]
+   WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WT[0] WT[1]
+   WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3]
+   WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] SNPS_SP_HD_512x8_sacwa_lt_seg1
X_mm16a05_u_hdsp_plus_capsac_wa_64 VDDP[8] VDDPI[8] VSS[8] VBP[8] VBN[8] LOG0
+   LOG1 PWDO VEDGE WAPRCLKBUF WAPRCLKBUFB_RET mm16a05_u_hdsp_plus_capsac_wa
.ENDS
.SUBCKT SNPS_SP_HD_512x8_sacwa_row ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1]
+       ARYSD_BC2[0] ARYSD_BC2[1] CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT
+       FLOATT FLOAT_RET LBKADR0 LBKADR1 LBKADR2 LCGTH[0] LCGTH[1] LCGTH_PCHG
+       LDFTX LITESLP LMATCHB LOG0[0] LOG0[1] LOG0[2] LOG1[0] LOG1[1] LOG1[2]
+       LWEIB LWERD LWEWR LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+       LXADR[6] LXADR[7] LYADR[0] LYADR[1] PM[0] PM[1] PM[2] PM[3] PRCKE_B
+       PWDO[0] PWDO[1] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8]
+       QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3]
+       QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14]
+       QT[15] RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RB[0] RB[1] RB[2]
+       RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13]
+       RB[14] RB[15] RBLWA RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RT[0] RT[1] RT[2]
+       RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13]
+       RT[14] RT[15] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7]
+       SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] T1T
+       TEST_RNMB VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+       VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17]
+       VBN[18] VBN[19] VBN[20] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+       VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15]
+       VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VDDA[0] VDDA[1] VDDA[2] VDDMINB
+       VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8]
+       VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16]
+       VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+       VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+       VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17]
+       VDDPI[18] VDDPI[19] VDDPI[20] VEDGE[0] VEDGE[1] VSS[0] VSS[1] VSS[2]
+       VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12]
+       VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] VSS[20]
+       VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6]
+       VSS_WA[7] VSS_WA[8] VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12]
+       VSS_WA[13] VSS_WA[14] VSS_WA[15] WABUF[0] WABUF[1] WABUF[2]
+       WAPRCLKBUFB_RET WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8]
+       WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WB_IN[0] WB_IN[1]
+       WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9]
+       WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WMT[0]
+       WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT[0] WT[1] WT[2] WT[3]
+       WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14]
+       WT[15] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6]
+       WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13]
+       WT_IN[14] WT_IN[15]
X_sacwa_lt LOG0[0] LOG1[0] PWDO[0] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6]
+   QB[7] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] RB[0] RB[1] RB[2]
+   RB[3] RB[4] RB[5] RB[6] RB[7] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6]
+   RT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] VBN[0] VBN[1]
+   VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+   VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+   VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VEDGE[0] VSS[0] VSS[1] VSS[2] VSS[3]
+   VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3]
+   VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7] WAL[0] WAL[1] WAPRCLKBUF[0]
+   WAPRCLKBUFB_RETL WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB_IN[0]
+   WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WT[0] WT[1]
+   WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3]
+   WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] SNPS_SP_HD_512x8_sacwa_lt
X_sacwa_cnt ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+   ARYSD_BC2[1] CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET
+   LBKADR0 LBKADR1 LBKADR2 LCGTH[0] LCGTH[1] LCGTH_PCHG LDFTX LITESLP LMATCHB
+   LOG0[1] LOG1[1] LWEIB LWERD LWEWR LXADR[0] LXADR[1] LXADR[2] LXADR[3]
+   LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PM[0] PM[1] PM[2]
+   PM[3] PRCKE_B RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RBLWA RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] T1T TEST_RNMB VBN[9] VBN[10] VBN[11] VBP[9]
+   VBP[10] VBP[11] VDDA[0] VDDA[1] VDDA[2] VDDMINB VDDP[9] VDDP[10] VDDP[11]
+   VDDPI[9] VDDPI[10] VDDPI[11] VSS[9] VSS[10] VSS[11] WABUF[0] WABUF[1]
+   WABUF[2] WAL[0] WAL[1] WAPRCLKBUF[0] WAPRCLKBUF[1] WAPRCLKBUFB_RET
+   WAPRCLKBUFB_RETL WAR[0] WAR[1] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+   WPBUF[2] SNPS_SP_HD_512x8_sacwa_cnt
X_sacwa_rt LOG0[2] LOG1[2] PWDO[1] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13]
+   QB[14] QB[15] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] RB[8]
+   RB[9] RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RT[8] RT[9] RT[10] RT[11]
+   RT[12] RT[13] RT[14] RT[15] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13]
+   SEL[14] SEL[15] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18]
+   VBN[19] VBN[20] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18]
+   VBP[19] VBP[20] VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17]
+   VDDP[18] VDDP[19] VDDP[20] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16]
+   VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VEDGE[1] VSS[12] VSS[13] VSS[14]
+   VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS_WA[8] VSS_WA[9]
+   VSS_WA[10] VSS_WA[11] VSS_WA[12] VSS_WA[13] VSS_WA[14] VSS_WA[15]
+   WAPRCLKBUF[1] WAPRCLKBUFB_RET WAR[0] WAR[1] WB[8] WB[9] WB[10] WB[11] WB[12]
+   WB[13] WB[14] WB[15] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12]
+   WB_IN[13] WB_IN[14] WB_IN[15] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14]
+   WT[15] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14]
+   WT_IN[15] SNPS_SP_HD_512x8_sacwa_rt
.ENDS
.SUBCKT SNPS_SP_HD_512x8_samp BYPASS BYPASS_RET LCGTH LOG0 LOG1 QBOUT[0]
+       QBOUT[1] QB_IN[0] QB_IN[1] QB_NORIN[0] QB_NORIN[1] QTOUT[0] QTOUT[1]
+       QT_IN[0] QT_IN[1] QT_NORIN[0] QT_NORIN[1] RASSISTT[0] RASSISTT[1] RB[0]
+       RB[1] RT[0] RT[1] SAEB SAED SAPRB SEL[0] SEL[1] VBN[0] VBN[1] VBP[0]
+       VBP[1] VDDP[0] VDDP[1] VDDPI[0] VDDPI[1] VSS[0] VSS[1] VSS_WA[0]
+       VSS_WA[1] WB[0] WB[1] WB_IN[0] WB_IN[1] WT[0] WT[1] WT_IN[0] WT_IN[1]

*** Jumper Report ***
* Jumper: LOG0 QB_NORIN[0] QB_NORIN[1] QT_NORIN[0] QT_NORIN[1]
* Jumper: VDDP[0] VDDPI[0]
* Jumper: VDDP[1] VDDPI[1]

X_mm16a05_u_hdsp_plus_sacm4x1_nor_S0 VDDP[0] VDDPI[0] VSS[0] VSS_WA[0] VBP[0]
+   VBN[0] QBOUT[0] QTOUT[0] BYPASS BYPASS_RET LCGTH LOG0 LOG1 RASSISTT[0]
+   RASSISTT[1] RB[0] RT[0] SAED WB[0] WB_IN[0] WT[0] WT_IN[0] QB_IN[0]
+   QB_NORIN[0] QT_IN[0] QT_NORIN[0] SAEB SAPRB SEL[0]
+   mm16a05_u_hdsp_plus_sacm4x1_nor
X_mm16a05_u_hdsp_plus_sacm4x1_nor_F0 VDDP[1] VDDPI[1] VSS[1] VSS_WA[1] VBP[1]
+   VBN[1] QBOUT[1] QTOUT[1] BYPASS BYPASS_RET LCGTH LOG0 LOG1 RASSISTT[0]
+   RASSISTT[1] RB[1] RT[1] SAED WB[1] WB_IN[1] WT[1] WT_IN[1] QB_IN[1]
+   QB_NORIN[1] QT_IN[1] QT_NORIN[1] SAEB SAPRB SEL[1]
+   mm16a05_u_hdsp_plus_sacm4x1_nor
.ENDS
.SUBCKT SNPS_SP_HD_512x8_sac_lt_seg1 BYPASS BYPASS_RET LCGTH LOG0 LOG1 QBOUT[0]
+       QBOUT[1] QBOUT[2] QBOUT[3] QBOUT[4] QBOUT[5] QBOUT[6] QBOUT[7] QB_IN[0]
+       QB_IN[1] QB_IN[2] QB_IN[3] QB_IN[4] QB_IN[5] QB_IN[6] QB_IN[7]
+       QB_NORIN[0] QB_NORIN[1] QB_NORIN[2] QB_NORIN[3] QB_NORIN[4] QB_NORIN[5]
+       QB_NORIN[6] QB_NORIN[7] QTOUT[0] QTOUT[1] QTOUT[2] QTOUT[3] QTOUT[4]
+       QTOUT[5] QTOUT[6] QTOUT[7] QT_IN[0] QT_IN[1] QT_IN[2] QT_IN[3] QT_IN[4]
+       QT_IN[5] QT_IN[6] QT_IN[7] QT_NORIN[0] QT_NORIN[1] QT_NORIN[2]
+       QT_NORIN[3] QT_NORIN[4] QT_NORIN[5] QT_NORIN[6] QT_NORIN[7] RASSISTT[0]
+       RASSISTT[1] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RT[0] RT[1]
+       RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] SAEB SAED SAPRB SEL[0] SEL[1] SEL[2]
+       SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4]
+       VBN[5] VBN[6] VBN[7] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+       VBP[7] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7]
+       VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+       VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS_WA[0]
+       VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7]
+       WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB_IN[0] WB_IN[1]
+       WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WT[0] WT[1] WT[2]
+       WT[3] WT[4] WT[5] WT[6] WT[7] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3]
+       WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7]
X_samp_S0 BYPASS BYPASS_RET LCGTH LOG0 LOG1 QBOUT[0] QBOUT[1] QB_IN[0] QB_IN[1]
+   QB_NORIN[0] QB_NORIN[1] QTOUT[0] QTOUT[1] QT_IN[0] QT_IN[1] QT_NORIN[0]
+   QT_NORIN[1] RASSISTT[0] RASSISTT[1] RB[0] RB[1] RT[0] RT[1] SAEB SAED SAPRB
+   SEL[0] SEL[1] VBN[0] VBN[1] VBP[0] VBP[1] VDDP[0] VDDP[1] VDDPI[0] VDDPI[1]
+   VSS[0] VSS[1] VSS_WA[0] VSS_WA[1] WB[0] WB[1] WB_IN[0] WB_IN[1] WT[0] WT[1]
+   WT_IN[0] WT_IN[1] SNPS_SP_HD_512x8_samp
X_samp_S1 BYPASS BYPASS_RET LCGTH LOG0 LOG1 QBOUT[2] QBOUT[3] QB_IN[2] QB_IN[3]
+   QB_NORIN[2] QB_NORIN[3] QTOUT[2] QTOUT[3] QT_IN[2] QT_IN[3] QT_NORIN[2]
+   QT_NORIN[3] RASSISTT[0] RASSISTT[1] RB[2] RB[3] RT[2] RT[3] SAEB SAED SAPRB
+   SEL[2] SEL[3] VBN[2] VBN[3] VBP[2] VBP[3] VDDP[2] VDDP[3] VDDPI[2] VDDPI[3]
+   VSS[2] VSS[3] VSS_WA[2] VSS_WA[3] WB[2] WB[3] WB_IN[2] WB_IN[3] WT[2] WT[3]
+   WT_IN[2] WT_IN[3] SNPS_SP_HD_512x8_samp
X_samp_F1 BYPASS BYPASS_RET LCGTH LOG0 LOG1 QBOUT[4] QBOUT[5] QB_IN[4] QB_IN[5]
+   QB_NORIN[4] QB_NORIN[5] QTOUT[4] QTOUT[5] QT_IN[4] QT_IN[5] QT_NORIN[4]
+   QT_NORIN[5] RASSISTT[0] RASSISTT[1] RB[4] RB[5] RT[4] RT[5] SAEB SAED SAPRB
+   SEL[4] SEL[5] VBN[4] VBN[5] VBP[4] VBP[5] VDDP[4] VDDP[5] VDDPI[4] VDDPI[5]
+   VSS[4] VSS[5] VSS_WA[4] VSS_WA[5] WB[4] WB[5] WB_IN[4] WB_IN[5] WT[4] WT[5]
+   WT_IN[4] WT_IN[5] SNPS_SP_HD_512x8_samp
X_samp_F0 BYPASS BYPASS_RET LCGTH LOG0 LOG1 QBOUT[6] QBOUT[7] QB_IN[6] QB_IN[7]
+   QB_NORIN[6] QB_NORIN[7] QTOUT[6] QTOUT[7] QT_IN[6] QT_IN[7] QT_NORIN[6]
+   QT_NORIN[7] RASSISTT[0] RASSISTT[1] RB[6] RB[7] RT[6] RT[7] SAEB SAED SAPRB
+   SEL[6] SEL[7] VBN[6] VBN[7] VBP[6] VBP[7] VDDP[6] VDDP[7] VDDPI[6] VDDPI[7]
+   VSS[6] VSS[7] VSS_WA[6] VSS_WA[7] WB[6] WB[7] WB_IN[6] WB_IN[7] WT[6] WT[7]
+   WT_IN[6] WT_IN[7] SNPS_SP_HD_512x8_samp
.ENDS
.SUBCKT SNPS_SP_HD_512x8_sac_lt BYPASS BYPASS_RET LCGTH LOG0 LOG1 PWDO QBOUT[0]
+       QBOUT[1] QBOUT[2] QBOUT[3] QBOUT[4] QBOUT[5] QBOUT[6] QBOUT[7] QB_IN[0]
+       QB_IN[1] QB_IN[2] QB_IN[3] QB_IN[4] QB_IN[5] QB_IN[6] QB_IN[7]
+       QB_NORIN[0] QB_NORIN[1] QB_NORIN[2] QB_NORIN[3] QB_NORIN[4] QB_NORIN[5]
+       QB_NORIN[6] QB_NORIN[7] QTOUT[0] QTOUT[1] QTOUT[2] QTOUT[3] QTOUT[4]
+       QTOUT[5] QTOUT[6] QTOUT[7] QT_IN[0] QT_IN[1] QT_IN[2] QT_IN[3] QT_IN[4]
+       QT_IN[5] QT_IN[6] QT_IN[7] QT_NORIN[0] QT_NORIN[1] QT_NORIN[2]
+       QT_NORIN[3] QT_NORIN[4] QT_NORIN[5] QT_NORIN[6] QT_NORIN[7] RASSISTT[0]
+       RASSISTT[1] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RT[0] RT[1]
+       RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] SAEB SAED SAPRB SEL[0] SEL[1] SEL[2]
+       SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4]
+       VBN[5] VBN[6] VBN[7] VBN[8] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5]
+       VBP[6] VBP[7] VBP[8] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5]
+       VDDP[6] VDDP[7] VDDP[8] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+       VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VEDGE VSS[0] VSS[1] VSS[2] VSS[3]
+       VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS_WA[0] VSS_WA[1] VSS_WA[2]
+       VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7] WB[0] WB[1] WB[2]
+       WB[3] WB[4] WB[5] WB[6] WB[7] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3]
+       WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5]
+       WT[6] WT[7] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5]
+       WT_IN[6] WT_IN[7]
X_mm16a05_u_hdsp_plus_capsac VDDP[0] VDDPI[0] VSS[0] VBP[0] VBN[0] SAED LOG0
+   LOG1 PWDO VEDGE SAEB mm16a05_u_hdsp_plus_capsac
X_sac_lt_seg1 BYPASS BYPASS_RET LCGTH LOG0 LOG1 QBOUT[0] QBOUT[1] QBOUT[2]
+   QBOUT[3] QBOUT[4] QBOUT[5] QBOUT[6] QBOUT[7] QB_IN[0] QB_IN[1] QB_IN[2]
+   QB_IN[3] QB_IN[4] QB_IN[5] QB_IN[6] QB_IN[7] QB_NORIN[0] QB_NORIN[1]
+   QB_NORIN[2] QB_NORIN[3] QB_NORIN[4] QB_NORIN[5] QB_NORIN[6] QB_NORIN[7]
+   QTOUT[0] QTOUT[1] QTOUT[2] QTOUT[3] QTOUT[4] QTOUT[5] QTOUT[6] QTOUT[7]
+   QT_IN[0] QT_IN[1] QT_IN[2] QT_IN[3] QT_IN[4] QT_IN[5] QT_IN[6] QT_IN[7]
+   QT_NORIN[0] QT_NORIN[1] QT_NORIN[2] QT_NORIN[3] QT_NORIN[4] QT_NORIN[5]
+   QT_NORIN[6] QT_NORIN[7] RASSISTT[0] RASSISTT[1] RB[0] RB[1] RB[2] RB[3]
+   RB[4] RB[5] RB[6] RB[7] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] SAEB
+   SAED SAPRB SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] VBN[1]
+   VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[1] VBP[2] VBP[3] VBP[4]
+   VBP[5] VBP[6] VBP[7] VBP[8] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6]
+   VDDP[7] VDDP[8] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6]
+   VDDPI[7] VDDPI[8] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+   VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6]
+   VSS_WA[7] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB_IN[0] WB_IN[1]
+   WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WT[0] WT[1] WT[2]
+   WT[3] WT[4] WT[5] WT[6] WT[7] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4]
+   WT_IN[5] WT_IN[6] WT_IN[7] SNPS_SP_HD_512x8_sac_lt_seg1
.ENDS
.SUBCKT SNPS_SP_HD_512x8_sac_cen BYPASS BYP_VLOAD CENDP DEF_MODE ENLPGB FAST1B
+       FAST1_MODE FAST2_MODE FLOAT FLOATT FLOATT_PGM FLOAT_RET
+       FLOAT_RET_TIMER_PROG LBKADR[0] LBKADR[1] LBKADR[2] LCGTB LCGTHB LCGTHHV
+       LCGTHLV LCGTH_PCHG LDFTX LITESLP LLBKADRB[0] LLBKADRB[1] LLBKADRB[2]
+       LLBKADRT[0] LLBKADRT[1] LLBKADRT[2] LMATCH LMATCHB LMATCHB_I_BBK
+       LMATCHB_I_TBK LOG0 LOG1 LWEIB LWERD LWEWR LXADR[0] LXADR[1] LXADR[2]
+       LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+       PLBKADR[0] PLBKADR[1] PLBKADR[2] PLBKADRB PM[0] PM[1] PM[2] PM[3]
+       PRCKE_B PRCKE_T PRCLKB RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2]
+       RMT[3] RWLBHV RWLBLV RWLB_SAC SAEDL SAEDR SAET SAPRT T1T TEST_RNMB VBN
+       VBP VDDA VDDMINB VDDP VDDPI VSS WABUF[0] WABUF[1] WABUF[2]
+       WAPRCLKBUFB_RET WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]

*** Jumper Report ***
* Jumper: FLOAT_RET FLOAT_RET_TIMER_PROG PRCLKB
* Jumper: LCGTHHV LCGTHLV
* Jumper: LLBKADRB[0] PLBKADR[0] PLBKADRB
* Jumper: LLBKADRB[1] PLBKADR[1]
* Jumper: LLBKADRB[2] PLBKADR[2]
* Jumper: LOG0 ENLPGB LBKADR[0] LBKADR[1] LBKADR[2] LDFTX
* Jumper: LOG1 FLOATT_PGM LMATCHB LMATCHB_I_BBK LMATCHB_I_TBK
* Jumper: RWLBHV RWLBLV
* Jumper: VDDA VDDP VDDPI

X_mm16a05_u_hdsp_plus_sactrl VDDA VDDMINB VDDP VDDPI VSS VBP VBN FAST1B LCGTB
+   LCGTHB LCGTHLV LCGTH_PCHG LLBKADRB[0] LLBKADRB[1] LLBKADRB[2] LLBKADRT[0]
+   LLBKADRT[1] LLBKADRT[2] LMATCH LWERD LWEWR PM[0] PM[1] PM[2] PM[3] PRCKE_B
+   PRCKE_T PRCLKB RWLBLV SAET SAPRT BYPASS BYP_VLOAD DEF_MODE FAST1_MODE
+   FAST2_MODE FLOAT FLOATT_PGM FLOAT_RET LOG0 LOG1 RBLRD RBLWA RBLWR RMT[0]
+   RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2]
+   WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] CENDP ENLPGB FLOATT
+   FLOAT_RET_TIMER_PROG LBKADR[0] LBKADR[1] LBKADR[2] LCGTHHV LDFTX LITESLP
+   LMATCHB LMATCHB_I_BBK LMATCHB_I_TBK LWEIB LXADR[0] LXADR[1] LXADR[2]
+   LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PLBKADR[0]
+   PLBKADR[1] PLBKADR[2] PLBKADRB RM3CNT RWLBHV SAEDL SAEDR WAPRCLKBUFB_RET
+   mm16a05_u_hdsp_plus_sactrl
.ENDS
.SUBCKT SNPS_SP_HD_512x8_sac_buf ARYSD ARYSD_BC1 ARYSD_BC2 BYPASS BYPASS_RET
+       LCGTH LCGTHB LCGTHB_IN LCGTHHV LOG0 LOG1 RASSIST[0] RASSIST[1]
+       RASSISTT[0] RASSISTT[1] SAEB SAED SAET SAPRB SAPRT VBN VBP VDDA VDDP
+       VDDPI VSS

*** Jumper Report ***
* Jumper: LCGTHB LCGTHB_IN
* Jumper: VDDA VDDP VDDPI

X_mm16a05_u_hdsp_plus_sacbuf VDDA VDDP VDDPI VSS VBP VBN LCGTH SAEB SAPRB ARYSD
+   ARYSD_BC1 ARYSD_BC2 BYPASS BYPASS_RET LOG0 LOG1 RASSIST[0] RASSIST[1]
+   RASSISTT[0] RASSISTT[1] SAED LCGTHB LCGTHB_IN LCGTHHV SAET SAPRT
+   mm16a05_u_hdsp_plus_sacbuf
.ENDS
.SUBCKT SNPS_SP_HD_512x8_sac_cnt ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1]
+       ARYSD_BC2[0] ARYSD_BC2[1] BYPASS[0] BYPASS[1] BYPASS_RET[0]
+       BYPASS_RET[1] BYP_VLOAD CENDP DEF_MODE ENLPGB FAST1B FAST1_MODE
+       FAST2_MODE FLOAT FLOATT FLOATT_PGM FLOAT_RET FLOAT_RET_TIMER_PROG
+       LCGTH[0] LCGTH[1] LCGTH_PCHG LDFTX LITESLP LLBKADRB[0] LLBKADRB[1]
+       LLBKADRB[2] LLBKADRT[0] LLBKADRT[1] LLBKADRT[2] LMATCH LMATCHB
+       LMATCHB_I_BBK LMATCHB_I_TBK LOG0 LOG1 LWEIB LWERD LWEWR LXADR[0]
+       LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+       LYADR[1] PLBKADR[0] PLBKADR[1] PLBKADR[2] PLBKADRB PM[0] PM[1] PM[2]
+       PM[3] PRCKE_B PRCKE_T PRCLKB RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3]
+       RASSISTTH[0] RASSISTTH[1] RASSISTTL[0] RASSISTTL[1] RBLRD RBLWA RBLWR
+       RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC SAEBL SAEBR SAEDL SAEDR
+       SAPRB[0] SAPRB[1] T1T TEST_RNMB VBN[0] VBN[1] VBN[2] VBP[0] VBP[1]
+       VBP[2] VDDA[0] VDDA[1] VDDA[2] VDDMINB VDDP[0] VDDP[1] VDDP[2] VDDPI[0]
+       VDDPI[1] VDDPI[2] VSS[0] VSS[1] VSS[2] WABUF[0] WABUF[1] WABUF[2]
+       WAPRCLKBUFB_RET WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]

*** Jumper Report ***
* Jumper: LCGTHB LCGTHB_IN[0]
* Jumper: VDDA[0] VDDP[0] VDDPI[0]

X_mm16a05_u_hdsp_plus_sacbuf_left VDDA[0] VDDP[0] VDDPI[0] VSS[0] VBP[0] VBN[0]
+   LCGTH[0] SAEBL SAPRB[0] ARYSD[0] ARYSD_BC1[0] ARYSD_BC2[0] BYPASS[0]
+   BYPASS_RET[0] LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTTL[0] RASSISTTL[1]
+   SAEDL LCGTHB LCGTHB LCGTHHV SAET SAPRT mm16a05_u_hdsp_plus_sacbuf
X_sac_cen BYPASS[1] BYP_VLOAD CENDP DEF_MODE ENLPGB FAST1B FAST1_MODE FAST2_MODE
+   FLOAT FLOATT FLOATT_PGM FLOAT_RET FLOAT_RET_TIMER_PROG LOG0 LOG0 LOG0 LCGTB
+   LCGTHB LCGTHHV LCGTHHV LCGTH_PCHG LDFTX LITESLP LLBKADRB[0] LLBKADRB[1]
+   LLBKADRB[2] LLBKADRT[0] LLBKADRT[1] LLBKADRT[2] LMATCH LMATCHB LMATCHB_I_BBK
+   LMATCHB_I_TBK LOG0 LOG1 LWEIB LWERD LWEWR LXADR[0] LXADR[1] LXADR[2]
+   LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PLBKADR[0]
+   PLBKADR[1] PLBKADR[2] PLBKADRB PM[0] PM[1] PM[2] PM[3] PRCKE_B PRCKE_T
+   PRCLKB RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLBHV RWLBHV
+   RWLB_SAC SAEDL SAEDR SAET SAPRT T1T TEST_RNMB VBN[1] VBP[1] VDDA[1] VDDMINB
+   VDDP[1] VDDPI[1] VSS[1] WABUF[0] WABUF[1] WABUF[2] WAPRCLKBUFB_RET WMT[0]
+   WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] SNPS_SP_HD_512x8_sac_cen
X_sac_buf ARYSD[1] ARYSD_BC1[1] ARYSD_BC2[1] BYPASS[1] BYPASS_RET[1] LCGTH[1]
+   LCGTHB LCGTHB LCGTHHV LOG0 LOG1 RASSIST[2] RASSIST[3] RASSISTTH[0]
+   RASSISTTH[1] SAEBR SAEDR SAET SAPRB[1] SAPRT VBN[2] VBP[2] VDDA[2] VDDP[2]
+   VDDPI[2] VSS[2] SNPS_SP_HD_512x8_sac_buf
.ENDS
.SUBCKT SNPS_SP_HD_512x8_sac_rt BYPASS BYPASS_RET LCGTH LOG0 LOG1 PWDO QBOUT[0]
+       QBOUT[1] QBOUT[2] QBOUT[3] QBOUT[4] QBOUT[5] QBOUT[6] QBOUT[7] QB_IN[0]
+       QB_IN[1] QB_IN[2] QB_IN[3] QB_IN[4] QB_IN[5] QB_IN[6] QB_IN[7]
+       QB_NORIN[0] QB_NORIN[1] QB_NORIN[2] QB_NORIN[3] QB_NORIN[4] QB_NORIN[5]
+       QB_NORIN[6] QB_NORIN[7] QTOUT[0] QTOUT[1] QTOUT[2] QTOUT[3] QTOUT[4]
+       QTOUT[5] QTOUT[6] QTOUT[7] QT_IN[0] QT_IN[1] QT_IN[2] QT_IN[3] QT_IN[4]
+       QT_IN[5] QT_IN[6] QT_IN[7] QT_NORIN[0] QT_NORIN[1] QT_NORIN[2]
+       QT_NORIN[3] QT_NORIN[4] QT_NORIN[5] QT_NORIN[6] QT_NORIN[7] RASSISTT[0]
+       RASSISTT[1] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RT[0] RT[1]
+       RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] SAEB SAED SAPRB SEL[0] SEL[1] SEL[2]
+       SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4]
+       VBN[5] VBN[6] VBN[7] VBN[8] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5]
+       VBP[6] VBP[7] VBP[8] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5]
+       VDDP[6] VDDP[7] VDDP[8] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+       VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VEDGE VSS[0] VSS[1] VSS[2] VSS[3]
+       VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS_WA[0] VSS_WA[1] VSS_WA[2]
+       VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7] WB[0] WB[1] WB[2]
+       WB[3] WB[4] WB[5] WB[6] WB[7] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3]
+       WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5]
+       WT[6] WT[7] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5]
+       WT_IN[6] WT_IN[7]
X_sac_lt_seg1 BYPASS BYPASS_RET LCGTH LOG0 LOG1 QBOUT[0] QBOUT[1] QBOUT[2]
+   QBOUT[3] QBOUT[4] QBOUT[5] QBOUT[6] QBOUT[7] QB_IN[0] QB_IN[1] QB_IN[2]
+   QB_IN[3] QB_IN[4] QB_IN[5] QB_IN[6] QB_IN[7] QB_NORIN[0] QB_NORIN[1]
+   QB_NORIN[2] QB_NORIN[3] QB_NORIN[4] QB_NORIN[5] QB_NORIN[6] QB_NORIN[7]
+   QTOUT[0] QTOUT[1] QTOUT[2] QTOUT[3] QTOUT[4] QTOUT[5] QTOUT[6] QTOUT[7]
+   QT_IN[0] QT_IN[1] QT_IN[2] QT_IN[3] QT_IN[4] QT_IN[5] QT_IN[6] QT_IN[7]
+   QT_NORIN[0] QT_NORIN[1] QT_NORIN[2] QT_NORIN[3] QT_NORIN[4] QT_NORIN[5]
+   QT_NORIN[6] QT_NORIN[7] RASSISTT[0] RASSISTT[1] RB[0] RB[1] RB[2] RB[3]
+   RB[4] RB[5] RB[6] RB[7] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] SAEB
+   SAED SAPRB SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] VBN[0]
+   VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBP[0] VBP[1] VBP[2] VBP[3]
+   VBP[4] VBP[5] VBP[6] VBP[7] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5]
+   VDDP[6] VDDP[7] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5]
+   VDDPI[6] VDDPI[7] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6]
+   VSS_WA[7] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB_IN[0] WB_IN[1]
+   WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WT[0] WT[1] WT[2]
+   WT[3] WT[4] WT[5] WT[6] WT[7] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4]
+   WT_IN[5] WT_IN[6] WT_IN[7] SNPS_SP_HD_512x8_sac_lt_seg1
X_mm16a05_u_hdsp_plus_capsac VDDP[8] VDDPI[8] VSS[8] VBP[8] VBN[8] SAED LOG0
+   LOG1 PWDO VEDGE SAEB mm16a05_u_hdsp_plus_capsac
.ENDS
.SUBCKT SNPS_SP_HD_512x8_sac_row_1 ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1]
+       ARYSD_BC2[0] ARYSD_BC2[1] BYP_VLOAD CENDP DEF_MODE ENLPGB FAST1B
+       FAST1_MODE FAST2_MODE FLOAT FLOATT FLOATT_PGM FLOAT_RET
+       FLOAT_RET_TIMER_PROG LCGTH[0] LCGTH[1] LCGTH_PCHG LDFTX LITESLP
+       LLBKADRB[0] LLBKADRB[1] LLBKADRB[2] LLBKADRT[0] LLBKADRT[1] LLBKADRT[2]
+       LMATCH LMATCHB LMATCHB_I_BBK LMATCHB_I_TBK LOG0 LOG1 LWEIB LWERD LWEWR
+       LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+       LYADR[0] LYADR[1] PLBKADR[0] PLBKADR[1] PLBKADR[2] PLBKADRB PM[0] PM[1]
+       PM[2] PM[3] PRCKE_B PRCKE_T PRCLKB PWDO[0] PWDO[1] QBOUT[0] QBOUT[1]
+       QBOUT[2] QBOUT[3] QBOUT[4] QBOUT[5] QBOUT[6] QBOUT[7] QBOUT[8] QBOUT[9]
+       QBOUT[10] QBOUT[11] QBOUT[12] QBOUT[13] QBOUT[14] QBOUT[15] QB_IN[0]
+       QB_IN[1] QB_IN[2] QB_IN[3] QB_IN[4] QB_IN[5] QB_IN[6] QB_IN[7] QB_IN[8]
+       QB_IN[9] QB_IN[10] QB_IN[11] QB_IN[12] QB_IN[13] QB_IN[14] QB_IN[15]
+       QB_NORIN[0] QB_NORIN[1] QB_NORIN[2] QB_NORIN[3] QB_NORIN[4] QB_NORIN[5]
+       QB_NORIN[6] QB_NORIN[7] QB_NORIN[8] QB_NORIN[9] QB_NORIN[10]
+       QB_NORIN[11] QB_NORIN[12] QB_NORIN[13] QB_NORIN[14] QB_NORIN[15]
+       QTOUT[0] QTOUT[1] QTOUT[2] QTOUT[3] QTOUT[4] QTOUT[5] QTOUT[6] QTOUT[7]
+       QTOUT[8] QTOUT[9] QTOUT[10] QTOUT[11] QTOUT[12] QTOUT[13] QTOUT[14]
+       QTOUT[15] QT_IN[0] QT_IN[1] QT_IN[2] QT_IN[3] QT_IN[4] QT_IN[5] QT_IN[6]
+       QT_IN[7] QT_IN[8] QT_IN[9] QT_IN[10] QT_IN[11] QT_IN[12] QT_IN[13]
+       QT_IN[14] QT_IN[15] QT_NORIN[0] QT_NORIN[1] QT_NORIN[2] QT_NORIN[3]
+       QT_NORIN[4] QT_NORIN[5] QT_NORIN[6] QT_NORIN[7] QT_NORIN[8] QT_NORIN[9]
+       QT_NORIN[10] QT_NORIN[11] QT_NORIN[12] QT_NORIN[13] QT_NORIN[14]
+       QT_NORIN[15] RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RB[0] RB[1]
+       RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12]
+       RB[13] RB[14] RB[15] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2]
+       RMT[3] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9]
+       RT[10] RT[11] RT[12] RT[13] RT[14] RT[15] RWLB_SAC SEL[0] SEL[1] SEL[2]
+       SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+       SEL[13] SEL[14] SEL[15] T1T TEST_RNMB VBN[0] VBN[1] VBN[2] VBN[3] VBN[4]
+       VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13]
+       VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20] VBP[0] VBP[1]
+       VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11]
+       VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20]
+       VDDA[0] VDDA[1] VDDA[2] VDDMINB VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4]
+       VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12]
+       VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20]
+       VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+       VDDPI[8] VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14]
+       VDDPI[15] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VEDGE[0]
+       VEDGE[1] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+       VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17]
+       VSS[18] VSS[19] VSS[20] VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3]
+       VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7] VSS_WA[8] VSS_WA[9] VSS_WA[10]
+       VSS_WA[11] VSS_WA[12] VSS_WA[13] VSS_WA[14] VSS_WA[15] WABUF[0] WABUF[1]
+       WABUF[2] WAPRCLKBUFB_RET WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7]
+       WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15] WB_IN[0] WB_IN[1]
+       WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9]
+       WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WMT[0]
+       WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT[0] WT[1] WT[2] WT[3]
+       WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14]
+       WT[15] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6]
+       WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13]
+       WT_IN[14] WT_IN[15]
X_sac_lt BYPASS[0] BYPASS_RET[0] LCGTH[0] LOG0 LOG1 PWDO[0] QBOUT[0] QBOUT[1]
+   QBOUT[2] QBOUT[3] QBOUT[4] QBOUT[5] QBOUT[6] QBOUT[7] QB_IN[0] QB_IN[1]
+   QB_IN[2] QB_IN[3] QB_IN[4] QB_IN[5] QB_IN[6] QB_IN[7] QB_NORIN[0]
+   QB_NORIN[1] QB_NORIN[2] QB_NORIN[3] QB_NORIN[4] QB_NORIN[5] QB_NORIN[6]
+   QB_NORIN[7] QTOUT[0] QTOUT[1] QTOUT[2] QTOUT[3] QTOUT[4] QTOUT[5] QTOUT[6]
+   QTOUT[7] QT_IN[0] QT_IN[1] QT_IN[2] QT_IN[3] QT_IN[4] QT_IN[5] QT_IN[6]
+   QT_IN[7] QT_NORIN[0] QT_NORIN[1] QT_NORIN[2] QT_NORIN[3] QT_NORIN[4]
+   QT_NORIN[5] QT_NORIN[6] QT_NORIN[7] RASSISTTL[0] RASSISTTL[1] RB[0] RB[1]
+   RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5]
+   RT[6] RT[7] SAEBL SAEDL SAPRB[0] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5]
+   SEL[6] SEL[7] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE[0] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+   VSS_WA[0] VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6]
+   VSS_WA[7] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB_IN[0] WB_IN[1]
+   WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WT[0] WT[1] WT[2]
+   WT[3] WT[4] WT[5] WT[6] WT[7] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4]
+   WT_IN[5] WT_IN[6] WT_IN[7] SNPS_SP_HD_512x8_sac_lt
X_sac_cnt ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1]
+   BYPASS[0] BYPASS[1] BYPASS_RET[0] BYPASS_RET[1] BYP_VLOAD CENDP DEF_MODE
+   ENLPGB FAST1B FAST1_MODE FAST2_MODE FLOAT FLOATT FLOATT_PGM FLOAT_RET
+   FLOAT_RET_TIMER_PROG LCGTH[0] LCGTH[1] LCGTH_PCHG LDFTX LITESLP LLBKADRB[0]
+   LLBKADRB[1] LLBKADRB[2] LLBKADRT[0] LLBKADRT[1] LLBKADRT[2] LMATCH LMATCHB
+   LMATCHB_I_BBK LMATCHB_I_TBK LOG0 LOG1 LWEIB LWERD LWEWR LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PLBKADR[0] PLBKADR[1] PLBKADR[2] PLBKADRB PM[0] PM[1] PM[2] PM[3] PRCKE_B
+   PRCKE_T PRCLKB RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RASSISTTH[0]
+   RASSISTTH[1] RASSISTTL[0] RASSISTTL[1] RBLRD RBLWA RBLWR RM3CNT RMT[0]
+   RMT[1] RMT[2] RMT[3] RWLB_SAC SAEBL SAEBR SAEDL SAEDR SAPRB[0] SAPRB[1] T1T
+   TEST_RNMB VBN[9] VBN[10] VBN[11] VBP[9] VBP[10] VBP[11] VDDA[0] VDDA[1]
+   VDDA[2] VDDMINB VDDP[9] VDDP[10] VDDP[11] VDDPI[9] VDDPI[10] VDDPI[11]
+   VSS[9] VSS[10] VSS[11] WABUF[0] WABUF[1] WABUF[2] WAPRCLKBUFB_RET WMT[0]
+   WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] SNPS_SP_HD_512x8_sac_cnt
X_sac_rt BYPASS[1] BYPASS_RET[1] LCGTH[1] LOG0 LOG1 PWDO[1] QBOUT[8] QBOUT[9]
+   QBOUT[10] QBOUT[11] QBOUT[12] QBOUT[13] QBOUT[14] QBOUT[15] QB_IN[8]
+   QB_IN[9] QB_IN[10] QB_IN[11] QB_IN[12] QB_IN[13] QB_IN[14] QB_IN[15]
+   QB_NORIN[8] QB_NORIN[9] QB_NORIN[10] QB_NORIN[11] QB_NORIN[12] QB_NORIN[13]
+   QB_NORIN[14] QB_NORIN[15] QTOUT[8] QTOUT[9] QTOUT[10] QTOUT[11] QTOUT[12]
+   QTOUT[13] QTOUT[14] QTOUT[15] QT_IN[8] QT_IN[9] QT_IN[10] QT_IN[11]
+   QT_IN[12] QT_IN[13] QT_IN[14] QT_IN[15] QT_NORIN[8] QT_NORIN[9] QT_NORIN[10]
+   QT_NORIN[11] QT_NORIN[12] QT_NORIN[13] QT_NORIN[14] QT_NORIN[15]
+   RASSISTTH[0] RASSISTTH[1] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13] RB[14]
+   RB[15] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15] SAEBR SAEDR
+   SAPRB[1] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15]
+   VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20]
+   VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20]
+   VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19]
+   VDDP[20] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17]
+   VDDPI[18] VDDPI[19] VDDPI[20] VEDGE[1] VSS[12] VSS[13] VSS[14] VSS[15]
+   VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSS_WA[8] VSS_WA[9] VSS_WA[10]
+   VSS_WA[11] VSS_WA[12] VSS_WA[13] VSS_WA[14] VSS_WA[15] WB[8] WB[9] WB[10]
+   WB[11] WB[12] WB[13] WB[14] WB[15] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11]
+   WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WT[8] WT[9] WT[10] WT[11] WT[12]
+   WT[13] WT[14] WT[15] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12]
+   WT_IN[13] WT_IN[14] WT_IN[15] SNPS_SP_HD_512x8_sac_rt
.ENDS
.SUBCKT SNPS_SP_HD_512x8_cmux_tile BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] CKPRCH LOG0 LOG1
+       PO[0] PO[1] POWINT[0] POWINT[1] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2]
+       PRCHRDB[3] PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] QB[0] QB[1] QT[0]
+       QT[1] RB[0] RB[1] RT[0] RT[1] SEL[0] SEL[1] VBA[0] VBA[1] VBN[0] VBN[1]
+       VBP[0] VBP[1] VDDA[0] VDDA[1] VDDAI[0] VDDAI[1] VDDP[0] VDDP[1] VDDPI[0]
+       VDDPI[1] VSS[0] VSS[1] WB[0] WB[1] WBI[0] WBI[1] WT[0] WT[1] WTI[0]
+       WTI[1]

*** Jumper Report ***
* Jumper: VBA[0] VSS[0]
* Jumper: VBA[1] VSS[1]
* Jumper: VDDA[0] VDDP[0] VDDPI[0]
* Jumper: VDDA[1] VDDP[1] VDDPI[1]

X_mm16a05_u_hdsp_plus_hc_cmux4x1_S0 VDDA[0] VDDAI[0] VDDP[0] VDDPI[0] VSS[0]
+   VBP[0] VBN[0] BB[0] BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3] LOG0 LOG1
+   PO[0] PO[1] POWINT[0] POWINT[1] QB[0] QT[0] RB[0] RT[0] VBA[0] WB[0] WBI[0]
+   WT[0] WTI[0] CKPRCH PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0]
+   PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] SEL[0] mm16a05_u_hdsp_plus_hc_cmux4x1
X_mm16a05_u_hdsp_plus_hc_cmux4x1_F0 VDDA[1] VDDAI[1] VDDP[1] VDDPI[1] VSS[1]
+   VBP[1] VBN[1] BB[4] BB[5] BB[6] BB[7] BT[4] BT[5] BT[6] BT[7] LOG0 LOG1
+   PO[0] PO[1] POWINT[0] POWINT[1] QB[1] QT[1] RB[1] RT[1] VBA[1] WB[1] WBI[1]
+   WT[1] WTI[1] CKPRCH PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0]
+   PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] SEL[1] mm16a05_u_hdsp_plus_hc_cmux4x1
.ENDS
.SUBCKT SNPS_SP_HD_512x8_mux_lt_seg1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+       BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16]
+       BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26]
+       BT[27] BT[28] BT[29] BT[30] BT[31] CKPRCH LOG0 LOG1 PO[0] PO[1]
+       POWINT[0] POWINT[1] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3]
+       PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] QB[0] QB[1] QB[2] QB[3]
+       QB[4] QB[5] QB[6] QB[7] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+       RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RT[0] RT[1] RT[2] RT[3]
+       RT[4] RT[5] RT[6] RT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+       SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBN[0]
+       VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBP[0] VBP[1] VBP[2]
+       VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VDDA[0] VDDA[1] VDDA[2] VDDA[3]
+       VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDAI[0] VDDAI[1] VDDAI[2] VDDAI[3]
+       VDDAI[4] VDDAI[5] VDDAI[6] VDDAI[7] VDDP[0] VDDP[1] VDDP[2] VDDP[3]
+       VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3]
+       VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4]
+       VSS[5] VSS[6] VSS[7] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7]
+       WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WT[0] WT[1]
+       WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4]
+       WTI[5] WTI[6] WTI[7]
X_cmux_tile_S0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BT[0] BT[1] BT[2]
+   BT[3] BT[4] BT[5] BT[6] BT[7] CKPRCH LOG0 LOG1 PO[0] PO[1] POWINT[0]
+   POWINT[1] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0] PRCHWRB[1]
+   PRCHWRB[2] PRCHWRB[3] QB[0] QB[1] QT[0] QT[1] RB[0] RB[1] RT[0] RT[1] SEL[0]
+   SEL[1] VBA[0] VBA[1] VBN[0] VBN[1] VBP[0] VBP[1] VDDA[0] VDDA[1] VDDAI[0]
+   VDDAI[1] VDDP[0] VDDP[1] VDDPI[0] VDDPI[1] VSS[0] VSS[1] WB[0] WB[1] WBI[0]
+   WBI[1] WT[0] WT[1] WTI[0] WTI[1] SNPS_SP_HD_512x8_cmux_tile
X_cmux_tile_S1 BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BT[8] BT[9]
+   BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] CKPRCH LOG0 LOG1 PO[0] PO[1]
+   POWINT[0] POWINT[1] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0]
+   PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] QB[2] QB[3] QT[2] QT[3] RB[2] RB[3] RT[2]
+   RT[3] SEL[2] SEL[3] VBA[2] VBA[3] VBN[2] VBN[3] VBP[2] VBP[3] VDDA[2]
+   VDDA[3] VDDAI[2] VDDAI[3] VDDP[2] VDDP[3] VDDPI[2] VDDPI[3] VSS[2] VSS[3]
+   WB[2] WB[3] WBI[2] WBI[3] WT[2] WT[3] WTI[2] WTI[3]
+   SNPS_SP_HD_512x8_cmux_tile
X_cmux_tile_F1 BB[16] BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BT[16]
+   BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] CKPRCH LOG0 LOG1 PO[0]
+   PO[1] POWINT[0] POWINT[1] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3]
+   PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] QB[4] QB[5] QT[4] QT[5] RB[4]
+   RB[5] RT[4] RT[5] SEL[4] SEL[5] VBA[4] VBA[5] VBN[4] VBN[5] VBP[4] VBP[5]
+   VDDA[4] VDDA[5] VDDAI[4] VDDAI[5] VDDP[4] VDDP[5] VDDPI[4] VDDPI[5] VSS[4]
+   VSS[5] WB[4] WB[5] WBI[4] WBI[5] WT[4] WT[5] WTI[4] WTI[5]
+   SNPS_SP_HD_512x8_cmux_tile
X_cmux_tile_F0 BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[24]
+   BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] CKPRCH LOG0 LOG1 PO[0]
+   PO[1] POWINT[0] POWINT[1] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3]
+   PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] QB[6] QB[7] QT[6] QT[7] RB[6]
+   RB[7] RT[6] RT[7] SEL[6] SEL[7] VBA[6] VBA[7] VBN[6] VBN[7] VBP[6] VBP[7]
+   VDDA[6] VDDA[7] VDDAI[6] VDDAI[7] VDDP[6] VDDP[7] VDDPI[6] VDDPI[7] VSS[6]
+   VSS[7] WB[6] WB[7] WBI[6] WBI[7] WT[6] WT[7] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_cmux_tile
.ENDS
.SUBCKT SNPS_SP_HD_512x8_mux_lt BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7]
+       BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17]
+       BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27]
+       BB[28] BB[29] BB[30] BB[31] BOTEDGE BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+       BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16]
+       BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26]
+       BT[27] BT[28] BT[29] BT[30] BT[31] CKPRCH LOG0 LOG1 PGIOI PO POWINT[0]
+       POWINT[1] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0]
+       PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5]
+       QB[6] QB[7] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] RB[0] RB[1]
+       RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5]
+       RT[6] RT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7]
+       VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBN[0]
+       VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0] VBP[1]
+       VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[0] VDDA[1] VDDA[2]
+       VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDAIL1 VDDP[0] VDDP[1]
+       VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+       VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+       WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WBI[0] WBI[1] WBI[2]
+       WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5]
+       WT[6] WT[7] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]

*** Jumper Report ***
* Jumper: VDDA[0] VDDP[0] VDDPI[0]

X_mm16a05_u_hdsp_plus_capmux VDDA[0] VDDP[0] VDDPI[0] VSS[0] VBP[0] VBN[0]
+   BOTEDGE LOG0 LOG1 PGIOI PO VBA[0] VEDGE mm16a05_u_hdsp_plus_capmux
X_mux_lt_seg1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] CKPRCH LOG0 LOG1 PO
+   PO POWINT[0] POWINT[1] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3]
+   PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] QB[0] QB[1] QB[2] QB[3] QB[4]
+   QB[5] QB[6] QB[7] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] RB[0]
+   RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RT[0] RT[1] RT[2] RT[3] RT[4]
+   RT[5] RT[6] RT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7]
+   VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBN[1] VBN[2] VBN[3]
+   VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+   VBP[7] VBP[8] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+   VDDA[8] VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[1]
+   VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VSS[1] VSS[2]
+   VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WB[0] WB[1] WB[2] WB[3] WB[4]
+   WB[5] WB[6] WB[7] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7]
+   WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WTI[0] WTI[1] WTI[2] WTI[3]
+   WTI[4] WTI[5] WTI[6] WTI[7] SNPS_SP_HD_512x8_mux_lt_seg1
.ENDS
.SUBCKT SNPS_SP_HD_512x8_mux_cnt ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1]
+       ARYSD_BC2[0] ARYSD_BC2[1] BOTEDGE[0] BOTEDGE[1] BYP_VLOAD CENDP CKPRCHH
+       CKPRCHL DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LCGTH[0]
+       LCGTH[1] LCGTH_PCHG LDFTX LITESLP LMATCH LMATCHB LOG0 LOG1 LWEIB LWERD
+       LWEWR LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6]
+       LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5]
+       PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7]
+       PM[0] PM[1] PM[2] PM[3] PO[0] PO[1] PRCHRDBH[0] PRCHRDBH[1] PRCHRDBH[2]
+       PRCHRDBH[3] PRCHRDBL[0] PRCHRDBL[1] PRCHRDBL[2] PRCHRDBL[3] PRCHWRBH[0]
+       PRCHWRBH[1] PRCHWRBH[2] PRCHWRBH[3] PRCHWRBL[0] PRCHWRBL[1] PRCHWRBL[2]
+       PRCHWRBL[3] PRCKE_T RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3]
+       RASSISTBH[0] RASSISTBH[1] RASSISTBL[0] RASSISTBL[1] RBLRD RBLWA RBLWR
+       RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB VBA[0] VBA[1]
+       VBN[0] VBN[1] VBN[2] VBP[0] VBP[1] VBP[2] VDDA[0] VDDA[1] VDDA[2]
+       VDDMINB VDDP[0] VDDP[1] VDDP[2] VDDPI[0] VDDPI[1] VDDPI[2] VDDWL[0]
+       VDDWL[1] VSS[0] VSS[1] VSS[2] VSSC_WL_L VSSC_WL_R WABUF[0] WABUF[1]
+       WABUF[2] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] WMT[0] WMT[1] WMT[2] WMT[3]
+       WPBUF[0] WPBUF[1] WPBUF[2]

*** Jumper Report ***
* Jumper: CLK_WLBH CLK_WLBL
* Jumper: LOG1 LMATCHB
* Jumper: PRCHWR[0] PRCHWRH[0]
* Jumper: PRCHWR[1] PRCHWRH[1]
* Jumper: PRCHWR[2] PRCHWRH[2]
* Jumper: PRCHWR[3] PRCHWRH[3]
* Jumper: VDDA[0] VDDP[0] VDDPI[0]
* Jumper: VDDA[1] VDDP[1] VDDPI[1]
* Jumper: VDDA[2] VDDP[2] VDDPI[2]
* Jumper: XPRBH[0] XPRBL[0]
* Jumper: XPRBH[1] XPRBL[1]
* Jumper: XPRBH[2] XPRBL[2]
* Jumper: XPRBH[3] XPRBL[3]

X_mm16a05_u_hdsp_plus_lcenbuf_left VDDA[0] VDDP[0] VDDPI[0] VDDWL[0] VSS[0]
+   VBP[0] VBN[0] CKPRCHL LCGTHB[0] PRCHRDBL[0] PRCHRDBL[1] PRCHRDBL[2]
+   PRCHRDBL[3] PRCHWRBL[0] PRCHWRBL[1] PRCHWRBL[2] PRCHWRBL[3] RASSISTBL[0]
+   RASSISTBL[1] ARYSD[0] ARYSD_BC1[0] ARYSD_BC2[0] BOTEDGE[0] PO[0] VBA[0]
+   CKPRCHB LCGTH[0] LOG0 LOG1 PRCHRD[0] PRCHRD[1] PRCHRD[2] PRCHRD[3] PRCHWR[0]
+   PRCHWR[1] PRCHWR[2] PRCHWR[3] RASSIST[0] RASSIST[1]
+   mm16a05_u_hdsp_plus_lcenbuf
X_mm16a05_u_hdsp_plus_lcen VDDA[1] VDDMINB VDDP[1] VDDPI[1] VSS[1] VSSC_WL_L
+   VSSC_WL_R VBP[1] VBN[1] CKPRCHB LMATCH PBB[0] PBB[1] PBB[2] PBB[3] PBB[4]
+   PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7]
+   PRCHRD[0] PRCHRD[1] PRCHRD[2] PRCHRD[3] PRCHWR[0] PRCHWR[1] PRCHWR[2]
+   PRCHWR[3] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] BYP_VLOAD CENDP CLK_WLBH
+   CLK_WLBH DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LDFTX LITESLP
+   LOG0 LOG1 LWEIB LWERD LWEWR PRCHWR[0] PRCHWR[1] PRCHWR[2] PRCHWR[3] RBLRD
+   RBLWA RBLWR RWLB_SAC WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3]
+   WPBUF[0] WPBUF[1] WPBUF[2] XPRBH[0] XPRBH[1] XPRBH[2] XPRBH[3] XPRBH[0]
+   XPRBH[1] XPRBH[2] XPRBH[3] LBKADR[0] LBKADR[1] LBKADR[2] LCGTHB[1]
+   LCGTH_PCHG LMATCHB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+   LXADR[6] LXADR[7] LYADR[0] LYADR[1] PM[0] PM[1] PM[2] PM[3] PRCKE_T RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] T1T TEST_RNMB mm16a05_u_hdsp_plus_lcen
X_mm16a05_u_hdsp_plus_lcenbuf VDDA[2] VDDP[2] VDDPI[2] VDDWL[1] VSS[2] VBP[2]
+   VBN[2] CKPRCHH LCGTHB[1] PRCHRDBH[0] PRCHRDBH[1] PRCHRDBH[2] PRCHRDBH[3]
+   PRCHWRBH[0] PRCHWRBH[1] PRCHWRBH[2] PRCHWRBH[3] RASSISTBH[0] RASSISTBH[1]
+   ARYSD[1] ARYSD_BC1[1] ARYSD_BC2[1] BOTEDGE[1] PO[1] VBA[1] CKPRCHB LCGTH[1]
+   LOG0 LOG1 PRCHRD[0] PRCHRD[1] PRCHRD[2] PRCHRD[3] PRCHWR[0] PRCHWR[1]
+   PRCHWR[2] PRCHWR[3] RASSIST[2] RASSIST[3] mm16a05_u_hdsp_plus_lcenbuf
.ENDS
.SUBCKT SNPS_SP_HD_512x8_mux_rt BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7]
+       BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17]
+       BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27]
+       BB[28] BB[29] BB[30] BB[31] BOTEDGE BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+       BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16]
+       BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26]
+       BT[27] BT[28] BT[29] BT[30] BT[31] CKPRCH LOG0 LOG1 PGIOI PO POWINT[0]
+       POWINT[1] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3] PRCHWRB[0]
+       PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5]
+       QB[6] QB[7] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] RB[0] RB[1]
+       RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5]
+       RT[6] RT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7]
+       VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBN[0]
+       VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0] VBP[1]
+       VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[0] VDDA[1] VDDA[2]
+       VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDAIR1 VDDP[0] VDDP[1]
+       VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+       VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+       WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WBI[0] WBI[1] WBI[2]
+       WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5]
+       WT[6] WT[7] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]

*** Jumper Report ***
* Jumper: VDDA[8] VDDP[8] VDDPI[8]

X_mux_lt_seg1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] CKPRCH LOG0 LOG1 PO
+   PO POWINT[0] POWINT[1] PRCHRDB[0] PRCHRDB[1] PRCHRDB[2] PRCHRDB[3]
+   PRCHWRB[0] PRCHWRB[1] PRCHWRB[2] PRCHWRB[3] QB[0] QB[1] QB[2] QB[3] QB[4]
+   QB[5] QB[6] QB[7] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] RB[0]
+   RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RT[0] RT[1] RT[2] RT[3] RT[4]
+   RT[5] RT[6] RT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7]
+   VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBN[0] VBN[1] VBN[2]
+   VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5]
+   VBP[6] VBP[7] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6]
+   VDDA[7] VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1
+   VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VSS[0] VSS[1]
+   VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] WB[0] WB[1] WB[2] WB[3] WB[4]
+   WB[5] WB[6] WB[7] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7]
+   WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WTI[0] WTI[1] WTI[2] WTI[3]
+   WTI[4] WTI[5] WTI[6] WTI[7] SNPS_SP_HD_512x8_mux_lt_seg1
X_mm16a05_u_hdsp_plus_capmux VDDA[8] VDDP[8] VDDPI[8] VSS[8] VBP[8] VBN[8]
+   BOTEDGE LOG0 LOG1 PGIOI PO VBA[8] VEDGE mm16a05_u_hdsp_plus_capmux
.ENDS
.SUBCKT SNPS_SP_HD_512x8_mux_row_1 ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1]
+       ARYSD_BC2[0] ARYSD_BC2[1] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+       BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+       BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+       BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BOTEDGE[0] BOTEDGE[1]
+       BOTEDGE[2] BOTEDGE[3] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7]
+       BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16] BT[17]
+       BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27]
+       BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35] BT[36] BT[37]
+       BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47]
+       BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57]
+       BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BYP_VLOAD CENDP DEF_MODE
+       FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LCGTH[0] LCGTH[1]
+       LCGTH_PCHG LDFTX LITESLP LMATCH LMATCHB LOG0 LOG1 LWEIB LWERD LWEWR
+       LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+       LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6]
+       PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] PGIOI[0]
+       PGIOI[1] PM[0] PM[1] PM[2] PM[3] PRCKE_T QB[0] QB[1] QB[2] QB[3] QB[4]
+       QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15]
+       QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10]
+       QT[11] QT[12] QT[13] QT[14] QT[15] RASSIST[0] RASSIST[1] RASSIST[2]
+       RASSIST[3] RASSISTBH[0] RASSISTBH[1] RASSISTBL[0] RASSISTBL[1] RB[0]
+       RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10] RB[11]
+       RB[12] RB[13] RB[14] RB[15] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1]
+       RMT[2] RMT[3] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8]
+       RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15] RWLB_SAC SEL[0] SEL[1]
+       SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+       SEL[12] SEL[13] SEL[14] SEL[15] T1T TEST_RNMB VBA[0] VBA[1] VBA[2]
+       VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10] VBA[11] VBA[12]
+       VBA[13] VBA[14] VBA[15] VBA[16] VBA[17] VBA[18] VBA[19] VBN[0] VBN[1]
+       VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9] VBN[10] VBN[11]
+       VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20]
+       VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VBP[9]
+       VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18]
+       VBP[19] VBP[20] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6]
+       VDDA[7] VDDA[8] VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14]
+       VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDAIL1 VDDAIR1
+       VDDMINB VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7]
+       VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15]
+       VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDPI[0] VDDPI[1] VDDPI[2]
+       VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+       VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17]
+       VDDPI[18] VDDPI[19] VDDPI[20] VDDWL[0] VDDWL[1] VEDGE[0] VEDGE[1] VSS[0]
+       VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+       VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19]
+       VSS[20] VSSC_WL_L VSSC_WL_R WABUF[0] WABUF[1] WABUF[2] WB[0] WB[1] WB[2]
+       WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13]
+       WB[14] WB[15] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7]
+       WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15] WCLKB[0]
+       WCLKB[1] WCLKB[2] WCLKB[3] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+       WPBUF[2] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9]
+       WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WTI[0] WTI[1] WTI[2] WTI[3]
+       WTI[4] WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12]
+       WTI[13] WTI[14] WTI[15]
X_mux_lt BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31]
+   BOTEDGE[0] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9]
+   BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20]
+   BT[21] BT[22] BT[23] BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31]
+   CKPRCHL LOG0 LOG1 PGIOI[0] PO[0] POWINT[0] POWINT[1] PRCHRDBL[0] PRCHRDBL[1]
+   PRCHRDBL[2] PRCHRDBL[3] PRCHWRBL[0] PRCHWRBL[1] PRCHWRBL[2] PRCHWRBL[3]
+   QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1] QT[2] QT[3]
+   QT[4] QT[5] QT[6] QT[7] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7]
+   RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] SEL[0] SEL[1] SEL[2] SEL[3]
+   SEL[4] SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[0]
+   VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDAIL1
+   VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8]
+   VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+   VDDPI[8] VEDGE[0] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] WB[0] WB[1] WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WBI[0] WBI[1] WBI[2]
+   WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6]
+   WT[7] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_mux_lt
X_mux_cnt ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1]
+   BOTEDGE[1] BOTEDGE[2] BYP_VLOAD CENDP CKPRCHH CKPRCHL DEF_MODE FAST1_MODE
+   FAST2_MODE FLOAT FLOATT FLOAT_RET LCGTH[0] LCGTH[1] LCGTH_PCHG LDFTX LITESLP
+   LMATCH LMATCHB LOG0 LOG1 LWEIB LWERD LWEWR LXADR[0] LXADR[1] LXADR[2]
+   LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1]
+   PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4]
+   PCB[5] PCB[6] PCB[7] PM[0] PM[1] PM[2] PM[3] PO[0] PO[1] PRCHRDBH[0]
+   PRCHRDBH[1] PRCHRDBH[2] PRCHRDBH[3] PRCHRDBL[0] PRCHRDBL[1] PRCHRDBL[2]
+   PRCHRDBL[3] PRCHWRBH[0] PRCHWRBH[1] PRCHWRBH[2] PRCHWRBH[3] PRCHWRBL[0]
+   PRCHWRBL[1] PRCHWRBL[2] PRCHWRBL[3] PRCKE_T RASSIST[0] RASSIST[1] RASSIST[2]
+   RASSIST[3] RASSISTBH[0] RASSISTBH[1] RASSISTBL[0] RASSISTBL[1] RBLRD RBLWA
+   RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB VBA[9]
+   VBA[10] VBN[9] VBN[10] VBN[11] VBP[9] VBP[10] VBP[11] VDDA[9] VDDA[10]
+   VDDA[11] VDDMINB VDDP[9] VDDP[10] VDDP[11] VDDPI[9] VDDPI[10] VDDPI[11]
+   VDDWL[0] VDDWL[1] VSS[9] VSS[10] VSS[11] VSSC_WL_L VSSC_WL_R WABUF[0]
+   WABUF[1] WABUF[2] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] WMT[0] WMT[1] WMT[2]
+   WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] SNPS_SP_HD_512x8_mux_cnt
X_mux_rt BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41]
+   BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52]
+   BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63]
+   BOTEDGE[3] BT[32] BT[33] BT[34] BT[35] BT[36] BT[37] BT[38] BT[39] BT[40]
+   BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51]
+   BT[52] BT[53] BT[54] BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62]
+   BT[63] CKPRCHH LOG0 LOG1 PGIOI[1] PO[1] POWINT[2] POWINT[3] PRCHRDBH[0]
+   PRCHRDBH[1] PRCHRDBH[2] PRCHRDBH[3] PRCHWRBH[0] PRCHWRBH[1] PRCHWRBH[2]
+   PRCHWRBH[3] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QT[8]
+   QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] RB[8] RB[9] RB[10] RB[11]
+   RB[12] RB[13] RB[14] RB[15] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14]
+   RT[15] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] VBA[11]
+   VBA[12] VBA[13] VBA[14] VBA[15] VBA[16] VBA[17] VBA[18] VBA[19] VBN[12]
+   VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20] VBP[12]
+   VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VDDA[12]
+   VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17] VDDA[18] VDDA[19] VDDA[20]
+   VDDAIR1 VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18]
+   VDDP[19] VDDP[20] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16]
+   VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VEDGE[1] VSS[12] VSS[13] VSS[14]
+   VSS[15] VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] WB[8] WB[9] WB[10] WB[11]
+   WB[12] WB[13] WB[14] WB[15] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13]
+   WBI[14] WBI[15] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WTI[8]
+   WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]
+   SNPS_SP_HD_512x8_mux_rt
.ENDS
.SUBCKT SNPS_SP_HD_512x8_ary_lt_seg1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+       BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16]
+       BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26]
+       BT[27] BT[28] BT[29] BT[30] BT[31] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5]
+       QB[6] QB[7] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0]
+       SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2]
+       VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4]
+       VBN[5] VBN[6] VBN[7] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6]
+       VBP[7] VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7]
+       VDDAI[0] VDDAI[1] VDDAI[2] VDDAI[3] VDDAI[4] VDDAI[5] VDDAI[6] VDDAI[7]
+       VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VSS[0]
+       VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] WBI[0] WBI[1] WBI[2]
+       WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[0] WL[1] WL[2] WL[3] WTI[0] WTI[1]
+       WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
X_mm16a05_u_hdsp_plus_ar4x4m4_S0 VDDA[0] VDDAI[0] VDDP[0] VDDPI[0] VSS[0] VBP[0]
+   VBN[0] BB[0] BB[1] BB[2] BB[3] BT[0] BT[1] BT[2] BT[3] QB[0] QT[0] SEL[0]
+   VBA[0] WBI[0] WTI[0] WL[0] WL[1] WL[2] WL[3] mm16a05_u_hdsp_plus_ar4x4m4
X_mm16a05_u_hdsp_plus_ar4x4m4_S1 VDDA[1] VDDAI[1] VDDP[1] VDDPI[1] VSS[1] VBP[1]
+   VBN[1] BB[4] BB[5] BB[6] BB[7] BT[4] BT[5] BT[6] BT[7] QB[1] QT[1] SEL[1]
+   VBA[1] WBI[1] WTI[1] WL[0] WL[1] WL[2] WL[3] mm16a05_u_hdsp_plus_ar4x4m4
X_mm16a05_u_hdsp_plus_ar4x4m4_S2 VDDA[2] VDDAI[2] VDDP[2] VDDPI[2] VSS[2] VBP[2]
+   VBN[2] BB[8] BB[9] BB[10] BB[11] BT[8] BT[9] BT[10] BT[11] QB[2] QT[2]
+   SEL[2] VBA[2] WBI[2] WTI[2] WL[0] WL[1] WL[2] WL[3]
+   mm16a05_u_hdsp_plus_ar4x4m4
X_mm16a05_u_hdsp_plus_ar4x4m4_S3 VDDA[3] VDDAI[3] VDDP[3] VDDPI[3] VSS[3] VBP[3]
+   VBN[3] BB[12] BB[13] BB[14] BB[15] BT[12] BT[13] BT[14] BT[15] QB[3] QT[3]
+   SEL[3] VBA[3] WBI[3] WTI[3] WL[0] WL[1] WL[2] WL[3]
+   mm16a05_u_hdsp_plus_ar4x4m4
X_mm16a05_u_hdsp_plus_ar4x4m4_F3 VDDA[4] VDDAI[4] VDDP[4] VDDPI[4] VSS[4] VBP[4]
+   VBN[4] BB[16] BB[17] BB[18] BB[19] BT[16] BT[17] BT[18] BT[19] QB[4] QT[4]
+   SEL[4] VBA[4] WBI[4] WTI[4] WL[0] WL[1] WL[2] WL[3]
+   mm16a05_u_hdsp_plus_ar4x4m4
X_mm16a05_u_hdsp_plus_ar4x4m4_F2 VDDA[5] VDDAI[5] VDDP[5] VDDPI[5] VSS[5] VBP[5]
+   VBN[5] BB[20] BB[21] BB[22] BB[23] BT[20] BT[21] BT[22] BT[23] QB[5] QT[5]
+   SEL[5] VBA[5] WBI[5] WTI[5] WL[0] WL[1] WL[2] WL[3]
+   mm16a05_u_hdsp_plus_ar4x4m4
X_mm16a05_u_hdsp_plus_ar4x4m4_F1 VDDA[6] VDDAI[6] VDDP[6] VDDPI[6] VSS[6] VBP[6]
+   VBN[6] BB[24] BB[25] BB[26] BB[27] BT[24] BT[25] BT[26] BT[27] QB[6] QT[6]
+   SEL[6] VBA[6] WBI[6] WTI[6] WL[0] WL[1] WL[2] WL[3]
+   mm16a05_u_hdsp_plus_ar4x4m4
X_mm16a05_u_hdsp_plus_ar4x4m4_F0 VDDA[7] VDDAI[7] VDDP[7] VDDPI[7] VSS[7] VBP[7]
+   VBN[7] BB[28] BB[29] BB[30] BB[31] BT[28] BT[29] BT[30] BT[31] QB[7] QT[7]
+   SEL[7] VBA[7] WBI[7] WTI[7] WL[0] WL[1] WL[2] WL[3]
+   mm16a05_u_hdsp_plus_ar4x4m4
.ENDS
.SUBCKT SNPS_SP_HD_512x8_ary_lt BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7]
+       BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17]
+       BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27]
+       BB[28] BB[29] BB[30] BB[31] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6]
+       BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16]
+       BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26]
+       BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB EDGET LOG0 LOG1 PGIOI QB[0]
+       QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1] QT[2] QT[3] QT[4]
+       QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+       SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8]
+       VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+       VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[0] VDDA[1]
+       VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDAIL1 VDDP[0]
+       VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+       VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+       WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[0] WL[1]
+       WL[2] WL[3] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
X_mm16a05_u_hdsp_plus_edge4 VDDA[0] VDDP[0] VDDPI[0] VSS[0] VBP[0] VBN[0] EDGEB
+   EDGET LOG0 LOG1 PGIOI VBA[0] VEDGE WL[0] WL[1] WL[2] WL[3]
+   mm16a05_u_hdsp_plus_edge4
X_ary_lt_seg1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] QB[0] QB[1] QB[2]
+   QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] VBA[1] VBA[2]
+   VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5]
+   VBN[6] VBN[7] VBN[8] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8]
+   VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDAIL1
+   VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDP[1] VDDP[2]
+   VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[1] VDDPI[2] VDDPI[3]
+   VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VSS[1] VSS[2] VSS[3] VSS[4]
+   VSS[5] VSS[6] VSS[7] VSS[8] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+   WBI[7] WL[0] WL[1] WL[2] WL[3] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] SNPS_SP_HD_512x8_ary_lt_seg1
.ENDS
.SUBCKT SNPS_SP_HD_512x8_ary_left_strap BB[0] BB[1] BB[2] BB[3] BB[4] BB[5]
+       BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+       BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16]
+       BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26]
+       BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[0] EDGET[15] LOG0 LOG1 PGIOI
+       QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1] QT[2] QT[3]
+       QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+       SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8]
+       VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+       VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[0] VDDA[1]
+       VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10]
+       VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17] VDDA[18]
+       VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDAIL1 VDDP[0] VDDP[1]
+       VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+       VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+       WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[0] WL[1]
+       WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12]
+       WL[13] WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22]
+       WL[23] WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32]
+       WL[33] WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42]
+       WL[43] WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52]
+       WL[53] WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62]
+       WL[63] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
X_ary_lt_S0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[0] EDGET[0]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[0] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDAIL1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[0] WL[1] WL[2] WL[3]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_lt
X_ary_lt_S1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[1] EDGET[1]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[9] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDAIL1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[4] WL[5] WL[6] WL[7]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_lt
X_ary_lt_S2 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[2] EDGET[2]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[10] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDAIL1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[8] WL[9] WL[10] WL[11]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_lt
X_ary_lt_S3 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[3] EDGET[3]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[11] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDAIL1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[12] WL[13] WL[14] WL[15]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_lt
X_ary_lt_S4 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[4] EDGET[4]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[12] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDAIL1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[16] WL[17] WL[18] WL[19]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_lt
X_ary_lt_S5 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[5] EDGET[5]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[13] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDAIL1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[20] WL[21] WL[22] WL[23]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_lt
X_ary_lt_S6 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[6] EDGET[6]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[14] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDAIL1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[24] WL[25] WL[26] WL[27]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_lt
X_ary_lt_S7 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[7] EDGET[7]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[15] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDAIL1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[28] WL[29] WL[30] WL[31]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_lt
X_ary_lt_F7 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[8] EDGET[8]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[16] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDAIL1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[32] WL[33] WL[34] WL[35]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_lt
X_ary_lt_F6 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[9] EDGET[9]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[17] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDAIL1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[36] WL[37] WL[38] WL[39]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_lt
X_ary_lt_F5 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[10] EDGET[10]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[18] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDAIL1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[40] WL[41] WL[42] WL[43]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_lt
X_ary_lt_F4 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[11] EDGET[11]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[19] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDAIL1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[44] WL[45] WL[46] WL[47]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_lt
X_ary_lt_F3 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[12] EDGET[12]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[20] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDAIL1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[48] WL[49] WL[50] WL[51]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_lt
X_ary_lt_F2 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[13] EDGET[13]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[21] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDAIL1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[52] WL[53] WL[54] WL[55]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_lt
X_ary_lt_F1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[14] EDGET[14]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[22] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDAIL1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[56] WL[57] WL[58] WL[59]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_lt
X_ary_lt_F0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[15] EDGET[15]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[23] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDAIL1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[60] WL[61] WL[62] WL[63]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_lt
.ENDS
.SUBCKT SNPS_SP_HD_512x8_ary_buf_lt_col ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[0]
+       EDGET[15] LCGTH LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1]
+       VBA VBN VBP VDDA VDDP VDDPI VDDWL VSS WL[0] WL[1] WL[2] WL[3] WL[4]
+       WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13] WL[14] WL[15]
+       WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23] WL[24] WL[25]
+       WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33] WL[34] WL[35]
+       WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42] WL[43] WL[44] WL[45]
+       WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53] WL[54] WL[55]
+       WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63] WLB[0] WLB[1]
+       WLB[2] WLB[3] WLB[4] WLB[5] WLB[6] WLB[7] WLB[8] WLB[9] WLB[10] WLB[11]
+       WLB[12] WLB[13] WLB[14] WLB[15] WLB[16] WLB[17] WLB[18] WLB[19] WLB[20]
+       WLB[21] WLB[22] WLB[23] WLB[24] WLB[25] WLB[26] WLB[27] WLB[28] WLB[29]
+       WLB[30] WLB[31] WLB[32] WLB[33] WLB[34] WLB[35] WLB[36] WLB[37] WLB[38]
+       WLB[39] WLB[40] WLB[41] WLB[42] WLB[43] WLB[44] WLB[45] WLB[46] WLB[47]
+       WLB[48] WLB[49] WLB[50] WLB[51] WLB[52] WLB[53] WLB[54] WLB[55] WLB[56]
+       WLB[57] WLB[58] WLB[59] WLB[60] WLB[61] WLB[62] WLB[63]
X_mm16a05_u_hdsp_plus_x4buf_left_S0 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[0]
+   WL[1] WL[2] WL[3] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[0] EDGET[0] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[0] WLB[1] WLB[2]
+   WLB[3] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S1 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[4]
+   WL[5] WL[6] WL[7] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[1] EDGET[1] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[4] WLB[5] WLB[6]
+   WLB[7] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S2 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[8]
+   WL[9] WL[10] WL[11] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[2] EDGET[2] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[8] WLB[9] WLB[10]
+   WLB[11] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S3 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[12]
+   WL[13] WL[14] WL[15] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[3] EDGET[3] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[12] WLB[13]
+   WLB[14] WLB[15] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S4 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[16]
+   WL[17] WL[18] WL[19] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[4] EDGET[4] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[16] WLB[17]
+   WLB[18] WLB[19] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S5 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[20]
+   WL[21] WL[22] WL[23] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[5] EDGET[5] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[20] WLB[21]
+   WLB[22] WLB[23] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S6 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[24]
+   WL[25] WL[26] WL[27] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[6] EDGET[6] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[24] WLB[25]
+   WLB[26] WLB[27] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_S7 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[28]
+   WL[29] WL[30] WL[31] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[7] EDGET[7] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[28] WLB[29]
+   WLB[30] WLB[31] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F7 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[32]
+   WL[33] WL[34] WL[35] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[8] EDGET[8] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[32] WLB[33]
+   WLB[34] WLB[35] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F6 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[36]
+   WL[37] WL[38] WL[39] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[9] EDGET[9] LCGTH LOG0
+   LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[36] WLB[37]
+   WLB[38] WLB[39] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F5 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[40]
+   WL[41] WL[42] WL[43] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[10] EDGET[10] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[40] WLB[41]
+   WLB[42] WLB[43] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F4 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[44]
+   WL[45] WL[46] WL[47] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[11] EDGET[11] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[44] WLB[45]
+   WLB[46] WLB[47] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F3 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[48]
+   WL[49] WL[50] WL[51] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[12] EDGET[12] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[48] WLB[49]
+   WLB[50] WLB[51] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F2 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[52]
+   WL[53] WL[54] WL[55] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[13] EDGET[13] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[52] WLB[53]
+   WLB[54] WLB[55] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F1 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[56]
+   WL[57] WL[58] WL[59] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[14] EDGET[14] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[56] WLB[57]
+   WLB[58] WLB[59] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_left_F0 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[60]
+   WL[61] WL[62] WL[63] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[15] EDGET[15] LCGTH
+   LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[60] WLB[61]
+   WLB[62] WLB[63] mm16a05_u_hdsp_plus_x4buf
.ENDS
.SUBCKT SNPS_SP_HD_512x8_ary_buf_lsh_l ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB EDGET
+       LCGTH LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTBL[0] RASSISTBL[1] VBA VBN
+       VBP VDDA VDDP VDDPI VDDWL VSS WLBL[0] WLBL[1] WLBL[2] WLBL[3] WLBL[4]
+       WLBL[5] WLBL[6] WLBL[7] WLBL[8] WLBL[9] WLBL[10] WLBL[11] WLBL[12]
+       WLBL[13] WLBL[14] WLBL[15] WLBL[16] WLBL[17] WLBL[18] WLBL[19] WLBL[20]
+       WLBL[21] WLBL[22] WLBL[23] WLBL[24] WLBL[25] WLBL[26] WLBL[27] WLBL[28]
+       WLBL[29] WLBL[30] WLBL[31] WLBL[32] WLBL[33] WLBL[34] WLBL[35] WLBL[36]
+       WLBL[37] WLBL[38] WLBL[39] WLBL[40] WLBL[41] WLBL[42] WLBL[43] WLBL[44]
+       WLBL[45] WLBL[46] WLBL[47] WLBL[48] WLBL[49] WLBL[50] WLBL[51] WLBL[52]
+       WLBL[53] WLBL[54] WLBL[55] WLBL[56] WLBL[57] WLBL[58] WLBL[59] WLBL[60]
+       WLBL[61] WLBL[62] WLBL[63] WLL[0] WLL[1] WLL[2] WLL[3] WLL[4] WLL[5]
+       WLL[6] WLL[7] WLL[8] WLL[9] WLL[10] WLL[11] WLL[12] WLL[13] WLL[14]
+       WLL[15] WLL[16] WLL[17] WLL[18] WLL[19] WLL[20] WLL[21] WLL[22] WLL[23]
+       WLL[24] WLL[25] WLL[26] WLL[27] WLL[28] WLL[29] WLL[30] WLL[31] WLL[32]
+       WLL[33] WLL[34] WLL[35] WLL[36] WLL[37] WLL[38] WLL[39] WLL[40] WLL[41]
+       WLL[42] WLL[43] WLL[44] WLL[45] WLL[46] WLL[47] WLL[48] WLL[49] WLL[50]
+       WLL[51] WLL[52] WLL[53] WLL[54] WLL[55] WLL[56] WLL[57] WLL[58] WLL[59]
+       WLL[60] WLL[61] WLL[62] WLL[63]
X_ary_buf_lt_col ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB EDGET LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTBL[0] RASSISTBL[1] VBA VBN VBP VDDA VDDP VDDPI
+   VDDWL VSS WLL[0] WLL[1] WLL[2] WLL[3] WLL[4] WLL[5] WLL[6] WLL[7] WLL[8]
+   WLL[9] WLL[10] WLL[11] WLL[12] WLL[13] WLL[14] WLL[15] WLL[16] WLL[17]
+   WLL[18] WLL[19] WLL[20] WLL[21] WLL[22] WLL[23] WLL[24] WLL[25] WLL[26]
+   WLL[27] WLL[28] WLL[29] WLL[30] WLL[31] WLL[32] WLL[33] WLL[34] WLL[35]
+   WLL[36] WLL[37] WLL[38] WLL[39] WLL[40] WLL[41] WLL[42] WLL[43] WLL[44]
+   WLL[45] WLL[46] WLL[47] WLL[48] WLL[49] WLL[50] WLL[51] WLL[52] WLL[53]
+   WLL[54] WLL[55] WLL[56] WLL[57] WLL[58] WLL[59] WLL[60] WLL[61] WLL[62]
+   WLL[63] WLBL[0] WLBL[1] WLBL[2] WLBL[3] WLBL[4] WLBL[5] WLBL[6] WLBL[7]
+   WLBL[8] WLBL[9] WLBL[10] WLBL[11] WLBL[12] WLBL[13] WLBL[14] WLBL[15]
+   WLBL[16] WLBL[17] WLBL[18] WLBL[19] WLBL[20] WLBL[21] WLBL[22] WLBL[23]
+   WLBL[24] WLBL[25] WLBL[26] WLBL[27] WLBL[28] WLBL[29] WLBL[30] WLBL[31]
+   WLBL[32] WLBL[33] WLBL[34] WLBL[35] WLBL[36] WLBL[37] WLBL[38] WLBL[39]
+   WLBL[40] WLBL[41] WLBL[42] WLBL[43] WLBL[44] WLBL[45] WLBL[46] WLBL[47]
+   WLBL[48] WLBL[49] WLBL[50] WLBL[51] WLBL[52] WLBL[53] WLBL[54] WLBL[55]
+   WLBL[56] WLBL[57] WLBL[58] WLBL[59] WLBL[60] WLBL[61] WLBL[62] WLBL[63]
+   SNPS_SP_HD_512x8_ary_buf_lt_col
.ENDS
.SUBCKT SNPS_SP_HD_512x8_ary_xdec B[0] BYP_VLOAD C[0] CENDP DECH[0] DECH[1]
+       DECH[2] DECH[3] DECH[4] DECH[5] DECH[6] DECH[7] DECH[8] DECH[9] DECH[10]
+       DECH[11] DECH[12] DECH[13] DECH[14] DECH[15] DECL[0] DECL[1] DECL[2]
+       DECL[3] DECL[4] DECL[5] DECL[6] DECL[7] DECL[8] DECL[9] DECL[10]
+       DECL[11] DECL[12] DECL[13] DECL[14] DECL[15] DEF_MODE FAST1_MODE
+       FAST2_MODE FLOAT FLOATT FLOAT_RET LDFTX LITESLP LMATCH[0] LMATCHB LOG0
+       LOG1 LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+       LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4]
+       PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6]
+       PCB[7] RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3]
+       RWLB_SAC T1T TEST_RNMB VBN VBP VDDA VDDMINB VDDP VDDPI VSS VSSC_WL_L
+       VSSC_WL_R WABUF[0] WABUF[1] WABUF[2] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+       WLBH[0] WLBH[1] WLBH[2] WLBH[3] WLBH[4] WLBH[5] WLBH[6] WLBH[7] WLBH[8]
+       WLBH[9] WLBH[10] WLBH[11] WLBH[12] WLBH[13] WLBH[14] WLBH[15] WLBH[16]
+       WLBH[17] WLBH[18] WLBH[19] WLBH[20] WLBH[21] WLBH[22] WLBH[23] WLBH[24]
+       WLBH[25] WLBH[26] WLBH[27] WLBH[28] WLBH[29] WLBH[30] WLBH[31] WLBH[32]
+       WLBH[33] WLBH[34] WLBH[35] WLBH[36] WLBH[37] WLBH[38] WLBH[39] WLBH[40]
+       WLBH[41] WLBH[42] WLBH[43] WLBH[44] WLBH[45] WLBH[46] WLBH[47] WLBH[48]
+       WLBH[49] WLBH[50] WLBH[51] WLBH[52] WLBH[53] WLBH[54] WLBH[55] WLBH[56]
+       WLBH[57] WLBH[58] WLBH[59] WLBH[60] WLBH[61] WLBH[62] WLBH[63] WLBL[0]
+       WLBL[1] WLBL[2] WLBL[3] WLBL[4] WLBL[5] WLBL[6] WLBL[7] WLBL[8] WLBL[9]
+       WLBL[10] WLBL[11] WLBL[12] WLBL[13] WLBL[14] WLBL[15] WLBL[16] WLBL[17]
+       WLBL[18] WLBL[19] WLBL[20] WLBL[21] WLBL[22] WLBL[23] WLBL[24] WLBL[25]
+       WLBL[26] WLBL[27] WLBL[28] WLBL[29] WLBL[30] WLBL[31] WLBL[32] WLBL[33]
+       WLBL[34] WLBL[35] WLBL[36] WLBL[37] WLBL[38] WLBL[39] WLBL[40] WLBL[41]
+       WLBL[42] WLBL[43] WLBL[44] WLBL[45] WLBL[46] WLBL[47] WLBL[48] WLBL[49]
+       WLBL[50] WLBL[51] WLBL[52] WLBL[53] WLBL[54] WLBL[55] WLBL[56] WLBL[57]
+       WLBL[58] WLBL[59] WLBL[60] WLBL[61] WLBL[62] WLBL[63] WMT[0] WMT[1]
+       WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]

*** Jumper Report ***
* Jumper: B[0] PBB[0] B[8]
* Jumper: C[0] PCB[0] C[1] C[2] C[3] C[4] C[5] C[6] C[7]
* Jumper: DECH[0] DECL[0]
* Jumper: DECH[1] DECL[1]
* Jumper: DECH[2] DECL[2]
* Jumper: DECH[3] DECL[3]
* Jumper: DECH[4] DECL[4]
* Jumper: DECH[5] DECL[5]
* Jumper: DECH[6] DECL[6]
* Jumper: DECH[7] DECL[7]
* Jumper: DECH[8] DECL[8]
* Jumper: DECH[9] DECL[9]
* Jumper: DECH[10] DECL[10]
* Jumper: DECH[11] DECL[11]
* Jumper: DECH[12] DECL[12]
* Jumper: DECH[13] DECL[13]
* Jumper: DECH[14] DECL[14]
* Jumper: DECH[15] DECL[15]
* Jumper: PBB[1] B[1] B[9]
* Jumper: PBB[2] B[2] B[10]
* Jumper: PBB[3] B[3] B[11]
* Jumper: PBB[4] B[4] B[12]
* Jumper: PBB[5] B[5] B[13]
* Jumper: PBB[6] B[6] B[14]
* Jumper: PBB[7] B[7] B[15]
* Jumper: PCB[1] C[8] C[9] C[10] C[11] C[12] C[13] C[14] C[15]

X_mm16a05_u_hdsp_plus_x4dec_S0 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[0] WLBH[0] WLBH[1] WLBH[2] WLBH[3] WLBL[0] WLBL[1] WLBL[2]
+   WLBL[3] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET LDFTX
+   LMATCH[0] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT RMT[0]
+   RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2]
+   WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] B[0] C[0] CENDP
+   DECH[0] FLOAT LBKADR[0] LBKADR[1] LBKADR[2] LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S1 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[1] WLBH[4] WLBH[5] WLBH[6] WLBH[7] WLBL[4] WLBL[5] WLBL[6]
+   WLBL[7] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET LDFTX
+   LMATCH[1] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT RMT[0]
+   RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2]
+   WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[1] C[0] CENDP
+   DECH[1] FLOAT LBKADR[0] LBKADR[1] LBKADR[2] LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S2 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[2] WLBH[8] WLBH[9] WLBH[10] WLBH[11] WLBL[8] WLBL[9] WLBL[10]
+   WLBL[11] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET LDFTX
+   LMATCH[2] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT RMT[0]
+   RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1] WABUF[2]
+   WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[2] C[0] CENDP
+   DECH[2] FLOAT LBKADR[0] LBKADR[1] LBKADR[2] LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S3 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[3] WLBH[12] WLBH[13] WLBH[14] WLBH[15] WLBL[12] WLBL[13]
+   WLBL[14] WLBL[15] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[3] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[3] C[0]
+   CENDP DECH[3] FLOAT LBKADR[0] LBKADR[1] LBKADR[2] LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S4 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[4] WLBH[16] WLBH[17] WLBH[18] WLBH[19] WLBL[16] WLBL[17]
+   WLBL[18] WLBL[19] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[4] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[4] C[0]
+   CENDP DECH[4] FLOAT LBKADR[0] LBKADR[1] LBKADR[2] LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S5 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[5] WLBH[20] WLBH[21] WLBH[22] WLBH[23] WLBL[20] WLBL[21]
+   WLBL[22] WLBL[23] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[5] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[5] C[0]
+   CENDP DECH[5] FLOAT LBKADR[0] LBKADR[1] LBKADR[2] LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S6 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[6] WLBH[24] WLBH[25] WLBH[26] WLBH[27] WLBL[24] WLBL[25]
+   WLBL[26] WLBL[27] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[6] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[6] C[0]
+   CENDP DECH[6] FLOAT LBKADR[0] LBKADR[1] LBKADR[2] LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_S7 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[7] WLBH[28] WLBH[29] WLBH[30] WLBH[31] WLBL[28] WLBL[29]
+   WLBL[30] WLBL[31] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[7] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[7] C[0]
+   CENDP DECH[7] FLOAT LBKADR[0] LBKADR[1] LBKADR[2] LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F7 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[8] WLBH[32] WLBH[33] WLBH[34] WLBH[35] WLBL[32] WLBL[33]
+   WLBL[34] WLBL[35] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[8] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] B[0] PCB[1]
+   CENDP DECH[8] FLOAT LBKADR[0] LBKADR[1] LBKADR[2] LITESLP LXADR[0] LXADR[1]
+   LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+   PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2]
+   PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F6 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[9] WLBH[36] WLBH[37] WLBH[38] WLBH[39] WLBL[36] WLBL[37]
+   WLBL[38] WLBL[39] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[9] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[1]
+   PCB[1] CENDP DECH[9] FLOAT LBKADR[0] LBKADR[1] LBKADR[2] LITESLP LXADR[0]
+   LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+   LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0]
+   PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2]
+   WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F5 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[10] WLBH[40] WLBH[41] WLBH[42] WLBH[43] WLBL[40] WLBL[41]
+   WLBL[42] WLBL[43] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[10] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[2]
+   PCB[1] CENDP DECH[10] FLOAT LBKADR[0] LBKADR[1] LBKADR[2] LITESLP LXADR[0]
+   LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+   LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0]
+   PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2]
+   WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F4 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[11] WLBH[44] WLBH[45] WLBH[46] WLBH[47] WLBL[44] WLBL[45]
+   WLBL[46] WLBL[47] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[11] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[3]
+   PCB[1] CENDP DECH[11] FLOAT LBKADR[0] LBKADR[1] LBKADR[2] LITESLP LXADR[0]
+   LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+   LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0]
+   PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2]
+   WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F3 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[12] WLBH[48] WLBH[49] WLBH[50] WLBH[51] WLBL[48] WLBL[49]
+   WLBL[50] WLBL[51] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[12] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[4]
+   PCB[1] CENDP DECH[12] FLOAT LBKADR[0] LBKADR[1] LBKADR[2] LITESLP LXADR[0]
+   LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+   LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0]
+   PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2]
+   WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F2 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[13] WLBH[52] WLBH[53] WLBH[54] WLBH[55] WLBL[52] WLBL[53]
+   WLBL[54] WLBL[55] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[13] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[5]
+   PCB[1] CENDP DECH[13] FLOAT LBKADR[0] LBKADR[1] LBKADR[2] LITESLP LXADR[0]
+   LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+   LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0]
+   PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2]
+   WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F1 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[14] WLBH[56] WLBH[57] WLBH[58] WLBH[59] WLBL[56] WLBL[57]
+   WLBL[58] WLBL[59] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[14] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[6]
+   PCB[1] CENDP DECH[14] FLOAT LBKADR[0] LBKADR[1] LBKADR[2] LITESLP LXADR[0]
+   LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+   LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0]
+   PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2]
+   WCLKB[3] mm16a05_u_hdsp_plus_x4dec
X_mm16a05_u_hdsp_plus_x4dec_F0 VDDA VDDMINB VDDP VDDPI VSSC_WL_L VSSC_WL_R VSS
+   VBP VBN DECL[15] WLBH[60] WLBH[61] WLBH[62] WLBH[63] WLBL[60] WLBL[61]
+   WLBL[62] WLBL[63] BYP_VLOAD DEF_MODE FAST1_MODE FAST2_MODE FLOATT FLOAT_RET
+   LDFTX LMATCH[15] LMATCHB LOG0 LOG1 LWEIB RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] PBB[7]
+   PCB[1] CENDP DECH[15] FLOAT LBKADR[0] LBKADR[1] LBKADR[2] LITESLP LXADR[0]
+   LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+   LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0]
+   PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] WCLKB[0] WCLKB[1] WCLKB[2]
+   WCLKB[3] mm16a05_u_hdsp_plus_x4dec
.ENDS
.SUBCKT SNPS_SP_HD_512x8_ary_buf_col ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[0]
+       EDGET[15] LCGTH LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1]
+       VBA VBN VBP VDDA VDDP VDDPI VDDWL VSS WL[0] WL[1] WL[2] WL[3] WL[4]
+       WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12] WL[13] WL[14] WL[15]
+       WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22] WL[23] WL[24] WL[25]
+       WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32] WL[33] WL[34] WL[35]
+       WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42] WL[43] WL[44] WL[45]
+       WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52] WL[53] WL[54] WL[55]
+       WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62] WL[63] WLB[0] WLB[1]
+       WLB[2] WLB[3] WLB[4] WLB[5] WLB[6] WLB[7] WLB[8] WLB[9] WLB[10] WLB[11]
+       WLB[12] WLB[13] WLB[14] WLB[15] WLB[16] WLB[17] WLB[18] WLB[19] WLB[20]
+       WLB[21] WLB[22] WLB[23] WLB[24] WLB[25] WLB[26] WLB[27] WLB[28] WLB[29]
+       WLB[30] WLB[31] WLB[32] WLB[33] WLB[34] WLB[35] WLB[36] WLB[37] WLB[38]
+       WLB[39] WLB[40] WLB[41] WLB[42] WLB[43] WLB[44] WLB[45] WLB[46] WLB[47]
+       WLB[48] WLB[49] WLB[50] WLB[51] WLB[52] WLB[53] WLB[54] WLB[55] WLB[56]
+       WLB[57] WLB[58] WLB[59] WLB[60] WLB[61] WLB[62] WLB[63]
X_mm16a05_u_hdsp_plus_x4buf_S0 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[0] WL[1]
+   WL[2] WL[3] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[0] EDGET[0] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[0] WLB[1] WLB[2]
+   WLB[3] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S1 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[4] WL[5]
+   WL[6] WL[7] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[1] EDGET[1] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[4] WLB[5] WLB[6]
+   WLB[7] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S2 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[8] WL[9]
+   WL[10] WL[11] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[2] EDGET[2] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[8] WLB[9] WLB[10]
+   WLB[11] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S3 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[12] WL[13]
+   WL[14] WL[15] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[3] EDGET[3] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[12] WLB[13] WLB[14]
+   WLB[15] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S4 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[16] WL[17]
+   WL[18] WL[19] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[4] EDGET[4] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[16] WLB[17] WLB[18]
+   WLB[19] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S5 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[20] WL[21]
+   WL[22] WL[23] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[5] EDGET[5] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[20] WLB[21] WLB[22]
+   WLB[23] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S6 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[24] WL[25]
+   WL[26] WL[27] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[6] EDGET[6] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[24] WLB[25] WLB[26]
+   WLB[27] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_S7 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[28] WL[29]
+   WL[30] WL[31] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[7] EDGET[7] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[28] WLB[29] WLB[30]
+   WLB[31] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F7 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[32] WL[33]
+   WL[34] WL[35] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[8] EDGET[8] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[32] WLB[33] WLB[34]
+   WLB[35] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F6 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[36] WL[37]
+   WL[38] WL[39] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[9] EDGET[9] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[36] WLB[37] WLB[38]
+   WLB[39] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F5 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[40] WL[41]
+   WL[42] WL[43] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[10] EDGET[10] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[40] WLB[41] WLB[42]
+   WLB[43] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F4 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[44] WL[45]
+   WL[46] WL[47] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[11] EDGET[11] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[44] WLB[45] WLB[46]
+   WLB[47] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F3 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[48] WL[49]
+   WL[50] WL[51] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[12] EDGET[12] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[48] WLB[49] WLB[50]
+   WLB[51] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F2 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[52] WL[53]
+   WL[54] WL[55] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[13] EDGET[13] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[52] WLB[53] WLB[54]
+   WLB[55] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F1 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[56] WL[57]
+   WL[58] WL[59] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[14] EDGET[14] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[56] WLB[57] WLB[58]
+   WLB[59] mm16a05_u_hdsp_plus_x4buf
X_mm16a05_u_hdsp_plus_x4buf_F0 VDDWL VDDA VDDP VDDPI VSS VBP VBN WL[60] WL[61]
+   WL[62] WL[63] ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB[15] EDGET[15] LCGTH LOG0 LOG1
+   RASSIST[0] RASSIST[1] RASSISTB[0] RASSISTB[1] VBA WLB[60] WLB[61] WLB[62]
+   WLB[63] mm16a05_u_hdsp_plus_x4buf
.ENDS
.SUBCKT SNPS_SP_HD_512x8_ary_buf_lsh ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB EDGET LCGTH
+       LOG0 LOG1 RASSIST[0] RASSIST[1] RASSISTBH[0] RASSISTBH[1] VBA VBN VBP
+       VDDA VDDP VDDPI VDDWL VSS WLBH[0] WLBH[1] WLBH[2] WLBH[3] WLBH[4]
+       WLBH[5] WLBH[6] WLBH[7] WLBH[8] WLBH[9] WLBH[10] WLBH[11] WLBH[12]
+       WLBH[13] WLBH[14] WLBH[15] WLBH[16] WLBH[17] WLBH[18] WLBH[19] WLBH[20]
+       WLBH[21] WLBH[22] WLBH[23] WLBH[24] WLBH[25] WLBH[26] WLBH[27] WLBH[28]
+       WLBH[29] WLBH[30] WLBH[31] WLBH[32] WLBH[33] WLBH[34] WLBH[35] WLBH[36]
+       WLBH[37] WLBH[38] WLBH[39] WLBH[40] WLBH[41] WLBH[42] WLBH[43] WLBH[44]
+       WLBH[45] WLBH[46] WLBH[47] WLBH[48] WLBH[49] WLBH[50] WLBH[51] WLBH[52]
+       WLBH[53] WLBH[54] WLBH[55] WLBH[56] WLBH[57] WLBH[58] WLBH[59] WLBH[60]
+       WLBH[61] WLBH[62] WLBH[63] WLH[0] WLH[1] WLH[2] WLH[3] WLH[4] WLH[5]
+       WLH[6] WLH[7] WLH[8] WLH[9] WLH[10] WLH[11] WLH[12] WLH[13] WLH[14]
+       WLH[15] WLH[16] WLH[17] WLH[18] WLH[19] WLH[20] WLH[21] WLH[22] WLH[23]
+       WLH[24] WLH[25] WLH[26] WLH[27] WLH[28] WLH[29] WLH[30] WLH[31] WLH[32]
+       WLH[33] WLH[34] WLH[35] WLH[36] WLH[37] WLH[38] WLH[39] WLH[40] WLH[41]
+       WLH[42] WLH[43] WLH[44] WLH[45] WLH[46] WLH[47] WLH[48] WLH[49] WLH[50]
+       WLH[51] WLH[52] WLH[53] WLH[54] WLH[55] WLH[56] WLH[57] WLH[58] WLH[59]
+       WLH[60] WLH[61] WLH[62] WLH[63]
X_ary_buf_col ARYSD ARYSD_BC1 ARYSD_BC2 EDGEB EDGET LCGTH LOG0 LOG1 RASSIST[0]
+   RASSIST[1] RASSISTBH[0] RASSISTBH[1] VBA VBN VBP VDDA VDDP VDDPI VDDWL VSS
+   WLH[0] WLH[1] WLH[2] WLH[3] WLH[4] WLH[5] WLH[6] WLH[7] WLH[8] WLH[9]
+   WLH[10] WLH[11] WLH[12] WLH[13] WLH[14] WLH[15] WLH[16] WLH[17] WLH[18]
+   WLH[19] WLH[20] WLH[21] WLH[22] WLH[23] WLH[24] WLH[25] WLH[26] WLH[27]
+   WLH[28] WLH[29] WLH[30] WLH[31] WLH[32] WLH[33] WLH[34] WLH[35] WLH[36]
+   WLH[37] WLH[38] WLH[39] WLH[40] WLH[41] WLH[42] WLH[43] WLH[44] WLH[45]
+   WLH[46] WLH[47] WLH[48] WLH[49] WLH[50] WLH[51] WLH[52] WLH[53] WLH[54]
+   WLH[55] WLH[56] WLH[57] WLH[58] WLH[59] WLH[60] WLH[61] WLH[62] WLH[63]
+   WLBH[0] WLBH[1] WLBH[2] WLBH[3] WLBH[4] WLBH[5] WLBH[6] WLBH[7] WLBH[8]
+   WLBH[9] WLBH[10] WLBH[11] WLBH[12] WLBH[13] WLBH[14] WLBH[15] WLBH[16]
+   WLBH[17] WLBH[18] WLBH[19] WLBH[20] WLBH[21] WLBH[22] WLBH[23] WLBH[24]
+   WLBH[25] WLBH[26] WLBH[27] WLBH[28] WLBH[29] WLBH[30] WLBH[31] WLBH[32]
+   WLBH[33] WLBH[34] WLBH[35] WLBH[36] WLBH[37] WLBH[38] WLBH[39] WLBH[40]
+   WLBH[41] WLBH[42] WLBH[43] WLBH[44] WLBH[45] WLBH[46] WLBH[47] WLBH[48]
+   WLBH[49] WLBH[50] WLBH[51] WLBH[52] WLBH[53] WLBH[54] WLBH[55] WLBH[56]
+   WLBH[57] WLBH[58] WLBH[59] WLBH[60] WLBH[61] WLBH[62] WLBH[63]
+   SNPS_SP_HD_512x8_ary_buf_col
.ENDS
.SUBCKT SNPS_SP_HD_512x8_ary_cnt ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1]
+       ARYSD_BC2[0] ARYSD_BC2[1] B BYP_VLOAD C CENDP DEF_MODE EDGEB[0] EDGEB[1]
+       EDGET[0] EDGET[1] FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LCGTH[0]
+       LCGTH[1] LDFTX LITESLP LMATCH LMATCHB LOG0[0] LOG0[1] LOG0[2] LOG1[0]
+       LOG1[1] LOG1[2] LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+       LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3]
+       PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5]
+       PCB[6] PCB[7] RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RASSISTBH[0]
+       RASSISTBH[1] RASSISTBL[0] RASSISTBL[1] RBLRD RBLWA RBLWR RBLWR_LOAD
+       RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T TEST_RNMB VBA[0] VBA[1]
+       VBN[0] VBN[1] VBN[2] VBP[0] VBP[1] VBP[2] VDDA[0] VDDA[1] VDDA[2]
+       VDDMINB VDDP[0] VDDP[1] VDDP[2] VDDPI[0] VDDPI[1] VDDPI[2] VDDWL[0]
+       VDDWL[1] VSS[0] VSS[1] VSS[2] VSSC_WL_L VSSC_WL_R WABUF[0] WABUF[1]
+       WABUF[2] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] WLH[0] WLH[1] WLH[2] WLH[3]
+       WLH[4] WLH[5] WLH[6] WLH[7] WLH[8] WLH[9] WLH[10] WLH[11] WLH[12]
+       WLH[13] WLH[14] WLH[15] WLH[16] WLH[17] WLH[18] WLH[19] WLH[20] WLH[21]
+       WLH[22] WLH[23] WLH[24] WLH[25] WLH[26] WLH[27] WLH[28] WLH[29] WLH[30]
+       WLH[31] WLH[32] WLH[33] WLH[34] WLH[35] WLH[36] WLH[37] WLH[38] WLH[39]
+       WLH[40] WLH[41] WLH[42] WLH[43] WLH[44] WLH[45] WLH[46] WLH[47] WLH[48]
+       WLH[49] WLH[50] WLH[51] WLH[52] WLH[53] WLH[54] WLH[55] WLH[56] WLH[57]
+       WLH[58] WLH[59] WLH[60] WLH[61] WLH[62] WLH[63] WLL[0] WLL[1] WLL[2]
+       WLL[3] WLL[4] WLL[5] WLL[6] WLL[7] WLL[8] WLL[9] WLL[10] WLL[11] WLL[12]
+       WLL[13] WLL[14] WLL[15] WLL[16] WLL[17] WLL[18] WLL[19] WLL[20] WLL[21]
+       WLL[22] WLL[23] WLL[24] WLL[25] WLL[26] WLL[27] WLL[28] WLL[29] WLL[30]
+       WLL[31] WLL[32] WLL[33] WLL[34] WLL[35] WLL[36] WLL[37] WLL[38] WLL[39]
+       WLL[40] WLL[41] WLL[42] WLL[43] WLL[44] WLL[45] WLL[46] WLL[47] WLL[48]
+       WLL[49] WLL[50] WLL[51] WLL[52] WLL[53] WLL[54] WLL[55] WLL[56] WLL[57]
+       WLL[58] WLL[59] WLL[60] WLL[61] WLL[62] WLL[63] WMT[0] WMT[1] WMT[2]
+       WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]
X_ary_buf_lsh_l ARYSD[0] ARYSD_BC1[0] ARYSD_BC2[0] EDGEB[0] EDGET[0] LCGTH[0]
+   LOG0[0] LOG1[0] RASSIST[0] RASSIST[1] RASSISTBL[0] RASSISTBL[1] VBA[0]
+   VBN[0] VBP[0] VDDA[0] VDDP[0] VDDPI[0] VDDWL[0] VSS[0] WLBL[0] WLBL[1]
+   WLBL[2] WLBL[3] WLBL[4] WLBL[5] WLBL[6] WLBL[7] WLBL[8] WLBL[9] WLBL[10]
+   WLBL[11] WLBL[12] WLBL[13] WLBL[14] WLBL[15] WLBL[16] WLBL[17] WLBL[18]
+   WLBL[19] WLBL[20] WLBL[21] WLBL[22] WLBL[23] WLBL[24] WLBL[25] WLBL[26]
+   WLBL[27] WLBL[28] WLBL[29] WLBL[30] WLBL[31] WLBL[32] WLBL[33] WLBL[34]
+   WLBL[35] WLBL[36] WLBL[37] WLBL[38] WLBL[39] WLBL[40] WLBL[41] WLBL[42]
+   WLBL[43] WLBL[44] WLBL[45] WLBL[46] WLBL[47] WLBL[48] WLBL[49] WLBL[50]
+   WLBL[51] WLBL[52] WLBL[53] WLBL[54] WLBL[55] WLBL[56] WLBL[57] WLBL[58]
+   WLBL[59] WLBL[60] WLBL[61] WLBL[62] WLBL[63] WLL[0] WLL[1] WLL[2] WLL[3]
+   WLL[4] WLL[5] WLL[6] WLL[7] WLL[8] WLL[9] WLL[10] WLL[11] WLL[12] WLL[13]
+   WLL[14] WLL[15] WLL[16] WLL[17] WLL[18] WLL[19] WLL[20] WLL[21] WLL[22]
+   WLL[23] WLL[24] WLL[25] WLL[26] WLL[27] WLL[28] WLL[29] WLL[30] WLL[31]
+   WLL[32] WLL[33] WLL[34] WLL[35] WLL[36] WLL[37] WLL[38] WLL[39] WLL[40]
+   WLL[41] WLL[42] WLL[43] WLL[44] WLL[45] WLL[46] WLL[47] WLL[48] WLL[49]
+   WLL[50] WLL[51] WLL[52] WLL[53] WLL[54] WLL[55] WLL[56] WLL[57] WLL[58]
+   WLL[59] WLL[60] WLL[61] WLL[62] WLL[63] SNPS_SP_HD_512x8_ary_buf_lsh_l
X_ary_xdec B BYP_VLOAD C CENDP DECH[0] DECH[1] DECH[2] DECH[3] DECH[4] DECH[5]
+   DECH[6] DECH[7] DECH[8] DECH[9] DECH[10] DECH[11] DECH[12] DECH[13] DECH[14]
+   DECH[15] DECH[0] DECH[1] DECH[2] DECH[3] DECH[4] DECH[5] DECH[6] DECH[7]
+   DECH[8] DECH[9] DECH[10] DECH[11] DECH[12] DECH[13] DECH[14] DECH[15]
+   DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LDFTX LITESLP LMATCH
+   LMATCHB LOG0[1] LOG1[1] LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+   LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3]
+   PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6]
+   PCB[7] RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3]
+   RWLB_SAC T1T TEST_RNMB VBN[1] VBP[1] VDDA[1] VDDMINB VDDP[1] VDDPI[1] VSS[1]
+   VSSC_WL_L VSSC_WL_R WABUF[0] WABUF[1] WABUF[2] WCLKB[0] WCLKB[1] WCLKB[2]
+   WCLKB[3] WLBH[0] WLBH[1] WLBH[2] WLBH[3] WLBH[4] WLBH[5] WLBH[6] WLBH[7]
+   WLBH[8] WLBH[9] WLBH[10] WLBH[11] WLBH[12] WLBH[13] WLBH[14] WLBH[15]
+   WLBH[16] WLBH[17] WLBH[18] WLBH[19] WLBH[20] WLBH[21] WLBH[22] WLBH[23]
+   WLBH[24] WLBH[25] WLBH[26] WLBH[27] WLBH[28] WLBH[29] WLBH[30] WLBH[31]
+   WLBH[32] WLBH[33] WLBH[34] WLBH[35] WLBH[36] WLBH[37] WLBH[38] WLBH[39]
+   WLBH[40] WLBH[41] WLBH[42] WLBH[43] WLBH[44] WLBH[45] WLBH[46] WLBH[47]
+   WLBH[48] WLBH[49] WLBH[50] WLBH[51] WLBH[52] WLBH[53] WLBH[54] WLBH[55]
+   WLBH[56] WLBH[57] WLBH[58] WLBH[59] WLBH[60] WLBH[61] WLBH[62] WLBH[63]
+   WLBL[0] WLBL[1] WLBL[2] WLBL[3] WLBL[4] WLBL[5] WLBL[6] WLBL[7] WLBL[8]
+   WLBL[9] WLBL[10] WLBL[11] WLBL[12] WLBL[13] WLBL[14] WLBL[15] WLBL[16]
+   WLBL[17] WLBL[18] WLBL[19] WLBL[20] WLBL[21] WLBL[22] WLBL[23] WLBL[24]
+   WLBL[25] WLBL[26] WLBL[27] WLBL[28] WLBL[29] WLBL[30] WLBL[31] WLBL[32]
+   WLBL[33] WLBL[34] WLBL[35] WLBL[36] WLBL[37] WLBL[38] WLBL[39] WLBL[40]
+   WLBL[41] WLBL[42] WLBL[43] WLBL[44] WLBL[45] WLBL[46] WLBL[47] WLBL[48]
+   WLBL[49] WLBL[50] WLBL[51] WLBL[52] WLBL[53] WLBL[54] WLBL[55] WLBL[56]
+   WLBL[57] WLBL[58] WLBL[59] WLBL[60] WLBL[61] WLBL[62] WLBL[63] WMT[0] WMT[1]
+   WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] SNPS_SP_HD_512x8_ary_xdec
X_ary_buf_lsh ARYSD[1] ARYSD_BC1[1] ARYSD_BC2[1] EDGEB[1] EDGET[1] LCGTH[1]
+   LOG0[2] LOG1[2] RASSIST[2] RASSIST[3] RASSISTBH[0] RASSISTBH[1] VBA[1]
+   VBN[2] VBP[2] VDDA[2] VDDP[2] VDDPI[2] VDDWL[1] VSS[2] WLBH[0] WLBH[1]
+   WLBH[2] WLBH[3] WLBH[4] WLBH[5] WLBH[6] WLBH[7] WLBH[8] WLBH[9] WLBH[10]
+   WLBH[11] WLBH[12] WLBH[13] WLBH[14] WLBH[15] WLBH[16] WLBH[17] WLBH[18]
+   WLBH[19] WLBH[20] WLBH[21] WLBH[22] WLBH[23] WLBH[24] WLBH[25] WLBH[26]
+   WLBH[27] WLBH[28] WLBH[29] WLBH[30] WLBH[31] WLBH[32] WLBH[33] WLBH[34]
+   WLBH[35] WLBH[36] WLBH[37] WLBH[38] WLBH[39] WLBH[40] WLBH[41] WLBH[42]
+   WLBH[43] WLBH[44] WLBH[45] WLBH[46] WLBH[47] WLBH[48] WLBH[49] WLBH[50]
+   WLBH[51] WLBH[52] WLBH[53] WLBH[54] WLBH[55] WLBH[56] WLBH[57] WLBH[58]
+   WLBH[59] WLBH[60] WLBH[61] WLBH[62] WLBH[63] WLH[0] WLH[1] WLH[2] WLH[3]
+   WLH[4] WLH[5] WLH[6] WLH[7] WLH[8] WLH[9] WLH[10] WLH[11] WLH[12] WLH[13]
+   WLH[14] WLH[15] WLH[16] WLH[17] WLH[18] WLH[19] WLH[20] WLH[21] WLH[22]
+   WLH[23] WLH[24] WLH[25] WLH[26] WLH[27] WLH[28] WLH[29] WLH[30] WLH[31]
+   WLH[32] WLH[33] WLH[34] WLH[35] WLH[36] WLH[37] WLH[38] WLH[39] WLH[40]
+   WLH[41] WLH[42] WLH[43] WLH[44] WLH[45] WLH[46] WLH[47] WLH[48] WLH[49]
+   WLH[50] WLH[51] WLH[52] WLH[53] WLH[54] WLH[55] WLH[56] WLH[57] WLH[58]
+   WLH[59] WLH[60] WLH[61] WLH[62] WLH[63] SNPS_SP_HD_512x8_ary_buf_lsh
.ENDS
.SUBCKT SNPS_SP_HD_512x8_ary_rt BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7]
+       BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17]
+       BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27]
+       BB[28] BB[29] BB[30] BB[31] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6]
+       BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16]
+       BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26]
+       BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB EDGET LOG0 LOG1 PGIOI QB[0]
+       QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1] QT[2] QT[3] QT[4]
+       QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+       SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8]
+       VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+       VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[0] VDDA[1]
+       VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDAIR1 VDDP[0]
+       VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+       VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+       WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[0] WL[1]
+       WL[2] WL[3] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
X_ary_lt_seg1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] QB[0] QB[1] QB[2]
+   QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+   QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] VBA[0] VBA[1]
+   VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4]
+   VBN[5] VBN[6] VBN[7] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7]
+   VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDAIR1
+   VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDP[0] VDDP[1]
+   VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDPI[0] VDDPI[1] VDDPI[2]
+   VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VSS[0] VSS[1] VSS[2] VSS[3]
+   VSS[4] VSS[5] VSS[6] VSS[7] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+   WBI[7] WL[0] WL[1] WL[2] WL[3] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+   WTI[6] WTI[7] SNPS_SP_HD_512x8_ary_lt_seg1
X_mm16a05_u_hdsp_plus_edge4 VDDA[8] VDDP[8] VDDPI[8] VSS[8] VBP[8] VBN[8] EDGEB
+   EDGET LOG0 LOG1 PGIOI VBA[8] VEDGE WL[0] WL[1] WL[2] WL[3]
+   mm16a05_u_hdsp_plus_edge4
.ENDS
.SUBCKT SNPS_SP_HD_512x8_ary_right_strap BB[0] BB[1] BB[2] BB[3] BB[4] BB[5]
+       BB[6] BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BT[0] BT[1] BT[2] BT[3] BT[4] BT[5]
+       BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15] BT[16]
+       BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26]
+       BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[0] EDGET[15] LOG0 LOG1 PGIOI
+       QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1] QT[2] QT[3]
+       QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6]
+       SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8]
+       VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+       VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[0] VDDA[1]
+       VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10]
+       VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17] VDDA[18]
+       VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDAIR1 VDDP[0] VDDP[1]
+       VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+       VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8]
+       WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[0] WL[1]
+       WL[2] WL[3] WL[4] WL[5] WL[6] WL[7] WL[8] WL[9] WL[10] WL[11] WL[12]
+       WL[13] WL[14] WL[15] WL[16] WL[17] WL[18] WL[19] WL[20] WL[21] WL[22]
+       WL[23] WL[24] WL[25] WL[26] WL[27] WL[28] WL[29] WL[30] WL[31] WL[32]
+       WL[33] WL[34] WL[35] WL[36] WL[37] WL[38] WL[39] WL[40] WL[41] WL[42]
+       WL[43] WL[44] WL[45] WL[46] WL[47] WL[48] WL[49] WL[50] WL[51] WL[52]
+       WL[53] WL[54] WL[55] WL[56] WL[57] WL[58] WL[59] WL[60] WL[61] WL[62]
+       WL[63] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
X_ary_rt_S0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[0] EDGET[0]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[0] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDAIR1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[0] WL[1] WL[2] WL[3]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_rt
X_ary_rt_S1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[1] EDGET[1]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[0] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[9] VDDAIR1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[4] WL[5] WL[6] WL[7]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_rt
X_ary_rt_S2 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[2] EDGET[2]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[0] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[10] VDDAIR1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[8] WL[9] WL[10] WL[11]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_rt
X_ary_rt_S3 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[3] EDGET[3]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[0] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[11] VDDAIR1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[12] WL[13] WL[14] WL[15]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_rt
X_ary_rt_S4 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[4] EDGET[4]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[0] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[12] VDDAIR1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[16] WL[17] WL[18] WL[19]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_rt
X_ary_rt_S5 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[5] EDGET[5]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[0] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[13] VDDAIR1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[20] WL[21] WL[22] WL[23]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_rt
X_ary_rt_S6 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[6] EDGET[6]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[0] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[14] VDDAIR1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[24] WL[25] WL[26] WL[27]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_rt
X_ary_rt_S7 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[7] EDGET[7]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[0] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[15] VDDAIR1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[28] WL[29] WL[30] WL[31]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_rt
X_ary_rt_F7 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[8] EDGET[8]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[0] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[16] VDDAIR1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[32] WL[33] WL[34] WL[35]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_rt
X_ary_rt_F6 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[9] EDGET[9]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[0] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[17] VDDAIR1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[36] WL[37] WL[38] WL[39]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_rt
X_ary_rt_F5 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[10] EDGET[10]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[0] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[18] VDDAIR1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[40] WL[41] WL[42] WL[43]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_rt
X_ary_rt_F4 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[11] EDGET[11]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[0] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[19] VDDAIR1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[44] WL[45] WL[46] WL[47]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_rt
X_ary_rt_F3 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[12] EDGET[12]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[0] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[20] VDDAIR1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[48] WL[49] WL[50] WL[51]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_rt
X_ary_rt_F2 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[13] EDGET[13]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[0] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[21] VDDAIR1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[52] WL[53] WL[54] WL[55]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_rt
X_ary_rt_F1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[14] EDGET[14]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[0] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[22] VDDAIR1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[56] WL[57] WL[58] WL[59]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_rt
X_ary_rt_F0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[15] EDGET[15]
+   LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1]
+   QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7]
+   VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBP[0]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[0] VDDA[1]
+   VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[23] VDDAIR1 VDDP[0]
+   VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[0]
+   VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+   VEDGE VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0]
+   WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WL[60] WL[61] WL[62] WL[63]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ary_rt
.ENDS
.SUBCKT SNPS_SP_HD_512x8_ary_r1 ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1]
+       ARYSD_BC2[0] ARYSD_BC2[1] B BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+       BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+       BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+       BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1] BT[2] BT[3]
+       BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14]
+       BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+       BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34]
+       BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44]
+       BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54]
+       BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BYP_VLOAD
+       C CENDP DEF_MODE EDGEB[0] EDGEB[1] EDGEB[2] EDGEB[3] EDGET[0] EDGET[1]
+       EDGET[2] EDGET[3] FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LCGTH[0]
+       LCGTH[1] LDFTX LITESLP LMATCH LMATCHB LOG0[0] LOG0[1] LOG0[2] LOG0[3]
+       LOG0[4] LOG1[0] LOG1[1] LOG1[2] LOG1[3] LOG1[4] LWEIB LXADR[0] LXADR[1]
+       LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+       PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1]
+       PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] PGIOI[0] PGIOI[1] QB[0] QB[1]
+       QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12]
+       QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+       QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] RASSIST[0]
+       RASSIST[1] RASSIST[2] RASSIST[3] RASSISTBH[0] RASSISTBH[1] RASSISTBL[0]
+       RASSISTBL[1] RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2]
+       RMT[3] RWLB_SAC SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7]
+       SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] T1T
+       TEST_RNMB VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8]
+       VBA[9] VBA[10] VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16] VBA[17]
+       VBA[18] VBA[19] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7]
+       VBN[8] VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16]
+       VBN[17] VBN[18] VBN[19] VBN[20] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4]
+       VBP[5] VBP[6] VBP[7] VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13]
+       VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VDDA[0] VDDA[1]
+       VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8] VDDA[9] VDDA[10]
+       VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16] VDDA[17] VDDA[18]
+       VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDA[24] VDDA[25] VDDA[26]
+       VDDA[27] VDDA[28] VDDA[29] VDDA[30] VDDA[31] VDDA[32] VDDA[33] VDDA[34]
+       VDDA[35] VDDA[36] VDDA[37] VDDA[38] VDDA[39] VDDA[40] VDDA[41] VDDA[42]
+       VDDA[43] VDDA[44] VDDA[45] VDDA[46] VDDA[47] VDDA[48] VDDA[49] VDDA[50]
+       VDDAIL1 VDDAIR1 VDDMINB VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5]
+       VDDP[6] VDDP[7] VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13]
+       VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8]
+       VDDPI[9] VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15]
+       VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VDDPI[20] VDDWL[0] VDDWL[1]
+       VEDGE[0] VEDGE[1] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6]
+       VSS[7] VSS[8] VSS[9] VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSS[15]
+       VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] VSSC_WL_L VSSC_WL_R WABUF[0]
+       WABUF[1] WABUF[2] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6]
+       WBI[7] WBI[8] WBI[9] WBI[10] WBI[11] WBI[12] WBI[13] WBI[14] WBI[15]
+       WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] WLH[0] WLH[1] WLH[2] WLH[3] WLH[4]
+       WLH[5] WLH[6] WLH[7] WLH[8] WLH[9] WLH[10] WLH[11] WLH[12] WLH[13]
+       WLH[14] WLH[15] WLH[16] WLH[17] WLH[18] WLH[19] WLH[20] WLH[21] WLH[22]
+       WLH[23] WLH[24] WLH[25] WLH[26] WLH[27] WLH[28] WLH[29] WLH[30] WLH[31]
+       WLH[32] WLH[33] WLH[34] WLH[35] WLH[36] WLH[37] WLH[38] WLH[39] WLH[40]
+       WLH[41] WLH[42] WLH[43] WLH[44] WLH[45] WLH[46] WLH[47] WLH[48] WLH[49]
+       WLH[50] WLH[51] WLH[52] WLH[53] WLH[54] WLH[55] WLH[56] WLH[57] WLH[58]
+       WLH[59] WLH[60] WLH[61] WLH[62] WLH[63] WLL[0] WLL[1] WLL[2] WLL[3]
+       WLL[4] WLL[5] WLL[6] WLL[7] WLL[8] WLL[9] WLL[10] WLL[11] WLL[12]
+       WLL[13] WLL[14] WLL[15] WLL[16] WLL[17] WLL[18] WLL[19] WLL[20] WLL[21]
+       WLL[22] WLL[23] WLL[24] WLL[25] WLL[26] WLL[27] WLL[28] WLL[29] WLL[30]
+       WLL[31] WLL[32] WLL[33] WLL[34] WLL[35] WLL[36] WLL[37] WLL[38] WLL[39]
+       WLL[40] WLL[41] WLL[42] WLL[43] WLL[44] WLL[45] WLL[46] WLL[47] WLL[48]
+       WLL[49] WLL[50] WLL[51] WLL[52] WLL[53] WLL[54] WLL[55] WLL[56] WLL[57]
+       WLL[58] WLL[59] WLL[60] WLL[61] WLL[62] WLL[63] WMT[0] WMT[1] WMT[2]
+       WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4]
+       WTI[5] WTI[6] WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13]
+       WTI[14] WTI[15]
X_ary_left_strap BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9]
+   BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20]
+   BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31]
+   BT[0] BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11]
+   BT[12] BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22]
+   BT[23] BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] EDGEB[0]
+   EDGET[0] LOG0[0] LOG1[0] PGIOI[0] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6]
+   QB[7] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7]
+   VBN[8] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8]
+   VDDA[0] VDDA[1] VDDA[2] VDDA[3] VDDA[4] VDDA[5] VDDA[6] VDDA[7] VDDA[8]
+   VDDA[9] VDDA[10] VDDA[11] VDDA[12] VDDA[13] VDDA[14] VDDA[15] VDDA[16]
+   VDDA[17] VDDA[18] VDDA[19] VDDA[20] VDDA[21] VDDA[22] VDDA[23] VDDAIL1
+   VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8]
+   VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7]
+   VDDPI[8] VEDGE[0] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7]
+   VSS[8] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WLL[0] WLL[1]
+   WLL[2] WLL[3] WLL[4] WLL[5] WLL[6] WLL[7] WLL[8] WLL[9] WLL[10] WLL[11]
+   WLL[12] WLL[13] WLL[14] WLL[15] WLL[16] WLL[17] WLL[18] WLL[19] WLL[20]
+   WLL[21] WLL[22] WLL[23] WLL[24] WLL[25] WLL[26] WLL[27] WLL[28] WLL[29]
+   WLL[30] WLL[31] WLL[32] WLL[33] WLL[34] WLL[35] WLL[36] WLL[37] WLL[38]
+   WLL[39] WLL[40] WLL[41] WLL[42] WLL[43] WLL[44] WLL[45] WLL[46] WLL[47]
+   WLL[48] WLL[49] WLL[50] WLL[51] WLL[52] WLL[53] WLL[54] WLL[55] WLL[56]
+   WLL[57] WLL[58] WLL[59] WLL[60] WLL[61] WLL[62] WLL[63] WTI[0] WTI[1] WTI[2]
+   WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] SNPS_SP_HD_512x8_ary_left_strap
X_ary_cnt ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1]
+   B BYP_VLOAD C CENDP DEF_MODE EDGEB[1] EDGEB[2] EDGET[1] EDGET[2] FAST1_MODE
+   FAST2_MODE FLOAT FLOATT FLOAT_RET LCGTH[0] LCGTH[1] LDFTX LITESLP LMATCH
+   LMATCHB LOG0[1] LOG0[2] LOG0[3] LOG1[1] LOG1[2] LOG1[3] LWEIB LXADR[0]
+   LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+   LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0]
+   PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] RASSIST[0] RASSIST[1]
+   RASSIST[2] RASSIST[3] RASSISTBH[0] RASSISTBH[1] RASSISTBL[0] RASSISTBL[1]
+   RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC T1T
+   TEST_RNMB VBA[9] VBA[10] VBN[9] VBN[10] VBN[11] VBP[9] VBP[10] VBP[11]
+   VDDA[24] VDDA[25] VDDA[26] VDDMINB VDDP[9] VDDP[10] VDDP[11] VDDPI[9]
+   VDDPI[10] VDDPI[11] VDDWL[0] VDDWL[1] VSS[9] VSS[10] VSS[11] VSSC_WL_L
+   VSSC_WL_R WABUF[0] WABUF[1] WABUF[2] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   WLH[0] WLH[1] WLH[2] WLH[3] WLH[4] WLH[5] WLH[6] WLH[7] WLH[8] WLH[9]
+   WLH[10] WLH[11] WLH[12] WLH[13] WLH[14] WLH[15] WLH[16] WLH[17] WLH[18]
+   WLH[19] WLH[20] WLH[21] WLH[22] WLH[23] WLH[24] WLH[25] WLH[26] WLH[27]
+   WLH[28] WLH[29] WLH[30] WLH[31] WLH[32] WLH[33] WLH[34] WLH[35] WLH[36]
+   WLH[37] WLH[38] WLH[39] WLH[40] WLH[41] WLH[42] WLH[43] WLH[44] WLH[45]
+   WLH[46] WLH[47] WLH[48] WLH[49] WLH[50] WLH[51] WLH[52] WLH[53] WLH[54]
+   WLH[55] WLH[56] WLH[57] WLH[58] WLH[59] WLH[60] WLH[61] WLH[62] WLH[63]
+   WLL[0] WLL[1] WLL[2] WLL[3] WLL[4] WLL[5] WLL[6] WLL[7] WLL[8] WLL[9]
+   WLL[10] WLL[11] WLL[12] WLL[13] WLL[14] WLL[15] WLL[16] WLL[17] WLL[18]
+   WLL[19] WLL[20] WLL[21] WLL[22] WLL[23] WLL[24] WLL[25] WLL[26] WLL[27]
+   WLL[28] WLL[29] WLL[30] WLL[31] WLL[32] WLL[33] WLL[34] WLL[35] WLL[36]
+   WLL[37] WLL[38] WLL[39] WLL[40] WLL[41] WLL[42] WLL[43] WLL[44] WLL[45]
+   WLL[46] WLL[47] WLL[48] WLL[49] WLL[50] WLL[51] WLL[52] WLL[53] WLL[54]
+   WLL[55] WLL[56] WLL[57] WLL[58] WLL[59] WLL[60] WLL[61] WLL[62] WLL[63]
+   WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]
+   SNPS_SP_HD_512x8_ary_cnt
X_ary_right_strap BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40]
+   BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51]
+   BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62]
+   BB[63] BT[32] BT[33] BT[34] BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41]
+   BT[42] BT[43] BT[44] BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52]
+   BT[53] BT[54] BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63]
+   EDGEB[3] EDGET[3] LOG0[4] LOG1[4] PGIOI[1] QB[8] QB[9] QB[10] QB[11] QB[12]
+   QB[13] QB[14] QB[15] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15]
+   SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] VBA[11]
+   VBA[12] VBA[13] VBA[14] VBA[15] VBA[16] VBA[17] VBA[18] VBA[19] VBN[12]
+   VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18] VBN[19] VBN[20] VBP[12]
+   VBP[13] VBP[14] VBP[15] VBP[16] VBP[17] VBP[18] VBP[19] VBP[20] VDDA[27]
+   VDDA[28] VDDA[29] VDDA[30] VDDA[31] VDDA[32] VDDA[33] VDDA[34] VDDA[35]
+   VDDA[36] VDDA[37] VDDA[38] VDDA[39] VDDA[40] VDDA[41] VDDA[42] VDDA[43]
+   VDDA[44] VDDA[45] VDDA[46] VDDA[47] VDDA[48] VDDA[49] VDDA[50] VDDAIR1
+   VDDP[12] VDDP[13] VDDP[14] VDDP[15] VDDP[16] VDDP[17] VDDP[18] VDDP[19]
+   VDDP[20] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17]
+   VDDPI[18] VDDPI[19] VDDPI[20] VEDGE[1] VSS[12] VSS[13] VSS[14] VSS[15]
+   VSS[16] VSS[17] VSS[18] VSS[19] VSS[20] WBI[8] WBI[9] WBI[10] WBI[11]
+   WBI[12] WBI[13] WBI[14] WBI[15] WLH[0] WLH[1] WLH[2] WLH[3] WLH[4] WLH[5]
+   WLH[6] WLH[7] WLH[8] WLH[9] WLH[10] WLH[11] WLH[12] WLH[13] WLH[14] WLH[15]
+   WLH[16] WLH[17] WLH[18] WLH[19] WLH[20] WLH[21] WLH[22] WLH[23] WLH[24]
+   WLH[25] WLH[26] WLH[27] WLH[28] WLH[29] WLH[30] WLH[31] WLH[32] WLH[33]
+   WLH[34] WLH[35] WLH[36] WLH[37] WLH[38] WLH[39] WLH[40] WLH[41] WLH[42]
+   WLH[43] WLH[44] WLH[45] WLH[46] WLH[47] WLH[48] WLH[49] WLH[50] WLH[51]
+   WLH[52] WLH[53] WLH[54] WLH[55] WLH[56] WLH[57] WLH[58] WLH[59] WLH[60]
+   WLH[61] WLH[62] WLH[63] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13]
+   WTI[14] WTI[15] SNPS_SP_HD_512x8_ary_right_strap
.ENDS
.SUBCKT SNPS_SP_HD_512x8_ary_row_1 ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1]
+       ARYSD_BC2[0] ARYSD_BC2[1] B BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36]
+       BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44] BB[45] BB[46]
+       BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+       BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1] BT[2] BT[3]
+       BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14]
+       BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24]
+       BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34]
+       BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44]
+       BT[45] BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54]
+       BT[55] BT[56] BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BYP_VLOAD
+       C CENDP DEF_MODE EDGEB[0] EDGEB[1] EDGEB[2] EDGEB[3] EDGET[0] EDGET[1]
+       EDGET[2] EDGET[3] FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LCGTH[0]
+       LCGTH[1] LDFTX LITESLP LMATCH LMATCHB LOG0 LOG1 LWEIB LXADR[0] LXADR[1]
+       LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1]
+       PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0] PCB[1]
+       PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] PWDO[0] PWDO[1] QB[0] QB[1]
+       QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12]
+       QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+       QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] RASSIST[0]
+       RASSIST[1] RASSIST[2] RASSIST[3] RASSISTBH[0] RASSISTBH[1] RASSISTBL[0]
+       RASSISTBL[1] RBLRD RBLWA RBLWR RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2]
+       RMT[3] RWLB_SAC SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7]
+       SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] T1T
+       TEST_RNMB VBA VBN VBP VDDA VDDAIL1 VDDAIR1 VDDMINB VDDP VDDPI VDDWL[0]
+       VDDWL[1] VEDGE[0] VEDGE[1] VSS VSSC_WL_L VSSC_WL_R WABUF[0] WABUF[1]
+       WABUF[2] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6]
+       WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13]
+       WB_IN[14] WB_IN[15] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] WLH[0] WLH[1]
+       WLH[2] WLH[3] WLH[4] WLH[5] WLH[6] WLH[7] WLH[8] WLH[9] WLH[10] WLH[11]
+       WLH[12] WLH[13] WLH[14] WLH[15] WLH[16] WLH[17] WLH[18] WLH[19] WLH[20]
+       WLH[21] WLH[22] WLH[23] WLH[24] WLH[25] WLH[26] WLH[27] WLH[28] WLH[29]
+       WLH[30] WLH[31] WLH[32] WLH[33] WLH[34] WLH[35] WLH[36] WLH[37] WLH[38]
+       WLH[39] WLH[40] WLH[41] WLH[42] WLH[43] WLH[44] WLH[45] WLH[46] WLH[47]
+       WLH[48] WLH[49] WLH[50] WLH[51] WLH[52] WLH[53] WLH[54] WLH[55] WLH[56]
+       WLH[57] WLH[58] WLH[59] WLH[60] WLH[61] WLH[62] WLH[63] WLL[0] WLL[1]
+       WLL[2] WLL[3] WLL[4] WLL[5] WLL[6] WLL[7] WLL[8] WLL[9] WLL[10] WLL[11]
+       WLL[12] WLL[13] WLL[14] WLL[15] WLL[16] WLL[17] WLL[18] WLL[19] WLL[20]
+       WLL[21] WLL[22] WLL[23] WLL[24] WLL[25] WLL[26] WLL[27] WLL[28] WLL[29]
+       WLL[30] WLL[31] WLL[32] WLL[33] WLL[34] WLL[35] WLL[36] WLL[37] WLL[38]
+       WLL[39] WLL[40] WLL[41] WLL[42] WLL[43] WLL[44] WLL[45] WLL[46] WLL[47]
+       WLL[48] WLL[49] WLL[50] WLL[51] WLL[52] WLL[53] WLL[54] WLL[55] WLL[56]
+       WLL[57] WLL[58] WLL[59] WLL[60] WLL[61] WLL[62] WLL[63] WMT[0] WMT[1]
+       WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT_IN[0] WT_IN[1] WT_IN[2]
+       WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10]
+       WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15]
X_ary_r1 ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1] B
+   BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11]
+   BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21] BB[22]
+   BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] BB[32] BB[33]
+   BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] BB[44]
+   BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55]
+   BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0] BT[1] BT[2]
+   BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14]
+   BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25]
+   BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35] BT[36]
+   BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47]
+   BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57] BT[58]
+   BT[59] BT[60] BT[61] BT[62] BT[63] BYP_VLOAD C CENDP DEF_MODE EDGEB[0]
+   EDGEB[1] EDGEB[2] EDGEB[3] EDGET[0] EDGET[1] EDGET[2] EDGET[3] FAST1_MODE
+   FAST2_MODE FLOAT FLOATT FLOAT_RET LCGTH[0] LCGTH[1] LDFTX LITESLP LMATCH
+   LMATCHB LOG0 LOG0 LOG0 LOG0 LOG0 LOG1 LOG1 LOG1 LOG1 LOG1 LWEIB LXADR[0]
+   LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+   LYADR[1] PBB[0] PBB[1] PBB[2] PBB[3] PBB[4] PBB[5] PBB[6] PBB[7] PCB[0]
+   PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6] PCB[7] PWDO[0] PWDO[1] QB[0] QB[1]
+   QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13]
+   QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9]
+   QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] RASSIST[0] RASSIST[1] RASSIST[2]
+   RASSIST[3] RASSISTBH[0] RASSISTBH[1] RASSISTBL[0] RASSISTBL[1] RBLRD RBLWA
+   RBLWR RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] T1T TEST_RNMB VBA VBA VBA VBA VBA VBA VBA
+   VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDAIL1 VDDAIR1 VDDMINB VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDWL[0] VDDWL[1]
+   VEDGE[0] VEDGE[1] VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSSC_WL_L VSSC_WL_R WABUF[0] WABUF[1] WABUF[2]
+   WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7]
+   WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14]
+   WB_IN[15] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] WLH[0] WLH[1] WLH[2] WLH[3]
+   WLH[4] WLH[5] WLH[6] WLH[7] WLH[8] WLH[9] WLH[10] WLH[11] WLH[12] WLH[13]
+   WLH[14] WLH[15] WLH[16] WLH[17] WLH[18] WLH[19] WLH[20] WLH[21] WLH[22]
+   WLH[23] WLH[24] WLH[25] WLH[26] WLH[27] WLH[28] WLH[29] WLH[30] WLH[31]
+   WLH[32] WLH[33] WLH[34] WLH[35] WLH[36] WLH[37] WLH[38] WLH[39] WLH[40]
+   WLH[41] WLH[42] WLH[43] WLH[44] WLH[45] WLH[46] WLH[47] WLH[48] WLH[49]
+   WLH[50] WLH[51] WLH[52] WLH[53] WLH[54] WLH[55] WLH[56] WLH[57] WLH[58]
+   WLH[59] WLH[60] WLH[61] WLH[62] WLH[63] WLL[0] WLL[1] WLL[2] WLL[3] WLL[4]
+   WLL[5] WLL[6] WLL[7] WLL[8] WLL[9] WLL[10] WLL[11] WLL[12] WLL[13] WLL[14]
+   WLL[15] WLL[16] WLL[17] WLL[18] WLL[19] WLL[20] WLL[21] WLL[22] WLL[23]
+   WLL[24] WLL[25] WLL[26] WLL[27] WLL[28] WLL[29] WLL[30] WLL[31] WLL[32]
+   WLL[33] WLL[34] WLL[35] WLL[36] WLL[37] WLL[38] WLL[39] WLL[40] WLL[41]
+   WLL[42] WLL[43] WLL[44] WLL[45] WLL[46] WLL[47] WLL[48] WLL[49] WLL[50]
+   WLL[51] WLL[52] WLL[53] WLL[54] WLL[55] WLL[56] WLL[57] WLL[58] WLL[59]
+   WLL[60] WLL[61] WLL[62] WLL[63] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0]
+   WPBUF[1] WPBUF[2] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5]
+   WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13]
+   WT_IN[14] WT_IN[15] SNPS_SP_HD_512x8_ary_r1
.ENDS
.SUBCKT SNPS_SP_HD_512x8_ref_lt_seg1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16]
+       BB[17] BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26]
+       BB[27] BB[28] BB[29] BB[30] BB[31] LLSB LOG0 LOG1 QB[0] QB[1] QB[2]
+       QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6]
+       QT[7] SDB_BC1T SDB_BC2T SDOR SDOR_RET SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+       SEL[5] SEL[6] SEL[7] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+       VBA[7] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBP[0]
+       VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VDDA VDDAI[0] VDDAI[1]
+       VDDAI[2] VDDAI[3] VDDAI[4] VDDAI[5] VDDAI[6] VDDAI[7] VDDP[0] VDDP[1]
+       VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDPI[0] VDDPI[1]
+       VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VSS[0] VSS[1]
+       VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] WBI[0] WBI[1] WBI[2] WBI[3]
+       WBI[4] WBI[5] WBI[6] WBI[7] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5]
+       WTI[6] WTI[7]

*** Jumper Report ***
* Jumper: VBA[0] VSS[0]
* Jumper: VBA[1] VSS[1]
* Jumper: VBA[2] VSS[2]
* Jumper: VBA[3] VSS[3]
* Jumper: VBA[4] VSS[4]
* Jumper: VBA[5] VSS[5]
* Jumper: VBA[6] VSS[6]
* Jumper: VBA[7] VSS[7]
* Jumper: VDDA VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7]

X_mm16a05_u_hdsp_plus_rar4x1_top_S0 VDDA VDDAI[0] VDDP[0] VDDPI[0] VSS[0] VBP[0]
+   VBN[0] BB[0] BB[1] BB[2] BB[3] LOG0 LOG1 QB[0] QT[0] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[0] VBA[0] WBI[0] WTI[0] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_S1 VDDA VDDAI[1] VDDP[1] VDDPI[1] VSS[1] VBP[1]
+   VBN[1] BB[4] BB[5] BB[6] BB[7] LOG0 LOG1 QB[1] QT[1] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[1] VBA[1] WBI[1] WTI[1] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_S2 VDDA VDDAI[2] VDDP[2] VDDPI[2] VSS[2] VBP[2]
+   VBN[2] BB[8] BB[9] BB[10] BB[11] LOG0 LOG1 QB[2] QT[2] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[2] VBA[2] WBI[2] WTI[2] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_S3 VDDA VDDAI[3] VDDP[3] VDDPI[3] VSS[3] VBP[3]
+   VBN[3] BB[12] BB[13] BB[14] BB[15] LOG0 LOG1 QB[3] QT[3] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[3] VBA[3] WBI[3] WTI[3] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_F3 VDDA VDDAI[4] VDDP[4] VDDPI[4] VSS[4] VBP[4]
+   VBN[4] BB[16] BB[17] BB[18] BB[19] LOG0 LOG1 QB[4] QT[4] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[4] VBA[4] WBI[4] WTI[4] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_F2 VDDA VDDAI[5] VDDP[5] VDDPI[5] VSS[5] VBP[5]
+   VBN[5] BB[20] BB[21] BB[22] BB[23] LOG0 LOG1 QB[5] QT[5] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[5] VBA[5] WBI[5] WTI[5] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_F1 VDDA VDDAI[6] VDDP[6] VDDPI[6] VSS[6] VBP[6]
+   VBN[6] BB[24] BB[25] BB[26] BB[27] LOG0 LOG1 QB[6] QT[6] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[6] VBA[6] WBI[6] WTI[6] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_F0 VDDA VDDAI[7] VDDP[7] VDDPI[7] VSS[7] VBP[7]
+   VBN[7] BB[28] BB[29] BB[30] BB[31] LOG0 LOG1 QB[7] QT[7] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[7] VBA[7] WBI[7] WTI[7] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
.ENDS
.SUBCKT SNPS_SP_HD_512x8_ref_lt BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7]
+       BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17]
+       BB[18] BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27]
+       BB[28] BB[29] BB[30] BB[31] LLSB LOG0 LOG1 PGIOI QB[0] QB[1] QB[2] QB[3]
+       QB[4] QB[5] QB[6] QB[7] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+       SDB_BC1T SDB_BC2T SDOR SDOR_RET SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+       SEL[5] SEL[6] SEL[7] TOPEDGE VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+       VBA[6] VBA[7] VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6]
+       VBN[7] VBN[8] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7]
+       VBP[8] VDDA VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5]
+       VDDP[6] VDDP[7] VDDP[8] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+       VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VEDGE VSS[0] VSS[1] VSS[2] VSS[3]
+       VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4]
+       WBI[5] WBI[6] WBI[7] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+       WTI[7]

*** Jumper Report ***
* Jumper: LOG1 PGIOI

X_mm16a05_u_hdsp_plus_pg_pwedge_top VDDA VDDP[0] VDDPI[0] VSS[0] VBP[0] VBN[0]
+   LOG0 LOG1 PGIOI PO SDOR_RET TOPEDGE VBA[0] VEDGE SDOR
+   mm16a05_u_hdsp_plus_pg_pwedge
X_ref_lt_seg1 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31] LLSB
+   LOG0 LOG1 QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QT[0] QT[1] QT[2]
+   QT[3] QT[4] QT[5] QT[6] QT[7] SDB_BC1T SDB_BC2T SDOR SDOR_RET SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5]
+   VBA[6] VBA[7] VBA[8] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA VDDAIL1 VDDAIL1
+   VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDAIL1 VDDP[1] VDDP[2] VDDP[3]
+   VDDP[4] VDDP[5] VDDP[6] VDDP[7] VDDP[8] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4]
+   VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5]
+   VSS[6] VSS[7] VSS[8] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7]
+   WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7]
+   SNPS_SP_HD_512x8_ref_lt_seg1
.ENDS
.SUBCKT SNPS_SP_HD_512x8_ref_cnt ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+       ARYSD_BC2[1] ARYSD_IN[0] ARYSD_IN[1] ARYSD_TOP[0] ARYSD_TOP[1] CENDP
+       DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET FLOAT_RET_PROG
+       LCGTH[0] LCGTH[1] LDFTX LITESLP LLBKADRB[0] LLBKADRB[1] LLSB[0] LLSB[1]
+       LMATCHB LMATCHB_I LOG0[0] LOG0[1] LOG0[2] LOG0[3] LOG1[0] LOG1[1] LWEIB
+       LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+       LYADR[0] LYADR[1] PLBKADR[0] PLBKADR[1] RASSIST[0] RASSIST[1] RASSIST[2]
+       RASSIST[3] RASSISTBH[0] RASSISTBH[1] RASSISTBL[0] RASSISTBL[1] RBLRD
+       RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC RWLD_RD RWLD_WR
+       RWL_DLY_0 RWL_DLY_2 RWL_DLY_4 RWL_DLY_RD_PGM RWL_DLY_WR_PGM RWL_RD[1]
+       RWL_RWLD_AND RWL_RWLD_AND_WR RWL_WR[1] SDB_BC1T[0] SDB_BC1T[1]
+       SDB_BC2T[0] SDB_BC2T[1] SDOR[0] SDOR[1] SDOR_RET[0] SDOR_RET[1] T1T
+       TEST_RNMB TOPEDGE[0] TOPEDGE[1] VBA[0] VBA[1] VBN[0] VBN[1] VBN[2]
+       VBP[0] VBP[1] VBP[2] VDDA[0] VDDA[1] VDDA[2] VDDMINB VDDP[0] VDDP[1]
+       VDDP[2] VDDPI[0] VDDPI[1] VDDPI[2] VDDWL[0] VDDWL[1] VSS[0] VSS[1]
+       VSS[2] VSSC_WL_L VSSC_WL_R WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1]
+       WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]

*** Jumper Report ***
* Jumper: FLOAT_RET_PROG LOG1[1]
* Jumper: LLBKADRB[0] PLBKADR[0]
* Jumper: LLBKADRB[1] PLBKADR[1]
* Jumper: LMATCHB LMATCHB_I
* Jumper: LOG0[3] LBKADR[0] LBKADR[1] LBKADR[2]
* Jumper: RWLB_RD[1] RWLHVBRD
* Jumper: RWLB_WR[1] RWLHVBWR
* Jumper: RWL_DLY_0 RWL_DLY_RD_PGM RWL_DLY_WR_PGM
* Jumper: VDDA[0] VDDP[0]
* Jumper: VDDA[1] VDDP[1] VDDPI[1]
* Jumper: VDDA[2] VDDP[2]

X_mm16a05_u_hdsp_plus_rwbuf_top_left VDDA[0] VDDP[0] VDDPI[0] VDDWL[0] VSS[0]
+   VBP[0] VBN[0] SDB_BC1T[0] SDB_BC2T[0] ARYSD_TOP[0] LLSB[0] RWL_RD[0]
+   RWL_WR[0] SDOR[0] LOG0[0] LOG1[0] PO[0] RASSIST[0] RASSIST[1] RASSISTBL[0]
+   RASSISTBL[1] LOG0[1] LOG0[2] TOPEDGE[0] VBA[0] ARYSD_BC1[0] ARYSD_BC2[0]
+   ARYSD_IN[0] LCGTH[0] RWLB_RD[0] RWLB_WR[0] SDOR_RET[0]
+   mm16a05_u_hdsp_plus_rwbuf_left
X_mm16a05_u_hdsp_plus_rw_top VDDMINB VDDA[1] VDDP[1] VDDPI[1] VSS[1] VSSC_WL_L
+   VSSC_WL_R VBP[1] VBN[1] RWLB_RD[1] RWLB_WR[1] RWL_DLY_0 RWL_DLY_2 RWL_DLY_4
+   RWL_RWLD_AND RWL_RWLD_AND_WR CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT_RET
+   FLOAT_RET_PROG LOG0[3] LOG0[3] LOG0[3] LCGTHB LDFTX LITESLP LLBKADRB[0]
+   LLBKADRB[1] LMATCHB LMATCHB_I LOG0[3] LOG1[1] LXADR[0] LXADR[1] LXADR[2]
+   LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PLBKADR[0]
+   PLBKADR[1] RBLRD RBLWA RBLWR RM3CNT RWLB_SAC T1T TEST_RNMB WABUF[0] WABUF[1]
+   WABUF[2] WPBUF[0] WPBUF[1] WPBUF[2] FLOAT FLOATT LWEIB RMT[0] RMT[1] RMT[2]
+   RMT[3] RWLD_RD RWLD_WR RWLB_RD[1] RWLB_WR[1] RWL_DLY_RD_PGM RWL_DLY_WR_PGM
+   WMT[0] WMT[1] WMT[2] WMT[3] mm16a05_u_hdsp_plus_rw_gf22
X_mm16a05_u_hdsp_plus_rwbuf_top VDDA[2] VDDP[2] VDDPI[2] VDDWL[1] VSS[2] VBP[2]
+   VBN[2] SDB_BC1T[1] SDB_BC2T[1] ARYSD_TOP[1] LLSB[1] RWL_RD[1] RWL_WR[1]
+   SDOR[1] LCGTHB LOG0[3] LOG1[1] PO[1] RASSIST[2] RASSIST[3] RASSISTBH[0]
+   RASSISTBH[1] RWLD_RD RWLD_WR TOPEDGE[1] VBA[1] ARYSD_BC1[1] ARYSD_BC2[1]
+   ARYSD_IN[1] LCGTH[1] RWLB_RD[1] RWLB_WR[1] SDOR_RET[1]
+   mm16a05_u_hdsp_plus_rwbuf
.ENDS
.SUBCKT SNPS_SP_HD_512x8_ref_rt_rwl BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] LLSB LOG0 LOG1 QB[0] QB[1] QB[2] QT[0]
+       QT[1] QT[2] RWLD_RD RWLD_WR RWL_RD RWL_WR SDB_BC1T SDB_BC2T SDOR
+       SDOR_RET SEL[0] SEL[1] SEL[2] VBA[0] VBA[1] VBA[2] VBN[0] VBN[1] VBN[2]
+       VBP[0] VBP[1] VBP[2] VDDA VDDAI[0] VDDAI[1] VDDAI[2] VDDP[0] VDDP[1]
+       VDDP[2] VDDPI[0] VDDPI[1] VDDPI[2] VSS[0] VSS[1] VSS[2] WBI[0] WBI[1]
+       WBI[2] WTI[0] WTI[1] WTI[2]

*** Jumper Report ***
* Jumper: VBA[0] VSS[0]
* Jumper: VBA[1] VSS[1]
* Jumper: VBA[2] VSS[2]
* Jumper: VDDA VDDP[0] VDDP[1] VDDP[2]

X_mm16a05_u_hdsp_plus_rar4x1_top_S0 VDDA VDDAI[0] VDDP[0] VDDPI[0] VSS[0] VBP[0]
+   VBN[0] BB[0] BB[1] BB[2] BB[3] LOG0 LOG1 QB[0] QT[0] RWLD_RD RWLD_WR RWL_RD
+   RWL_WR SDOR SDOR_RET SEL[0] VBA[0] WBI[0] WTI[0] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_F1 VDDA VDDAI[1] VDDP[1] VDDPI[1] VSS[1] VBP[1]
+   VBN[1] BB[4] BB[5] BB[6] BB[7] LOG0 LOG1 QB[1] QT[1] RWLD_RD RWLD_WR RWL_RD
+   RWL_WR SDOR SDOR_RET SEL[1] VBA[1] WBI[1] WTI[1] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_F0 VDDA VDDAI[2] VDDP[2] VDDPI[2] VSS[2] VBP[2]
+   VBN[2] BB[8] BB[9] BB[10] BB[11] LOG0 LOG1 QB[2] QT[2] RWLD_RD RWLD_WR
+   RWL_RD RWL_WR SDOR SDOR_RET SEL[2] VBA[2] WBI[2] WTI[2] LLSB SDB_BC1T
+   SDB_BC2T mm16a05_u_hdsp_plus_rar4x1
.ENDS
.SUBCKT SNPS_SP_HD_512x8_ref_cnt_rt_rwl ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+       ARYSD_BC2[1] ARYSD_IN[0] ARYSD_IN[1] ARYSD_TOP[0] ARYSD_TOP[1] BB[0]
+       BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11]
+       CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET
+       FLOAT_RET_PROG LCGTH[0] LCGTH[1] LDFTX LITESLP LLBKADRB[0] LLBKADRB[1]
+       LLSB[0] LLSB[1] LMATCHB LMATCHB_I LOG0[0] LOG0[1] LOG0[2] LOG0[3]
+       LOG1[0] LOG1[1] LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+       LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PLBKADR[0] PLBKADR[1] QB[0]
+       QB[1] QB[2] QT[0] QT[1] QT[2] RASSIST[0] RASSIST[1] RASSIST[2]
+       RASSIST[3] RASSISTBH[0] RASSISTBH[1] RASSISTBL[0] RASSISTBL[1] RBLRD
+       RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC RWLD_RD RWLD_WR
+       RWL_DLY_0 RWL_DLY_2 RWL_DLY_4 RWL_DLY_RD_PGM RWL_DLY_WR_PGM RWL_RD
+       RWL_RWLD_AND RWL_RWLD_AND_WR RWL_WR SDB_BC1T[0] SDB_BC1T[1] SDB_BC2T[0]
+       SDB_BC2T[1] SDOR[0] SDOR[1] SDOR_RET[0] SDOR_RET[1] SEL[0] SEL[1] SEL[2]
+       T1T TEST_RNMB TOPEDGE[0] TOPEDGE[1] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4]
+       VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBP[0] VBP[1] VBP[2] VBP[3]
+       VBP[4] VBP[5] VDDA[0] VDDA[1] VDDA[2] VDDAI[0] VDDAI[1] VDDAI[2] VDDMINB
+       VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDPI[0] VDDPI[1]
+       VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDWL[0] VDDWL[1] VSS[0] VSS[1]
+       VSS[2] VSS[3] VSS[4] VSS[5] VSSC_WL_L VSSC_WL_R WABUF[0] WABUF[1]
+       WABUF[2] WBI[0] WBI[1] WBI[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0]
+       WPBUF[1] WPBUF[2] WTI[0] WTI[1] WTI[2]
X_ref_cnt ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1] ARYSD_IN[0]
+   ARYSD_IN[1] ARYSD_TOP[0] ARYSD_TOP[1] CENDP DEF_MODE FAST1_MODE FAST2_MODE
+   FLOAT FLOATT FLOAT_RET FLOAT_RET_PROG LCGTH[0] LCGTH[1] LDFTX LITESLP
+   LLBKADRB[0] LLBKADRB[1] LLSB[0] LLSB[1] LMATCHB LMATCHB_I LOG0[0] LOG0[1]
+   LOG0[2] LOG0[3] LOG1[0] LOG1[1] LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3]
+   LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PLBKADR[0] PLBKADR[1]
+   RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RASSISTBH[0] RASSISTBH[1]
+   RASSISTBL[0] RASSISTBL[1] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2]
+   RMT[3] RWLB_SAC RWLD_RD RWLD_WR RWL_DLY_0 RWL_DLY_2 RWL_DLY_4 RWL_DLY_RD_PGM
+   RWL_DLY_WR_PGM RWL_RD RWL_RWLD_AND RWL_RWLD_AND_WR RWL_WR SDB_BC1T[0]
+   SDB_BC1T[1] SDB_BC2T[0] SDB_BC2T[1] SDOR[0] SDOR[1] SDOR_RET[0] SDOR_RET[1]
+   T1T TEST_RNMB TOPEDGE[0] TOPEDGE[1] VBA[0] VBA[1] VBN[0] VBN[1] VBN[2]
+   VBP[0] VBP[1] VBP[2] VDDA[0] VDDA[1] VDDA[2] VDDMINB VDDP[0] VDDP[1] VDDP[2]
+   VDDPI[0] VDDPI[1] VDDPI[2] VDDWL[0] VDDWL[1] VSS[0] VSS[1] VSS[2] VSSC_WL_L
+   VSSC_WL_R WABUF[0] WABUF[1] WABUF[2] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0]
+   WPBUF[1] WPBUF[2] SNPS_SP_HD_512x8_ref_cnt
X_ref_rt_rwl BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] LLSB[1] LOG0[3] LOG1[1] QB[0] QB[1] QB[2] QT[0] QT[1] QT[2] RWLD_RD
+   RWLD_WR RWL_RD RWL_WR SDB_BC1T[1] SDB_BC2T[1] SDOR[1] SDOR_RET[1] SEL[0]
+   SEL[1] SEL[2] VBA[2] VBA[3] VBA[4] VBN[3] VBN[4] VBN[5] VBP[3] VBP[4] VBP[5]
+   VDDA[2] VDDAI[0] VDDAI[1] VDDAI[2] VDDP[3] VDDP[4] VDDP[5] VDDPI[3] VDDPI[4]
+   VDDPI[5] VSS[3] VSS[4] VSS[5] WBI[0] WBI[1] WBI[2] WTI[0] WTI[1] WTI[2]
+   SNPS_SP_HD_512x8_ref_rt_rwl
.ENDS
.SUBCKT SNPS_SP_HD_512x8_ref_rt_log0 BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6]
+       BB[7] BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] LLSB LOG0
+       LOG1 QB[0] QB[1] QB[2] QB[3] QT[0] QT[1] QT[2] QT[3] SDB_BC1T SDB_BC2T
+       SDOR SDOR_RET SEL[0] SEL[1] SEL[2] SEL[3] VBA[0] VBA[1] VBA[2] VBA[3]
+       VBN[0] VBN[1] VBN[2] VBN[3] VBP[0] VBP[1] VBP[2] VBP[3] VDDA VDDAI[0]
+       VDDAI[1] VDDAI[2] VDDAI[3] VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDPI[0]
+       VDDPI[1] VDDPI[2] VDDPI[3] VSS[0] VSS[1] VSS[2] VSS[3] WBI[0] WBI[1]
+       WBI[2] WBI[3] WTI[0] WTI[1] WTI[2] WTI[3]

*** Jumper Report ***
* Jumper: VBA[0] VSS[0]
* Jumper: VBA[1] VSS[1]
* Jumper: VBA[2] VSS[2]
* Jumper: VBA[3] VSS[3]
* Jumper: VDDA VDDP[0] VDDP[1] VDDP[2] VDDP[3]

X_mm16a05_u_hdsp_plus_rar4x1_top_S0 VDDA VDDAI[0] VDDP[0] VDDPI[0] VSS[0] VBP[0]
+   VBN[0] BB[0] BB[1] BB[2] BB[3] LOG0 LOG1 QB[0] QT[0] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[0] VBA[0] WBI[0] WTI[0] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_S1 VDDA VDDAI[1] VDDP[1] VDDPI[1] VSS[1] VBP[1]
+   VBN[1] BB[4] BB[5] BB[6] BB[7] LOG0 LOG1 QB[1] QT[1] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[1] VBA[1] WBI[1] WTI[1] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_F1 VDDA VDDAI[2] VDDP[2] VDDPI[2] VSS[2] VBP[2]
+   VBN[2] BB[8] BB[9] BB[10] BB[11] LOG0 LOG1 QB[2] QT[2] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[2] VBA[2] WBI[2] WTI[2] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
X_mm16a05_u_hdsp_plus_rar4x1_top_F0 VDDA VDDAI[3] VDDP[3] VDDPI[3] VSS[3] VBP[3]
+   VBN[3] BB[12] BB[13] BB[14] BB[15] LOG0 LOG1 QB[3] QT[3] LOG0 LOG0 LOG0 LOG0
+   SDOR SDOR_RET SEL[3] VBA[3] WBI[3] WTI[3] LLSB SDB_BC1T SDB_BC2T
+   mm16a05_u_hdsp_plus_rar4x1
.ENDS
.SUBCKT SNPS_SP_HD_512x8_ref_row_1 ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+       ARYSD_BC2[1] ARYSD_IN[0] ARYSD_IN[1] ARYSD_TOP[0] ARYSD_TOP[1] BB[0]
+       BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10] BB[11]
+       BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+       BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31]
+       BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41]
+       BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51]
+       BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61]
+       BB[62] BB[63] CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT
+       FLOAT_RET FLOAT_RET_PROG LCGTH[0] LCGTH[1] LDFTX LITESLP LLBKADRB[0]
+       LLBKADRB[1] LMATCHB LMATCHB_I LOG0[0] LOG0[1] LOG1[0] LOG1[1] LWEIB
+       LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+       LYADR[0] LYADR[1] PGIOI[0] PGIOI[1] PLBKADR[0] PLBKADR[1] QB[0] QB[1]
+       QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12]
+       QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7]
+       QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] RASSIST[0]
+       RASSIST[1] RASSIST[2] RASSIST[3] RASSISTBH[0] RASSISTBH[1] RASSISTBL[0]
+       RASSISTBL[1] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3]
+       RWLB_SAC RWL_DLY_0 RWL_DLY_2 RWL_DLY_4 RWL_DLY_RD_PGM RWL_DLY_WR_PGM
+       RWL_RWLD_AND RWL_RWLD_AND_WR SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5]
+       SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14]
+       SEL[15] T1T TEST_RNMB TOPEDGE[0] TOPEDGE[1] TOPEDGE[2] TOPEDGE[3] VBA[0]
+       VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6] VBA[7] VBA[8] VBA[9] VBA[10]
+       VBA[11] VBA[12] VBA[13] VBA[14] VBA[15] VBA[16] VBA[17] VBA[18] VBA[19]
+       VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8] VBN[9]
+       VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBN[15] VBN[16] VBN[17] VBN[18]
+       VBN[19] VBN[20] VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7]
+       VBP[8] VBP[9] VBP[10] VBP[11] VBP[12] VBP[13] VBP[14] VBP[15] VBP[16]
+       VBP[17] VBP[18] VBP[19] VBP[20] VDDA[0] VDDA[1] VDDA[2] VDDAIL1 VDDAIR1
+       VDDMINB VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7]
+       VDDP[8] VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDP[15]
+       VDDP[16] VDDP[17] VDDP[18] VDDP[19] VDDP[20] VDDPI[0] VDDPI[1] VDDPI[2]
+       VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6] VDDPI[7] VDDPI[8] VDDPI[9] VDDPI[10]
+       VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDPI[15] VDDPI[16] VDDPI[17]
+       VDDPI[18] VDDPI[19] VDDPI[20] VDDWL[0] VDDWL[1] VEDGE[0] VEDGE[1] VSS[0]
+       VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6] VSS[7] VSS[8] VSS[9] VSS[10]
+       VSS[11] VSS[12] VSS[13] VSS[14] VSS[15] VSS[16] VSS[17] VSS[18] VSS[19]
+       VSS[20] VSSC_WL_L VSSC_WL_R WABUF[0] WABUF[1] WABUF[2] WBI[0] WBI[1]
+       WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WBI[8] WBI[9] WBI[10] WBI[11]
+       WBI[12] WBI[13] WBI[14] WBI[15] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0]
+       WPBUF[1] WPBUF[2] WTI[0] WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6]
+       WTI[7] WTI[8] WTI[9] WTI[10] WTI[11] WTI[12] WTI[13] WTI[14] WTI[15]

*** Jumper Report ***
* Jumper: LOG1[1] PGIOI[1]
* Jumper: VBA[14] VSS[15]
* Jumper: VDDA[2] VDDP[15]

X_ref_lt BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9] BB[10]
+   BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20] BB[21]
+   BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31]
+   LLSB[0] LOG0[0] LOG1[0] PGIOI[0] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6]
+   QB[7] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] SDB_BC1T[0]
+   SDB_BC2T[0] SDOR[0] SDOR_RET[0] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5]
+   SEL[6] SEL[7] TOPEDGE[0] VBA[0] VBA[1] VBA[2] VBA[3] VBA[4] VBA[5] VBA[6]
+   VBA[7] VBA[8] VBN[0] VBN[1] VBN[2] VBN[3] VBN[4] VBN[5] VBN[6] VBN[7] VBN[8]
+   VBP[0] VBP[1] VBP[2] VBP[3] VBP[4] VBP[5] VBP[6] VBP[7] VBP[8] VDDA[0]
+   VDDAIL1 VDDP[0] VDDP[1] VDDP[2] VDDP[3] VDDP[4] VDDP[5] VDDP[6] VDDP[7]
+   VDDP[8] VDDPI[0] VDDPI[1] VDDPI[2] VDDPI[3] VDDPI[4] VDDPI[5] VDDPI[6]
+   VDDPI[7] VDDPI[8] VEDGE[0] VSS[0] VSS[1] VSS[2] VSS[3] VSS[4] VSS[5] VSS[6]
+   VSS[7] VSS[8] WBI[0] WBI[1] WBI[2] WBI[3] WBI[4] WBI[5] WBI[6] WBI[7] WTI[0]
+   WTI[1] WTI[2] WTI[3] WTI[4] WTI[5] WTI[6] WTI[7] SNPS_SP_HD_512x8_ref_lt
X_ref_cnt_rt_rwl ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1] ARYSD_IN[0]
+   ARYSD_IN[1] ARYSD_TOP[0] ARYSD_TOP[1] BB[32] BB[33] BB[34] BB[35] BB[36]
+   BB[37] BB[38] BB[39] BB[40] BB[41] BB[42] BB[43] CENDP DEF_MODE FAST1_MODE
+   FAST2_MODE FLOAT FLOATT FLOAT_RET FLOAT_RET_PROG LCGTH[0] LCGTH[1] LDFTX
+   LITESLP LLBKADRB[0] LLBKADRB[1] LLSB[0] LLSB[1] LMATCHB LMATCHB_I LOG0[0]
+   LOG0[0] LOG0[0] LOG0[1] LOG1[0] LOG1[1] LWEIB LXADR[0] LXADR[1] LXADR[2]
+   LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PLBKADR[0]
+   PLBKADR[1] QB[8] QB[9] QB[10] QT[8] QT[9] QT[10] RASSIST[0] RASSIST[1]
+   RASSIST[2] RASSIST[3] RASSISTBH[0] RASSISTBH[1] RASSISTBL[0] RASSISTBL[1]
+   RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC RWLD_RD
+   RWLD_WR RWL_DLY_0 RWL_DLY_2 RWL_DLY_4 RWL_DLY_RD_PGM RWL_DLY_WR_PGM RWLD_RD
+   RWL_RWLD_AND RWL_RWLD_AND_WR RWLD_WR SDB_BC1T[0] SDB_BC1T[1] SDB_BC2T[0]
+   SDB_BC2T[1] SDOR[0] SDOR[1] SDOR_RET[0] SDOR_RET[1] SEL[8] SEL[9] SEL[10]
+   T1T TEST_RNMB TOPEDGE[1] TOPEDGE[2] VBA[9] VBA[10] VBA[11] VBA[12] VBA[13]
+   VBN[9] VBN[10] VBN[11] VBN[12] VBN[13] VBN[14] VBP[9] VBP[10] VBP[11]
+   VBP[12] VBP[13] VBP[14] VDDA[0] VDDA[1] VDDA[2] VDDAIR1 VDDAIR1 VDDAIR1
+   VDDMINB VDDP[9] VDDP[10] VDDP[11] VDDP[12] VDDP[13] VDDP[14] VDDPI[9]
+   VDDPI[10] VDDPI[11] VDDPI[12] VDDPI[13] VDDPI[14] VDDWL[0] VDDWL[1] VSS[9]
+   VSS[10] VSS[11] VSS[12] VSS[13] VSS[14] VSSC_WL_L VSSC_WL_R WABUF[0]
+   WABUF[1] WABUF[2] WBI[8] WBI[9] WBI[10] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0]
+   WPBUF[1] WPBUF[2] WTI[8] WTI[9] WTI[10] SNPS_SP_HD_512x8_ref_cnt_rt_rwl
X_mm16a05_u_hdsp_plus_rrtar4x1_top VDDA[2] VDDAIR1 VDDP[15] VDDPI[15] VSS[15]
+   VBP[15] VBN[15] BB[44] BB[45] BB[46] BB[47] LOG0[1] LOG1[1] QB[11] QT[11]
+   RWLD_RD RWLD_WR RWLD_RD RWLD_WR SDOR[1] SDOR_RET[1] SEL[11] VBA[14] WBI[11]
+   WTI[11] LLSB[1] SDB_BC1T[1] SDB_BC2T[1] mm16a05_u_hdsp_plus_rar4x1
X_ref_rt_log0 BB[48] BB[49] BB[50] BB[51] BB[52] BB[53] BB[54] BB[55] BB[56]
+   BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] LLSB[1] LOG0[1] LOG1[1]
+   QB[12] QB[13] QB[14] QB[15] QT[12] QT[13] QT[14] QT[15] SDB_BC1T[1]
+   SDB_BC2T[1] SDOR[1] SDOR_RET[1] SEL[12] SEL[13] SEL[14] SEL[15] VBA[15]
+   VBA[16] VBA[17] VBA[18] VBN[16] VBN[17] VBN[18] VBN[19] VBP[16] VBP[17]
+   VBP[18] VBP[19] VDDA[2] VDDAIR1 VDDAIR1 VDDAIR1 VDDAIR1 VDDP[16] VDDP[17]
+   VDDP[18] VDDP[19] VDDPI[16] VDDPI[17] VDDPI[18] VDDPI[19] VSS[16] VSS[17]
+   VSS[18] VSS[19] WBI[12] WBI[13] WBI[14] WBI[15] WTI[12] WTI[13] WTI[14]
+   WTI[15] SNPS_SP_HD_512x8_ref_rt_log0
X_mm16a05_u_hdsp_plus_pg_pwedge_top VDDA[2] VDDP[20] VDDPI[20] VSS[20] VBP[20]
+   VBN[20] LOG0[1] LOG1[1] PGIOI[1] PO SDOR_RET[1] TOPEDGE[3] VBA[19] VEDGE[1]
+   SDOR[1] mm16a05_u_hdsp_plus_pg_pwedge
.ENDS
.SUBCKT SNPS_SP_HD_512x8_top ARYSD[2] ARYSD[3] ARYSD_BC1[0] ARYSD_BC1[1]
+       ARYSD_BC2[0] ARYSD_BC2[1] BC0 BC1 BC2 CENDP CLK D[0] D[1] D[2] D[3] D[4]
+       D[5] D[6] D[7] DEF_MODE DS FAST1_MODE FAST2_MODE FISO FLOAT FLOATT
+       FLOAT_RET FLOAT_RET_PROG LDFTX LITESLP LMATCHB LOG0 LOG1 LS LWEIB
+       LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7]
+       LYADR[0] LYADR[1] ME PWDO[0] PWDO[1] Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6]
+       Q[7] QB[16] QB[17] QB[18] QB[19] QB[20] QB[21] QB[22] QB[23] QB[24]
+       QB[25] QB[26] QB[27] QB[28] QB[29] QB[30] QB[31] QT[16] QT[17] QT[18]
+       QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28]
+       QT[29] QT[30] QT[31] RA[0] RA[1] RASSIST[0] RASSIST[1] RASSIST[2]
+       RASSIST[3] RM[0] RM[1] RM[2] RM[3] RM3CNT RME RMT[0] RMT[1] RMT[2]
+       RMT[3] ROP RWLB_SAC RWL_RWLD_AND RWL_RWLD_AND_WR SD SEL[0] SEL[1] SEL[2]
+       SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+       SEL[13] SEL[14] SEL[15] SO_D[0] SO_D[1] SO_Q[0] SO_Q[1] T1T TEST1
+       TEST_RNM TEST_RNMB TOPEDGE[0] TOPEDGE[1] TOPEDGE[2] TOPEDGE[3] VBA VBN
+       VBP VDDA VDDMINB VDDP VDDPI VEDGE[0] VEDGE[1] VSS WA[0] WA[1] WABUF[0]
+       WABUF[1] WABUF[2] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5]
+       WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12]
+       WB_IN[13] WB_IN[14] WB_IN[15] WE WEM[0] WEM[1] WEM[2] WEM[3] WEM[4]
+       WEM[5] WEM[6] WEM[7] WLH[0] WLH[1] WLH[2] WLH[3] WLH[4] WLH[5] WLH[6]
+       WLH[7] WLH[8] WLH[9] WLH[10] WLH[11] WLH[12] WLH[13] WLH[14] WLH[15]
+       WLH[16] WLH[17] WLH[18] WLH[19] WLH[20] WLH[21] WLH[22] WLH[23] WLH[24]
+       WLH[25] WLH[26] WLH[27] WLH[28] WLH[29] WLH[30] WLH[31] WLH[32] WLH[33]
+       WLH[34] WLH[35] WLH[36] WLH[37] WLH[38] WLH[39] WLH[40] WLH[41] WLH[42]
+       WLH[43] WLH[44] WLH[45] WLH[46] WLH[47] WLH[48] WLH[49] WLH[50] WLH[51]
+       WLH[52] WLH[53] WLH[54] WLH[55] WLH[56] WLH[57] WLH[58] WLH[59] WLH[60]
+       WLH[61] WLH[62] WLH[63] WLL[0] WLL[1] WLL[2] WLL[3] WLL[4] WLL[5] WLL[6]
+       WLL[7] WLL[8] WLL[9] WLL[10] WLL[11] WLL[12] WLL[13] WLL[14] WLL[15]
+       WLL[16] WLL[17] WLL[18] WLL[19] WLL[20] WLL[21] WLL[22] WLL[23] WLL[24]
+       WLL[25] WLL[26] WLL[27] WLL[28] WLL[29] WLL[30] WLL[31] WLL[32] WLL[33]
+       WLL[34] WLL[35] WLL[36] WLL[37] WLL[38] WLL[39] WLL[40] WLL[41] WLL[42]
+       WLL[43] WLL[44] WLL[45] WLL[46] WLL[47] WLL[48] WLL[49] WLL[50] WLL[51]
+       WLL[52] WLL[53] WLL[54] WLL[55] WLL[56] WLL[57] WLL[58] WLL[59] WLL[60]
+       WLL[61] WLL[62] WLL[63] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1]
+       WPBUF[2] WPULSE[0] WPULSE[1] WPULSE[2] WT_IN[0] WT_IN[1] WT_IN[2]
+       WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10]
+       WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15] XADR[0] XADR[1]
+       XADR[2] XADR[3] XADR[4] XADR[5] XADR[6] XADR[7] XBKADR[0] XBKADR[1]
+       XBKADR[2] YADR[0] YADR[1] YADR[2] YADR[3]

*** Jumper Report ***
* Jumper: LOG1 WEM[0] WEM[1] WEM[2] WEM[3] WEM[4] WEM[5] WEM[6] WEM[7]

*X_pin_row BC0 BC1 BC2 CLK D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] DS FISO LOG0
*+  LOG0 LOG0 LOG1 LOG1 LOG1 LS ME Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] QP[0]
*+  QP[1] QP[2] QP[3] QP[4] QP[5] QP[6] QP[7] RA[0] RA[1] RM[0] RM[1] RM[2]
*+  RM[3] RME ROP LOG0 LOG0 LOG0 LOG0 LOG0 SD SO_D[0] SO_D[1] SO_Q[0] SO_Q[1]
*+  TEST1 TEST_RNM VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBP VBP
*+  VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VDDP VDDP VDDP VDDP VDDP VDDP
*+  VDDP VDDP VDDP VDDP VDDP VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
*+  VDDPI VDDPI VDDPI VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS WA[0] WA[1] WE
*+  WEM[0] WEM[1] WEM[2] WEM[3] WEM[4] WEM[5] WEM[6] WEM[7] WPULSE[0] WPULSE[1]
*+  WPULSE[2] XADR[0] XADR[1] XADR[2] XADR[3] XADR[4] XADR[5] XADR[6] XADR[7]
*+  XBKADR[0] XBKADR[1] XBKADR[2] YADR[0] YADR[1] YADR[2] YADR[3]
*+  SNPS_SP_HD_512x8_pin_row
X_gio_row ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1]
+   BC0 BC1 BC2 CB[0] CB[1] CB[2] CB[3] CB[4] CB[5] CB[6] CB[7] CENDP CLK CLKB
+   CLKDEL CLKDEL CLKB CT[0] CT[1] CT[2] CT[3] CT[4] CT[5] CT[6] CT[7] D[0] D[1]
+   D[2] D[3] D[4] D[5] D[6] D[7] DEF1 DEF12B_PROG DEF12_PROG DEF1B DEF12_PROG
+   DEF12B_PROG DEF_MODE DEF1 LOG0 DIB[0] DIB[1] DIB[2] DIB[3] DIB[4] DIB[5]
+   DIB[6] DIB[7] DINB[0] DINB[1] DINB[2] DINB[3] DINB[4] DINB[5] DINB[6]
+   DINB[7] DISCHG LOG1 LOG1 LOG0 DINB[0] DINB[1] DINB[2] DINB[3] DINB[4]
+   DINB[5] DINB[6] DINB[7] FAST1_MODE FAST2_MODE FISO FLOAT FLOATT FLOAT_RET
+   LOG1 LOG1 LOG0 LOG0 IV_SEL[0] IV_SEL[1] IV_SEL[2] IV_SEL[3] IV_SEL[4]
+   IV_SEL[5] IV_SEL[6] IV_SEL[7] IV_SEL[8] IV_SEL[9] IV_SEL[10] IV_SEL[11]
+   IV_SEL[12] IV_SEL[13] IV_SEL[14] IV_SEL[15] IV_WB[0] IV_WB[1] IV_WB[2]
+   IV_WB[3] IV_WB[4] IV_WB[5] IV_WB[6] IV_WB[7] IV_WB[8] IV_WB[9] IV_WB[10]
+   IV_WB[11] IV_WB[12] IV_WB[13] IV_WB[14] IV_WB[15] IV_WT[0] IV_WT[1] IV_WT[2]
+   IV_WT[3] IV_WT[4] IV_WT[5] IV_WT[6] IV_WT[7] IV_WT[8] IV_WT[9] IV_WT[10]
+   IV_WT[11] IV_WT[12] IV_WT[13] IV_WT[14] IV_WT[15] LBKADR0 LBKADR1 LBKADR2
+   LCLKB LCLKT LDFTX LOG0 LOG0 LDIB[0] LDIB[1] LDIB[2] LDIB[3] LDIB[4] LDIB[5]
+   LDIB[6] LDIB[7] LITESLP LME LOG0 LOG1 LOG1_RM LQB[0] LQB[1] LQB[2] LQB[3]
+   LQB[4] LQB[5] LQB[6] LQB[7] LS LWE LWEIB LWIB[0] LWIB[1] LWIB[2] LWIB[3]
+   LWIB[4] LWIB[5] LWIB[6] LWIB[7] LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4]
+   LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] LY_ONE LY_TWO MCLKB MCLKT ME
+   MEB_I MEB_I MEORDFTCLKEN LOG1 IV_SEL[0] IV_SEL[1] IV_SEL[2] IV_SEL[3]
+   IV_SEL[4] IV_SEL[5] IV_SEL[6] IV_SEL[7] IV_SEL[8] IV_SEL[9] IV_SEL[10]
+   IV_SEL[11] IV_SEL[12] IV_SEL[13] IV_SEL[14] IV_SEL[15] IV_WB[0] IV_WB[1]
+   IV_WB[2] IV_WB[3] IV_WB[4] IV_WB[5] IV_WB[6] IV_WB[7] IV_WB[8] IV_WB[9]
+   IV_WB[10] IV_WB[11] IV_WB[12] IV_WB[13] IV_WB[14] IV_WB[15] IV_WT[0]
+   IV_WT[1] IV_WT[2] IV_WT[3] IV_WT[4] IV_WT[5] IV_WT[6] IV_WT[7] IV_WT[8]
+   IV_WT[9] IV_WT[10] IV_WT[11] IV_WT[12] IV_WT[13] IV_WT[14] IV_WT[15] PWDO[0]
+   PWDO[1] Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] QB[0] QB[1] QB[2] QB[3]
+   QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14]
+   QB[15] QT[0] QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10]
+   QT[11] QT[12] QT[13] QT[14] QT[15] RA[0] RA[1] RASSIST[0] RASSIST[1]
+   RASSIST[2] RASSIST[3] RM[0] RM[1] RM[2] RM[3] RM3CNT VBA VBA VBA LOG1_RM
+   LOG1_RM VBA LOG1_RM LOG1_RM RME LOG1 LOG1 LOG0 LOG1_RM LOG1_RM LOG1_RM
+   LOG1_RM RMT[0] RMT[1] RMT[2] RMT[3] LOG0 LOG0 LOG0 LOG0 LOG0 RWLCKB SD
+   SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9]
+   SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] LOG0 T1T TEST1 TEST_RNM
+   TEST_RNMB VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VDDA VDDA VDDA VDDMINB VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI_DR VDDPI_DR VDDPI_DR VDDPI_DR VDDPI_DR
+   VDDPI_DR VDDPI_DR VDDPI_DR VEDGE[0] VEDGE[1] VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS WA[0] WA[1] WABUF[0] WABUF[1] WABUF[2] WB_IN[0] WB_IN[1]
+   WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9]
+   WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WE WEM[0] WEM[1]
+   WEM[2] WEM[3] WEM[4] WEM[5] WEM[6] WEM[7] WEMB[0] WEMB[1] WEMB[2] WEMB[3]
+   WEMB[4] WEMB[5] WEMB[6] WEMB[7] WEMB[0] WEMB[1] WEMB[2] WEMB[3] WEMB[4]
+   WEMB[5] WEMB[6] WEMB[7] WFLOAT LOG1_RM LOG1_RM LOG1_RM VBA VBA VBA LOG1_RM
+   LOG1_RM LOG1_RM VBA LOG1_RM LOG1_RM WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0]
+   WPBUF[1] WPBUF[2] WPULSE[0] WPULSE[1] WPULSE[2] WT_IN[0] WT_IN[1] WT_IN[2]
+   WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10]
+   WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15] XADR[0] XADR[1] XADR[2]
+   XADR[3] XADR[4] XADR[5] XADR[6] XADR[7] XBKADR[0] XBKADR[1] XBKADR[2]
+   YADR[0] YADR[1] YADR[2] YADR[3] SNPS_SP_HD_512x8_gio_row
X_sacwa_row ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+   ARYSD_BC2[1] CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET
+   LBKADR0 LBKADR1 LBKADR2 LCGTH[0] LCGTH[1] LCGTH_PCHG LDFTX LITESLP LMATCHB
+   LOG0 LOG0 LOG0 LOG1 LOG1 LOG1 LWEIB LWERD LWEWR LXADR[0] LXADR[1] LXADR[2]
+   LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PM[0] PM[1]
+   PM[2] PM[3] PRCKE_B PWDO[0] PWDO[1] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5]
+   QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QT[0]
+   QT[1] QT[2] QT[3] QT[4] QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12]
+   QT[13] QT[14] QT[15] RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RB[0] RB[1]
+   RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10] RB[11] RB[12] RB[13]
+   RB[14] RB[15] RBLWA RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RT[0] RT[1] RT[2]
+   RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10] RT[11] RT[12] RT[13] RT[14]
+   RT[15] SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9]
+   SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] T1T TEST_RNMB VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VDDA VDDA VDDA VDDMINB VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VEDGE[0] VEDGE[1] VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS_WA[0]
+   VSS_WA[1] VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7]
+   VSS_WA[8] VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12] VSS_WA[13] VSS_WA[14]
+   VSS_WA[15] WABUF[0] WABUF[1] WABUF[2] WAPRCLKBUFB_RET WB[0] WB[1] WB[2]
+   WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14]
+   WB[15] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6]
+   WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14]
+   WB_IN[15] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT[0] WT[1]
+   WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13]
+   WT[14] WT[15] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6]
+   WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14]
+   WT_IN[15] SNPS_SP_HD_512x8_sacwa_row
X_sac_row_1 ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+   ARYSD_BC2[1] BYP_VLOAD CENDP DEF_MODE LOG0 FAST1B FAST1_MODE FAST2_MODE
+   FLOAT FLOATT LOG1 FLOAT_RET FLOAT_RET LCGTH[0] LCGTH[1] LCGTH_PCHG LDFTX
+   LITESLP LLBKADRB[0] LLBKADRB[1] LLBKADRB[2] LLBKADRT[0] LLBKADRT[1]
+   LLBKADRT[2] LMATCH[0] LMATCHB LOG1 LOG1 LOG0 LOG1 LWEIB LWERD LWEWR LXADR[0]
+   LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0]
+   LYADR[1] LLBKADRB[0] LLBKADRB[1] LLBKADRB[2] LLBKADRB[0] PM[0] PM[1] PM[2]
+   PM[3] PRCKE_B PRCKE_T FLOAT_RET PWDO[0] PWDO[1] QB[0] QB[1] QB[2] QB[3]
+   QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14]
+   QB[15] QB[16] QB[17] QB[18] QB[19] QB[20] QB[21] QB[22] QB[23] QB[24] QB[25]
+   QB[26] QB[27] QB[28] QB[29] QB[30] QB[31] LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0
+   LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 QT[0] QT[1] QT[2] QT[3] QT[4]
+   QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15]
+   QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26]
+   QT[27] QT[28] QT[29] QT[30] QT[31] LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0
+   LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 LOG0 RASSIST[0] RASSIST[1] RASSIST[2]
+   RASSIST[3] RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9]
+   RB[10] RB[11] RB[12] RB[13] RB[14] RB[15] RBLRD RBLWA RBLWR RM3CNT RMT[0]
+   RMT[1] RMT[2] RMT[3] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8]
+   RT[9] RT[10] RT[11] RT[12] RT[13] RT[14] RT[15] RWLB_SAC SEL[0] SEL[1]
+   SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11]
+   SEL[12] SEL[13] SEL[14] SEL[15] T1T TEST_RNMB VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VDDA VDDA
+   VDDA VDDMINB VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VEDGE[0] VEDGE[1] VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS_WA[0] VSS_WA[1]
+   VSS_WA[2] VSS_WA[3] VSS_WA[4] VSS_WA[5] VSS_WA[6] VSS_WA[7] VSS_WA[8]
+   VSS_WA[9] VSS_WA[10] VSS_WA[11] VSS_WA[12] VSS_WA[13] VSS_WA[14] VSS_WA[15]
+   WABUF[0] WABUF[1] WABUF[2] WAPRCLKBUFB_RET WB[0] WB[1] WB[2] WB[3] WB[4]
+   WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13] WB[14] WB[15]
+   WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7]
+   WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14]
+   WB_IN[15] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT[0] WT[1]
+   WT[2] WT[3] WT[4] WT[5] WT[6] WT[7] WT[8] WT[9] WT[10] WT[11] WT[12] WT[13]
+   WT[14] WT[15] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6]
+   WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14]
+   WT_IN[15] SNPS_SP_HD_512x8_sac_row_1
X_mux_row_1 ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+   ARYSD_BC2[1] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9]
+   BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20]
+   BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31]
+   BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42]
+   BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53]
+   BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63]
+   BOTEDGE[0] BOTEDGE[1] BOTEDGE[2] BOTEDGE[3] BT[0] BT[1] BT[2] BT[3] BT[4]
+   BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12] BT[13] BT[14] BT[15]
+   BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23] BT[24] BT[25] BT[26]
+   BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34] BT[35] BT[36] BT[37]
+   BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45] BT[46] BT[47] BT[48]
+   BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56] BT[57] BT[58] BT[59]
+   BT[60] BT[61] BT[62] BT[63] BYP_VLOAD CENDP DEF_MODE FAST1_MODE FAST2_MODE
+   FLOAT FLOATT FLOAT_RET LCGTH[0] LCGTH[1] LCGTH_PCHG LDFTX LITESLP LMATCH[1]
+   LMATCHB LOG0 LOG1 LWEIB LWERD LWEWR LXADR[0] LXADR[1] LXADR[2] LXADR[3]
+   LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] B PBB[1] PBB[2] PBB[3]
+   PBB[4] PBB[5] PBB[6] PBB[7] C PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6]
+   PCB[7] PWDO[0] PWDO[1] PM[0] PM[1] PM[2] PM[3] PRCKE_T QB[16] QB[17] QB[18]
+   QB[19] QB[20] QB[21] QB[22] QB[23] QB[24] QB[25] QB[26] QB[27] QB[28] QB[29]
+   QB[30] QB[31] QT[16] QT[17] QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24]
+   QT[25] QT[26] QT[27] QT[28] QT[29] QT[30] QT[31] RASSIST[0] RASSIST[1]
+   RASSIST[2] RASSIST[3] RASSISTBH[0] RASSISTBH[1] RASSISTBL[0] RASSISTBL[1]
+   RB[0] RB[1] RB[2] RB[3] RB[4] RB[5] RB[6] RB[7] RB[8] RB[9] RB[10] RB[11]
+   RB[12] RB[13] RB[14] RB[15] RBLRD RBLWA RBLWR RM3CNT RMT[0] RMT[1] RMT[2]
+   RMT[3] RT[0] RT[1] RT[2] RT[3] RT[4] RT[5] RT[6] RT[7] RT[8] RT[9] RT[10]
+   RT[11] RT[12] RT[13] RT[14] RT[15] RWLB_SAC SEL[0] SEL[1] SEL[2] SEL[3]
+   SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13]
+   SEL[14] SEL[15] T1T TEST_RNMB VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA
+   VBA VBA VBA VBA VBA VBA VBA VBA VBA VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA VDDA
+   VDDA VDDAIL1 VDDAIR1 VDDMINB VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDWL[0] VDDWL[1] VEDGE[0]
+   VEDGE[1] VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSSC_WL_L VSSC_WL_R WABUF[0] WABUF[1] WABUF[2] WB[0] WB[1]
+   WB[2] WB[3] WB[4] WB[5] WB[6] WB[7] WB[8] WB[9] WB[10] WB[11] WB[12] WB[13]
+   WB[14] WB[15] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6]
+   WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14]
+   WB_IN[15] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3] WMT[0] WMT[1] WMT[2] WMT[3]
+   WPBUF[0] WPBUF[1] WPBUF[2] WT[0] WT[1] WT[2] WT[3] WT[4] WT[5] WT[6] WT[7]
+   WT[8] WT[9] WT[10] WT[11] WT[12] WT[13] WT[14] WT[15] WT_IN[0] WT_IN[1]
+   WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9]
+   WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15]
+   SNPS_SP_HD_512x8_mux_row_1
X_ary_row_1 ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0]
+   ARYSD_BC2[1] B BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7] BB[8] BB[9]
+   BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18] BB[19] BB[20]
+   BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29] BB[30] BB[31]
+   BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40] BB[41] BB[42]
+   BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51] BB[52] BB[53]
+   BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62] BB[63] BT[0]
+   BT[1] BT[2] BT[3] BT[4] BT[5] BT[6] BT[7] BT[8] BT[9] BT[10] BT[11] BT[12]
+   BT[13] BT[14] BT[15] BT[16] BT[17] BT[18] BT[19] BT[20] BT[21] BT[22] BT[23]
+   BT[24] BT[25] BT[26] BT[27] BT[28] BT[29] BT[30] BT[31] BT[32] BT[33] BT[34]
+   BT[35] BT[36] BT[37] BT[38] BT[39] BT[40] BT[41] BT[42] BT[43] BT[44] BT[45]
+   BT[46] BT[47] BT[48] BT[49] BT[50] BT[51] BT[52] BT[53] BT[54] BT[55] BT[56]
+   BT[57] BT[58] BT[59] BT[60] BT[61] BT[62] BT[63] BYP_VLOAD C CENDP DEF_MODE
+   EDGEB[0] EDGEB[1] EDGEB[2] EDGEB[3] EDGET[0] EDGET[1] EDGET[2] EDGET[3]
+   FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET LCGTH[0] LCGTH[1] LDFTX LITESLP
+   LMATCH[1] LMATCHB LOG0 LOG1 LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3]
+   LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] B PBB[1] PBB[2] PBB[3]
+   PBB[4] PBB[5] PBB[6] PBB[7] C PCB[1] PCB[2] PCB[3] PCB[4] PCB[5] PCB[6]
+   PCB[7] PWDO[0] PWDO[1] QB[16] QB[17] QB[18] QB[19] QB[20] QB[21] QB[22]
+   QB[23] QB[24] QB[25] QB[26] QB[27] QB[28] QB[29] QB[30] QB[31] QT[16] QT[17]
+   QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28]
+   QT[29] QT[30] QT[31] RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3]
+   RASSISTBH[0] RASSISTBH[1] RASSISTBL[0] RASSISTBL[1] RBLRD RBLWA RBLWR
+   RBLWR_LOAD RM3CNT RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC SEL[0] SEL[1] SEL[2]
+   SEL[3] SEL[4] SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12]
+   SEL[13] SEL[14] SEL[15] T1T TEST_RNMB VBA VBN VBP VDDA VDDAIL1 VDDAIR1
+   VDDMINB VDDP VDDPI VDDWL[0] VDDWL[1] VEDGE[0] VEDGE[1] VSS VSSC_WL_L
+   VSSC_WL_R WABUF[0] WABUF[1] WABUF[2] WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3]
+   WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11]
+   WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WCLKB[0] WCLKB[1] WCLKB[2] WCLKB[3]
+   WLH[0] WLH[1] WLH[2] WLH[3] WLH[4] WLH[5] WLH[6] WLH[7] WLH[8] WLH[9]
+   WLH[10] WLH[11] WLH[12] WLH[13] WLH[14] WLH[15] WLH[16] WLH[17] WLH[18]
+   WLH[19] WLH[20] WLH[21] WLH[22] WLH[23] WLH[24] WLH[25] WLH[26] WLH[27]
+   WLH[28] WLH[29] WLH[30] WLH[31] WLH[32] WLH[33] WLH[34] WLH[35] WLH[36]
+   WLH[37] WLH[38] WLH[39] WLH[40] WLH[41] WLH[42] WLH[43] WLH[44] WLH[45]
+   WLH[46] WLH[47] WLH[48] WLH[49] WLH[50] WLH[51] WLH[52] WLH[53] WLH[54]
+   WLH[55] WLH[56] WLH[57] WLH[58] WLH[59] WLH[60] WLH[61] WLH[62] WLH[63]
+   WLL[0] WLL[1] WLL[2] WLL[3] WLL[4] WLL[5] WLL[6] WLL[7] WLL[8] WLL[9]
+   WLL[10] WLL[11] WLL[12] WLL[13] WLL[14] WLL[15] WLL[16] WLL[17] WLL[18]
+   WLL[19] WLL[20] WLL[21] WLL[22] WLL[23] WLL[24] WLL[25] WLL[26] WLL[27]
+   WLL[28] WLL[29] WLL[30] WLL[31] WLL[32] WLL[33] WLL[34] WLL[35] WLL[36]
+   WLL[37] WLL[38] WLL[39] WLL[40] WLL[41] WLL[42] WLL[43] WLL[44] WLL[45]
+   WLL[46] WLL[47] WLL[48] WLL[49] WLL[50] WLL[51] WLL[52] WLL[53] WLL[54]
+   WLL[55] WLL[56] WLL[57] WLL[58] WLL[59] WLL[60] WLL[61] WLL[62] WLL[63]
+   WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT_IN[0] WT_IN[1]
+   WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9]
+   WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15]
+   SNPS_SP_HD_512x8_ary_row_1
X_ref_row_1 ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1] ARYSD[0]
+   ARYSD[1] ARYSD[2] ARYSD[3] BB[0] BB[1] BB[2] BB[3] BB[4] BB[5] BB[6] BB[7]
+   BB[8] BB[9] BB[10] BB[11] BB[12] BB[13] BB[14] BB[15] BB[16] BB[17] BB[18]
+   BB[19] BB[20] BB[21] BB[22] BB[23] BB[24] BB[25] BB[26] BB[27] BB[28] BB[29]
+   BB[30] BB[31] BB[32] BB[33] BB[34] BB[35] BB[36] BB[37] BB[38] BB[39] BB[40]
+   BB[41] BB[42] BB[43] BB[44] BB[45] BB[46] BB[47] BB[48] BB[49] BB[50] BB[51]
+   BB[52] BB[53] BB[54] BB[55] BB[56] BB[57] BB[58] BB[59] BB[60] BB[61] BB[62]
+   BB[63] CENDP DEF_MODE FAST1_MODE FAST2_MODE FLOAT FLOATT FLOAT_RET
+   FLOAT_RET_PROG LCGTH[0] LCGTH[1] LDFTX LITESLP LLBKADRB[3] LLBKADRB[4]
+   LMATCHB LOG1 LOG0 LOG0 LOG1 LOG1 LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3]
+   LXADR[4] LXADR[5] LXADR[6] LXADR[7] LYADR[0] LYADR[1] PWDO[0] PWDO[1]
+   LLBKADRB[3] LLBKADRB[4] QB[16] QB[17] QB[18] QB[19] QB[20] QB[21] QB[22]
+   QB[23] QB[24] QB[25] QB[26] QB[27] QB[28] QB[29] QB[30] QB[31] QT[16] QT[17]
+   QT[18] QT[19] QT[20] QT[21] QT[22] QT[23] QT[24] QT[25] QT[26] QT[27] QT[28]
+   QT[29] QT[30] QT[31] RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3]
+   RASSISTBH[0] RASSISTBH[1] RASSISTBL[0] RASSISTBL[1] RBLRD RBLWA RBLWR RM3CNT
+   RMT[0] RMT[1] RMT[2] RMT[3] RWLB_SAC RWL_DLY_0 RWL_DLY_2 RWL_DLY_4 RWL_DLY_0
+   RWL_DLY_0 RWL_RWLD_AND RWL_RWLD_AND_WR SEL[0] SEL[1] SEL[2] SEL[3] SEL[4]
+   SEL[5] SEL[6] SEL[7] SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14]
+   SEL[15] T1T TEST_RNMB TOPEDGE[0] TOPEDGE[1] TOPEDGE[2] TOPEDGE[3] VBA VBA
+   VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBA VBN
+   VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN VBN
+   VBN VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP VBP
+   VBP VBP VBP VDDA VDDA VDDA VDDAIL1 VDDAIR1 VDDMINB VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP VDDP
+   VDDP VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI
+   VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDPI VDDWL[0] VDDWL[1]
+   VEDGE[0] VEDGE[1] VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+   VSS VSS VSS VSS VSS VSS VSS VSSC_WL_L VSSC_WL_R WABUF[0] WABUF[1] WABUF[2]
+   WB_IN[0] WB_IN[1] WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7]
+   WB_IN[8] WB_IN[9] WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14]
+   WB_IN[15] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2] WT_IN[0]
+   WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4] WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8]
+   WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12] WT_IN[13] WT_IN[14] WT_IN[15]
+   SNPS_SP_HD_512x8_ref_row_1
.ENDS
.SUBCKT SNPS_SP_HD_512x8_TOP_LAY ADR[0] ADR[1] ADR[2] ADR[4] ADR[5] ADR[9]
+       ADR[10] ADR[11] ADR[12] BC0 BC1 BC2 CLK D[0] D[1] D[2] D[3] D[4] D[5]
+       D[6] D[7] LS ME Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] RM[0] RM[1]
+       RM[2] RM[3] RME TEST1 TEST_RNM VDD[0] VNW_N VPW_P VSS WA[0] WA[1] WE
+       WPULSE[0] WPULSE[1] WPULSE[2]
X_top ARYSD[0] ARYSD[1] ARYSD_BC1[0] ARYSD_BC1[1] ARYSD_BC2[0] ARYSD_BC2[1] BC0
+   BC1 BC2 LOG0 CLK D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] DEF_MODE DS
+   FAST1_MODE FAST2_MODE LOG0 FLOAT FLOATT FLOAT_RET LOG1 LOG0 LITESLP LOG1
+   LOG0 LOG1 LS LWEIB LXADR[0] LXADR[1] LXADR[2] LXADR[3] LXADR[4] LXADR[5]
+   LXADR[6] LXADR[7] LYADR[0] LYADR[1] ME LOG1 LOG1 Q[0] Q[1] Q[2] Q[3] Q[4]
+   Q[5] Q[6] Q[7] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9]
+   QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QT[0] QT[1] QT[2] QT[3] QT[4]
+   QT[5] QT[6] QT[7] QT[8] QT[9] QT[10] QT[11] QT[12] QT[13] QT[14] QT[15] LOG0
+   LOG0 RASSIST[0] RASSIST[1] RASSIST[2] RASSIST[3] RM[0] RM[1] RM[2] RM[3]
+   RM3CNT RME RMT[0] RMT[1] RMT[2] RMT[3] ROP RWLB_SAC RWL_RWLD_AND
+   RWL_RWLD_AND_WR LOG0 SEL[0] SEL[1] SEL[2] SEL[3] SEL[4] SEL[5] SEL[6] SEL[7]
+   SEL[8] SEL[9] SEL[10] SEL[11] SEL[12] SEL[13] SEL[14] SEL[15] SO_D[0]
+   SO_D[1] SO_Q[0] SO_Q[1] T1T TEST1 TEST_RNM TEST_RNMB TOPEDGE[0] TOPEDGE[1]
+   TOPEDGE[2] TOPEDGE[3] VSS VNW_N VPW_P VDD[0] VDDMINB VDD[0] VDD[0] VEDGE[0]
+   VEDGE[1] VSS WA[0] WA[1] WABUF[0] WABUF[1] WABUF[2] WB_IN[0] WB_IN[1]
+   WB_IN[2] WB_IN[3] WB_IN[4] WB_IN[5] WB_IN[6] WB_IN[7] WB_IN[8] WB_IN[9]
+   WB_IN[10] WB_IN[11] WB_IN[12] WB_IN[13] WB_IN[14] WB_IN[15] WE LOG1 LOG1
+   LOG1 LOG1 LOG1 LOG1 LOG1 LOG1 WLH[0] WLH[1] WLH[2] WLH[3] WLH[4] WLH[5]
+   WLH[6] WLH[7] WLH[8] WLH[9] WLH[10] WLH[11] WLH[12] WLH[13] WLH[14] WLH[15]
+   WLH[16] WLH[17] WLH[18] WLH[19] WLH[20] WLH[21] WLH[22] WLH[23] WLH[24]
+   WLH[25] WLH[26] WLH[27] WLH[28] WLH[29] WLH[30] WLH[31] WLH[32] WLH[33]
+   WLH[34] WLH[35] WLH[36] WLH[37] WLH[38] WLH[39] WLH[40] WLH[41] WLH[42]
+   WLH[43] WLH[44] WLH[45] WLH[46] WLH[47] WLH[48] WLH[49] WLH[50] WLH[51]
+   WLH[52] WLH[53] WLH[54] WLH[55] WLH[56] WLH[57] WLH[58] WLH[59] WLH[60]
+   WLH[61] WLH[62] WLH[63] WLL[0] WLL[1] WLL[2] WLL[3] WLL[4] WLL[5] WLL[6]
+   WLL[7] WLL[8] WLL[9] WLL[10] WLL[11] WLL[12] WLL[13] WLL[14] WLL[15] WLL[16]
+   WLL[17] WLL[18] WLL[19] WLL[20] WLL[21] WLL[22] WLL[23] WLL[24] WLL[25]
+   WLL[26] WLL[27] WLL[28] WLL[29] WLL[30] WLL[31] WLL[32] WLL[33] WLL[34]
+   WLL[35] WLL[36] WLL[37] WLL[38] WLL[39] WLL[40] WLL[41] WLL[42] WLL[43]
+   WLL[44] WLL[45] WLL[46] WLL[47] WLL[48] WLL[49] WLL[50] WLL[51] WLL[52]
+   WLL[53] WLL[54] WLL[55] WLL[56] WLL[57] WLL[58] WLL[59] WLL[60] WLL[61]
+   WLL[62] WLL[63] WMT[0] WMT[1] WMT[2] WMT[3] WPBUF[0] WPBUF[1] WPBUF[2]
+   WPULSE[0] WPULSE[1] WPULSE[2] WT_IN[0] WT_IN[1] WT_IN[2] WT_IN[3] WT_IN[4]
+   WT_IN[5] WT_IN[6] WT_IN[7] WT_IN[8] WT_IN[9] WT_IN[10] WT_IN[11] WT_IN[12]
+   WT_IN[13] WT_IN[14] WT_IN[15] ADR[4] ADR[5] ADR[9] ADR[10] ADR[11] ADR[12]
+   LOG0 LOG0 LOG0 LOG0 LOG0 ADR[0] ADR[1] ADR[2] LOG0 SNPS_SP_HD_512x8_top
.ENDS
.SUBCKT SNPS_SP_HD_512x8 ADR[0] ADR[1] ADR[2] ADR[3] ADR[4] ADR[5] ADR[6] ADR[7]
+       ADR[8] BC0 BC1 BC2 CLK D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] LS ME
+       Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] RM[0] RM[1] RM[2] RM[3] RME
+       TEST1 TEST_RNM VDD VNW_N VPW_P VSS WA[0] WA[1] WE WPULSE[0] WPULSE[1]
+       WPULSE[2]
X_TOP_LAY ADR[0] ADR[1] ADR[2] ADR[3] ADR[4] ADR[5] ADR[6] ADR[7] ADR[8] BC0 BC1
+   BC2 CLK D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] LS ME Q[0] Q[1] Q[2] Q[3]
+   Q[4] Q[5] Q[6] Q[7] RM[0] RM[1] RM[2] RM[3] RME TEST1 TEST_RNM VDD VNW_N
+   VPW_P VSS WA[0] WA[1] WE WPULSE[0] WPULSE[1] WPULSE[2]
+   SNPS_SP_HD_512x8_TOP_LAY
 Xvpw_p_h VPW_P vassert_hi vmax=0
 Xvpw_p_l VPW_P vassert_lo vmin=-1.5
 Xvnw_n_l VNW_N vassert_lo vmin=0
 Xvnw_n_h VNW_N vassert_hi vmax=1.2
 Xvss_h VSS vassert_hi vmax=0
 Xvss_l VSS vassert_lo vmin=0
 Xvdd_h VDD vassert_hi vmax=0.9
 Xvdd_l VDD vassert_lo vmin=0.45
.ENDS
